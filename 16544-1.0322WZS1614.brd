# Allegro board 16544-1.0322WZS1614.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1401M40H102
  round 0.5 smd: A2(-17.7,18.7) A3(-16.7,18.7) A5(-15,18.7) A6(-13.8,18.7) A8(-12.6,18.7) A9(-11.4,18.7) A11(-10.2,18.7) A12(-9,18.7) A14(-7.8,18.7) A15(-6.6,18.7) A17(-5.4,18.7) A18(-4.2,18.7) A19(-3,18.7) A20(-1.8,18.7) A21(-0.6,18.7) A23(0.6,18.7) A24(1.8,18.7) A25(3,18.7) A26(4.2,18.7) A27(5.4,18.7) A29(6.6,18.7) A30(7.8,18.7) A32(9,18.7) A33(10.2,18.7) A35(11.4,18.7) A36(12.6,18.7) A38(13.8,18.7) A39(15,18.7) A41(16.7,18.7) A42(17.7,18.7) AA1(-18.7,0.6) AA2(-17.8,0.6) AA3(-16.9,0.6) AA4(-16,0.6) AA5(-15.1,0.6) AA6(-14.2,0.6) AA7(-13.4,0.6) AA8(-12.6,0.6) AA9(-11.8,0.6) AA10(-11,0.6) AA11(-10.2,0.6) AA12(-9.4,0.6) AA13(-8.6,0.6) AA14(-7.8,0.6) AA15(-7,1) AA16(-6,1) AA17(-5,1) AA18(-4,1) AA19(-3,1) AA20(-2,1) AA21(-1,1) AA22(0,1) AA23(1,1) AA24(2,1) AA25(3,1) AA26(4,1) AA27(5,1) AA28(6,1) AA29(7,1) AA30(7.8,0.6) AA31(8.6,0.6) AA32(9.4,0.6) AA33(10.2,0.6) AA34(11,0.6) AA35(11.8,0.6) AA36(12.6,0.6) AA37(13.4,0.6) AA38(14.2,0.6) AA39(15.1,0.6) AA40(16,0.6) AA41(16.9,0.6) AA42(17.8,0.6) AA43(18.7,0.6) AB15(-7,0) AB16(-6,0) AB17(-5,0) AB18(-4,0) AB19(-3,0) AB20(-2,0) AB21(-1,0) AB22(0,0) AB23(1,0) AB24(2,0) AB25(3,0) AB26(4,0) AB27(5,0) AB28(6,0) AB29(7,0) AC1(-18.7,-0.6) AC2(-17.8,-0.6) AC3(-16.9,-0.6) AC4(-16,-0.6) AC5(-15.1,-0.6) AC6(-14.2,-0.6) AC7(-13.4,-0.6) AC8(-12.6,-0.6) AC9(-11.8,-0.6) AC10(-11,-0.6) AC11(-10.2,-0.6) AC12(-9.4,-0.6) AC13(-8.6,-0.6) AC14(-7.8,-0.6) AC15(-7,-1) AC16(-6,-1) AC17(-5,-1) AC18(-4,-1) AC19(-3,-1) AC20(-2,-1) AC21(-1,-1) AC22(0,-1) AC23(1,-1) AC24(2,-1) AC25(3,-1) AC26(4,-1) AC27(5,-1) AC28(6,-1) AC29(7,-1) AC30(7.8,-0.6) AC31(8.6,-0.6) AC32(9.4,-0.6) AC33(10.2,-0.6) AC34(11,-0.6) AC35(11.8,-0.6) AC36(12.6,-0.6) AC37(13.4,-0.6) AC38(14.2,-0.6) AC39(15.1,-0.6) AC40(16,-0.6) AC41(16.9,-0.6) AC42(17.8,-0.6) AC43(18.7,-0.6) AD1(-18.7,-1.8) AD2(-17.8,-1.8) AD3(-16.9,-1.8) AD4(-16,-1.8) AD5(-15.1,-1.8) AD6(-14.2,-1.8) AD7(-13.4,-1.8) AD8(-12.6,-1.8) AD9(-11.8,-1.8) AD10(-11,-1.8) AD11(-10.2,-1.8) AD12(-9.4,-1.8) AD13(-8.6,-1.8) AD14(-7.8,-1.8) AD15(-7,-2) AD16(-6,-2) AD17(-5,-2) AD18(-4,-2) AD19(-3,-2) AD20(-2,-2) AD21(-1,-2) AD22(0,-2) AD23(1,-2) AD24(2,-2) AD25(3,-2) AD26(4,-2) AD27(5,-2) AD28(6,-2) AD29(7,-2) AD30(7.8,-1.8) AD31(8.6,-1.8) AD32(9.4,-1.8) AD33(10.2,-1.8) AD34(11,-1.8) AD35(11.8,-1.8) AD36(12.6,-1.8) AD37(13.4,-1.8) AD38(14.2,-1.8) AD39(15.1,-1.8) AD40(16,-1.8) AD41(16.9,-1.8) AD42(17.8,-1.8) AD43(18.7,-1.8) AE1(-18.7,-3) AE2(-17.8,-3) AE3(-16.9,-3) AE4(-16,-3) AE5(-15.1,-3) AE6(-14.2,-3) AE7(-13.4,-3) AE8(-12.6,-3) AE9(-11.8,-3) AE10(-11,-3) AE11(-10.2,-3) AE12(-9.4,-3) AE13(-8.6,-3) AE14(-7.8,-3) AE15(-7,-3) AE16(-6,-3) AE17(-5,-3) AE18(-4,-3) AE19(-3,-3) AE20(-2,-3) AE21(-1,-3) AE22(0,-3) AE23(1,-3) AE24(2,-3) AE25(3,-3) AE26(4,-3) AE27(5,-3) AE28(6,-3) AE29(7,-3) AE30(7.8,-3) AE31(8.6,-3) AE32(9.4,-3) AE33(10.2,-3) AE34(11,-3) AE35(11.8,-3) AE36(12.6,-3) AE37(13.4,-3) AE38(14.2,-3) AE39(15.1,-3) AE40(16,-3) AE41(16.9,-3) AE42(17.8,-3) AE43(18.7,-3) AF1(-18.7,-4.2) AF2(-17.8,-4.2) AF3(-16.9,-4.2) AF4(-16,-4.2) AF5(-15.1,-4.2) AF6(-14.2,-4.2) AF7(-13.4,-4.2) AF8(-12.6,-4.2) AF9(-11.8,-4.2) AF10(-11,-4.2) AF11(-10.2,-4.2) AF12(-9.4,-4.2) AF13(-8.6,-4.2) AF14(-7.8,-4.2) AF15(-7,-4) AF16(-6,-4) AF17(-5,-4) AF18(-4,-4) AF19(-3,-4) AF20(-2,-4) AF21(-1,-4) AF22(0,-4) AF23(1,-4) AF24(2,-4) AF25(3,-4) AF26(4,-4) AF27(5,-4) AF28(6,-4) AF29(7,-4) AF30(7.8,-4.2) AF31(8.6,-4.2) AF32(9.4,-4.2) AF33(10.2,-4.2) AF34(11,-4.2) AF35(11.8,-4.2) AF36(12.6,-4.2) AF37(13.4,-4.2) AF38(14.2,-4.2) AF39(15.1,-4.2) AF40(16,-4.2) AF41(16.9,-4.2) AF42(17.8,-4.2) AF43(18.7,-4.2) AG1(-18.7,-5.4) AG2(-17.8,-5.4) AG3(-16.9,-5.4) AG4(-16,-5.4) AG5(-15.1,-5.4) AG6(-14.2,-5.4) AG7(-13.4,-5.4) AG8(-12.6,-5.4) AG9(-11.8,-5.4) AG10(-11,-5.4) AG11(-10.2,-5.4) AG12(-9.4,-5.4) AG13(-8.6,-5.4) AG14(-7.8,-5.4) AG15(-7,-5) AG16(-6,-5) AG17(-5,-5) AG18(-4,-5) AG19(-3,-5) AG20(-2,-5) AG21(-1,-5) AG22(0,-5) AG23(1,-5) AG24(2,-5) AG25(3,-5) AG26(4,-5) AG27(5,-5) AG28(6,-5) AG29(7,-5) AG30(7.8,-5.4) AG31(8.6,-5.4) AG32(9.4,-5.4) AG33(10.2,-5.4) AG34(11,-5.4) AG35(11.8,-5.4) AG36(12.6,-5.4) AG37(13.4,-5.4) AG38(14.2,-5.4) AG39(15.1,-5.4) AG40(16,-5.4) AG41(16.9,-5.4) AG42(17.8,-5.4) AG43(18.7,-5.4) AH15(-7,-6) AH16(-6,-6) AH17(-5,-6) AH18(-4,-6) AH19(-3,-6) AH20(-2,-6) AH21(-1,-6) AH22(0,-6) AH23(1,-6) AH24(2,-6) AH25(3,-6) AH26(4,-6) AH27(5,-6) AH28(6,-6) AH29(7,-6) AJ1(-18.7,-6.6) AJ2(-17.8,-6.6) AJ3(-16.9,-6.6) AJ4(-16,-6.6) AJ5(-15.1,-6.6) AJ6(-14.2,-6.6) AJ7(-13.4,-6.6) AJ8(-12.6,-6.6) AJ9(-11.8,-6.6) AJ10(-11,-6.6) AJ11(-10.2,-6.6) AJ12(-9.4,-6.6) AJ13(-8.6,-6.6) AJ14(-7.8,-6.6) AJ15(-7,-7) AJ16(-6,-7) AJ17(-5,-7) AJ18(-4,-7) AJ19(-3,-7) AJ20(-2,-7) AJ21(-1,-7) AJ22(0,-7) AJ23(1,-7) AJ24(2,-7) AJ25(3,-7) AJ26(4,-7) AJ27(5,-7) AJ28(6,-7) AJ29(7,-7) AJ30(7.8,-6.6) AJ31(8.6,-6.6) AJ32(9.4,-6.6) AJ33(10.2,-6.6) AJ34(11,-6.6) AJ35(11.8,-6.6) AJ36(12.6,-6.6) AJ37(13.4,-6.6) AJ38(14.2,-6.6) AJ39(15.1,-6.6) AJ40(16,-6.6) AJ41(16.9,-6.6) AJ42(17.8,-6.6) AJ43(18.7,-6.6) AK1(-18.7,-7.8) AK2(-17.8,-7.8) AK3(-16.9,-7.8) AK4(-16,-7.8) AK5(-15.1,-7.8) AK6(-14.2,-7.8) AK7(-13.4,-7.8) AK8(-12.6,-7.8) AK9(-11.8,-7.8) AK10(-11,-7.8) AK11(-10.2,-7.8) AK12(-9.4,-7.8) AK14(-7.8,-7.8) AK15(-6.6,-7.8) AK17(-5.4,-7.8) AK18(-4.2,-7.8) AK19(-3,-7.8) AK20(-1.8,-7.8) AK21(-0.6,-7.8) AK23(0.6,-7.8) AK24(1.8,-7.8) AK25(3,-7.8) AK26(4.2,-7.8) AK27(5.4,-7.8) AK29(6.6,-7.8) AK30(7.8,-7.8) AK32(9.4,-7.8) AK33(10.2,-7.8) AK34(11,-7.8) AK35(11.8,-7.8) AK36(12.6,-7.8) AK37(13.4,-7.8) AK38(14.2,-7.8) AK39(15.1,-7.8) AK40(16,-7.8) AK41(16.9,-7.8) AK42(17.8,-7.8) AK43(18.7,-7.8) AL15(-6.6,-8.6) AL17(-5.4,-8.6) AL18(-4.2,-8.6) AL19(-3,-8.6) AL20(-1.8,-8.6) AL21(-0.6,-8.6) AL23(0.6,-8.6) AL24(1.8,-8.6) AL25(3,-8.6) AL26(4.2,-8.6) AL27(5.4,-8.6) AL29(6.6,-8.6) AM1(-18.7,-9) AM2(-17.8,-9) AM3(-16.9,-9) AM4(-16,-9) AM5(-15.1,-9) AM6(-14.2,-9) AM7(-13.4,-9) AM8(-12.6,-9) AM9(-11.8,-9) AM10(-11,-9) AM11(-10.2,-9) AM12(-9.2,-9.2) AM14(-7.8,-9.4) AM15(-6.6,-9.4) AM17(-5.4,-9.4) AM18(-4.2,-9.4) AM19(-3,-9.4) AM20(-1.8,-9.4) AM21(-0.6,-9.4) AM23(0.6,-9.4) AM24(1.8,-9.4) AM25(3,-9.4) AM26(4.2,-9.4) AM27(5.4,-9.4) AM29(6.6,-9.4) AM30(7.8,-9.4) AM32(9.2,-9.2) AM33(10.2,-9) AM34(11,-9) AM35(11.8,-9) AM36(12.6,-9) AM37(13.4,-9) AM38(14.2,-9) AM39(15.1,-9) AM40(16,-9) AM41(16.9,-9) AM42(17.8,-9) AM43(18.7,-9) AN1(-18.7,-10.2) AN2(-17.8,-10.2) AN3(-16.9,-10.2) AN4(-16,-10.2) AN5(-15.1,-10.2) AN6(-14.2,-10.2) AN7(-13.4,-10.2) AN8(-12.6,-10.2) AN9(-11.8,-10.2) AN11(-10.2,-10.2) AN12(-9,-10.2) AN14(-7.8,-10.2) AN15(-6.6,-10.2) AN17(-5.4,-10.2) AN18(-4.2,-10.2) AN19(-3,-10.2) AN20(-1.8,-10.2) AN21(-0.6,-10.2) AN23(0.6,-10.2) AN24(1.8,-10.2) AN25(3,-10.2) AN26(4.2,-10.2) AN27(5.4,-10.2) AN29(6.6,-10.2) AN30(7.8,-10.2) AN32(9,-10.2) AN33(10.2,-10.2) AN35(11.8,-10.2) AN36(12.6,-10.2) AN37(13.4,-10.2) AN38(14.2,-10.2) AN39(15.1,-10.2) AN40(16,-10.2) AN41(16.9,-10.2) AN42(17.8,-10.2) AN43(18.7,-10.2) AP12(-9,-11) AP14(-7.8,-11) AP15(-6.6,-11) AP17(-5.4,-11) AP18(-4.2,-11) AP19(-3,-11) AP20(-1.8,-11) AP21(-0.6,-11) AP23(0.6,-11) AP24(1.8,-11) AP25(3,-11) AP26(4.2,-11) AP27(5.4,-11) AP29(6.6,-11) AP30(7.8,-11) AP32(9,-11) AR1(-18.7,-11.4) AR2(-17.8,-11.4) AR3(-16.9,-11.4) AR4(-16,-11.4) AR5(-15.1,-11.4) AR6(-14.2,-11.4) AR7(-13.4,-11.4) AR8(-12.6,-11.4) AR9(-11.6,-11.6) AR11(-10.2,-11.8) AR12(-9,-11.8) AR14(-7.8,-11.8) AR15(-6.6,-11.8) AR17(-5.4,-11.8) AR18(-4.2,-11.8) AR19(-3,-11.8) AR20(-1.8,-11.8) AR21(-0.6,-11.8) AR23(0.6,-11.8) AR24(1.8,-11.8) AR25(3,-11.8) AR26(4.2,-11.8) AR27(5.4,-11.8) AR29(6.6,-11.8) AR30(7.8,-11.8) AR32(9,-11.8) AR33(10.2,-11.8) AR35(11.6,-11.6) AR36(12.6,-11.4) AR37(13.4,-11.4) AR38(14.2,-11.4) AR39(15.1,-11.4) AR40(16,-11.4) AR41(16.9,-11.4) AR42(17.8,-11.4) AR43(18.7,-11.4) AT1(-18.7,-12.6) AT2(-17.8,-12.6) AT3(-16.9,-12.6) AT4(-16,-12.6) AT5(-15.1,-12.6) AT6(-14.2,-12.6) AT8(-12.6,-12.6) AT9(-11.4,-12.6) AT11(-10.2,-12.6) AT12(-9,-12.6) AT14(-7.8,-12.6) AT15(-6.6,-12.6) AT17(-5.4,-12.6) AT18(-4.2,-12.6) AT19(-3,-12.6) AT20(-1.8,-12.6) AT21(-0.6,-12.6) AT23(0.6,-12.6) AT24(1.8,-12.6) AT25(3,-12.6) AT26(4.2,-12.6) AT27(5.4,-12.6) AT29(6.6,-12.6) AT30(7.8,-12.6) AT32(9,-12.6) AT33(10.2,-12.6) AT35(11.4,-12.6) AT36(12.6,-12.6) AT38(14.2,-12.6) AT39(15.1,-12.6) AT40(16,-12.6) AT41(16.9,-12.6) AT42(17.8,-12.6) AT43(18.7,-12.6) AU9(-11.4,-13.4) AU11(-10.2,-13.4) AU12(-9,-13.4) AU14(-7.8,-13.4) AU15(-6.6,-13.4) AU17(-5.4,-13.4) AU18(-4.2,-13.4) AU19(-3,-13.4) AU20(-1.8,-13.4) AU21(-0.6,-13.4) AU23(0.6,-13.4) AU24(1.8,-13.4) AU25(3,-13.4) AU26(4.2,-13.4) AU27(5.4,-13.4) AU29(6.6,-13.4) AU30(7.8,-13.4) AU32(9,-13.4) AU33(10.2,-13.4) AU35(11.4,-13.4) AV1(-18.7,-13.8) AV2(-17.8,-13.8) AV3(-16.9,-13.8) AV4(-16,-13.8) AV5(-15.1,-13.8) AV6(-14,-14) AV8(-12.6,-14.2) AV9(-11.4,-14.2) AV11(-10.2,-14.2) AV12(-9,-14.2) AV14(-7.8,-14.2) AV15(-6.6,-14.2) AV17(-5.4,-14.2) AV18(-4.2,-14.2) AV19(-3,-14.2) AV20(-1.8,-14.2) AV21(-0.6,-14.2) AV23(0.6,-14.2) AV24(1.8,-14.2) AV25(3,-14.2) AV26(4.2,-14.2) AV27(5.4,-14.2) AV29(6.6,-14.2) AV30(7.8,-14.2) AV32(9,-14.2) AV33(10.2,-14.2) AV35(11.4,-14.2) AV36(12.6,-14.2) AV38(14,-14) AV39(15.1,-13.8) AV40(16,-13.8) AV41(16.9,-13.8) AV42(17.8,-13.8) AV43(18.7,-13.8) AW1(-18.7,-15) AW2(-17.8,-15) AW3(-16.9,-15) AW4(-16,-15) AW5(-15.05,-15.05) AW6(-13.8,-15.1) AW8(-12.6,-15.1) AW9(-11.4,-15.1) AW11(-10.2,-15.1) AW12(-9,-15.1) AW14(-7.8,-15.1) AW15(-6.6,-15.1) AW17(-5.4,-15.1) AW18(-4.2,-15.1) AW19(-3,-15.1) AW20(-1.8,-15.1) AW21(-0.6,-15.1) AW23(0.6,-15.1) AW24(1.8,-15.1) AW25(3,-15.1) AW26(4.2,-15.1) AW27(5.4,-15.1) AW29(6.6,-15.1) AW30(7.8,-15.1) AW32(9,-15.1) AW33(10.2,-15.1) AW35(11.4,-15.1) AW36(12.6,-15.1) AW38(13.8,-15.1) AW39(15.05,-15.05) AW40(16,-15) AW41(16.9,-15) AW42(17.8,-15) AW43(18.7,-15) AY2(-17.8,-16.2) AY3(-16.9,-16.2) AY5(-15,-16) AY6(-13.8,-16) AY8(-12.6,-16) AY9(-11.4,-16) AY11(-10.2,-16) AY12(-9,-16) AY14(-7.8,-16) AY15(-6.6,-16) AY17(-5.4,-16) AY18(-4.2,-16) AY19(-3,-16) AY20(-1.8,-16) AY21(-0.6,-16) AY23(0.6,-16) AY24(1.8,-16) AY25(3,-16) AY26(4.2,-16) AY27(5.4,-16) AY29(6.6,-16) AY30(7.8,-16) AY32(9,-16) AY33(10.2,-16) AY35(11.4,-16) AY36(12.6,-16) AY38(13.8,-16) AY39(15,-16) AY41(16.9,-16.2) AY42(17.8,-16.2) B1(-18.7,17.7) B2(-17.7,17.7) B4(-16.2,17.8) B5(-15,17.8) B6(-13.8,17.8) B8(-12.6,17.8) B9(-11.4,17.8) B11(-10.2,17.8) B12(-9,17.8) B14(-7.8,17.8) B15(-6.6,17.8) B17(-5.4,17.8) B18(-4.2,17.8) B19(-3,17.8) B20(-1.8,17.8) B21(-0.6,17.8) B23(0.6,17.8) B24(1.8,17.8) B25(3,17.8) B26(4.2,17.8) B27(5.4,17.8) B29(6.6,17.8) B30(7.8,17.8) B32(9,17.8) B33(10.2,17.8) B35(11.4,17.8) B36(12.6,17.8) B38(13.8,17.8) B39(15,17.8) B40(16.2,17.8) B42(17.7,17.7) B43(18.7,17.7) BA1(-18.7,-16.7) BA4(-16.2,-16.9) BA5(-15,-16.9) BA6(-13.8,-16.9) BA8(-12.6,-16.9) BA9(-11.4,-16.9) BA11(-10.2,-16.9) BA12(-9,-16.9) BA14(-7.8,-16.9) BA15(-6.6,-16.9) BA17(-5.4,-16.9) BA18(-4.2,-16.9) BA19(-3,-16.9) BA20(-1.8,-16.9) BA21(-0.6,-16.9) BA23(0.6,-16.9) BA24(1.8,-16.9) BA25(3,-16.9) BA26(4.2,-16.9) BA27(5.4,-16.9) BA29(6.6,-16.9) BA30(7.8,-16.9) BA32(9,-16.9) BA33(10.2,-16.9) BA35(11.4,-16.9) BA36(12.6,-16.9) BA38(13.8,-16.9) BA39(15,-16.9) BA40(16.2,-16.9) BA43(18.7,-16.7) BB1(-18.7,-17.7) BB2(-17.7,-17.7) BB4(-16.2,-17.8) BB5(-15,-17.8) BB6(-13.8,-17.8) BB8(-12.6,-17.8) BB9(-11.4,-17.8) BB11(-10.2,-17.8) BB12(-9,-17.8) BB14(-7.8,-17.8) BB15(-6.6,-17.8) BB17(-5.4,-17.8) BB18(-4.2,-17.8) BB19(-3,-17.8) BB20(-1.8,-17.8) BB21(-0.6,-17.8) BB23(0.6,-17.8) BB24(1.8,-17.8) BB25(3,-17.8) BB26(4.2,-17.8) BB27(5.4,-17.8) BB29(6.6,-17.8) BB30(7.8,-17.8) BB32(9,-17.8) BB33(10.2,-17.8) BB35(11.4,-17.8) BB36(12.6,-17.8) BB38(13.8,-17.8) BB39(15,-17.8) BB40(16.2,-17.8) BB42(17.7,-17.7) BB43(18.7,-17.7) BC2(-17.7,-18.7) BC3(-16.7,-18.7) BC5(-15,-18.7) BC6(-13.8,-18.7) BC8(-12.6,-18.7) BC9(-11.4,-18.7) BC11(-10.2,-18.7) BC12(-9,-18.7) BC14(-7.8,-18.7) BC15(-6.6,-18.7) BC17(-5.4,-18.7) BC18(-4.2,-18.7) BC19(-3,-18.7) BC20(-1.8,-18.7) BC21(-0.6,-18.7) BC23(0.6,-18.7) BC24(1.8,-18.7) BC25(3,-18.7) BC26(4.2,-18.7) BC27(5.4,-18.7) BC29(6.6,-18.7) BC30(7.8,-18.7) BC32(9,-18.7) BC33(10.2,-18.7) BC35(11.4,-18.7) BC36(12.6,-18.7) BC38(13.8,-18.7) BC39(15,-18.7) BC41(16.7,-18.7) BC42(17.7,-18.7) C1(-18.7,16.7) C4(-16.2,16.9) C5(-15,16.9) C6(-13.8,16.9) C8(-12.6,16.9) C9(-11.4,16.9) C11(-10.2,16.9) C12(-9,16.9) C14(-7.8,16.9) C15(-6.6,16.9) C17(-5.4,16.9) C18(-4.2,16.9) C19(-3,16.9) C20(-1.8,16.9) C21(-0.6,16.9) C23(0.6,16.9) C24(1.8,16.9) C25(3,16.9) C26(4.2,16.9) C27(5.4,16.9) C29(6.6,16.9) C30(7.8,16.9) C32(9,16.9) C33(10.2,16.9) C35(11.4,16.9) C36(12.6,16.9) C38(13.8,16.9) C39(15,16.9) C40(16.2,16.9) C43(18.7,16.7) D2(-17.8,16.2) D3(-16.9,16.2) D5(-15,16) D6(-13.8,16) D8(-12.6,16) D9(-11.4,16) D11(-10.2,16) D12(-9,16) D14(-7.8,16) D15(-6.6,16) D17(-5.4,16) D18(-4.2,16) D19(-3,16) D20(-1.8,16) D21(-0.6,16) D23(0.6,16) D24(1.8,16) D25(3,16) D26(4.2,16) D27(5.4,16) D29(6.6,16) D30(7.8,16) D32(9,16) D33(10.2,16) D35(11.4,16) D36(12.6,16) D38(13.8,16) D39(15,16) D41(16.9,16.2) D42(17.8,16.2) E1(-18.7,15) E2(-17.8,15) E3(-16.9,15) E4(-16,15) E5(-15.05,15.05) E6(-13.8,15.1) E8(-12.6,15.1) E9(-11.4,15.1) E11(-10.2,15.1) E12(-9,15.1) E14(-7.8,15.1) E15(-6.6,15.1) E17(-5.4,15.1) E18(-4.2,15.1) E19(-3,15.1) E20(-1.8,15.1) E21(-0.6,15.1) E23(0.6,15.1) E24(1.8,15.1) E25(3,15.1) E26(4.2,15.1) E27(5.4,15.1) E29(6.6,15.1) E30(7.8,15.1) E32(9,15.1) E33(10.2,15.1) E35(11.4,15.1) E36(12.6,15.1) E38(13.8,15.1) E39(15.05,15.05) E40(16,15) E41(16.9,15) E42(17.8,15) E43(18.7,15) F1(-18.7,13.8) F2(-17.8,13.8) F3(-16.9,13.8) F4(-16,13.8) F5(-15.1,13.8) F6(-14,14) F8(-12.6,14.2) F9(-11.4,14.2) F11(-10.2,14.2) F12(-9,14.2) F14(-7.8,14.2) F15(-6.6,14.2) F17(-5.4,14.2) F18(-4.2,14.2) F19(-3,14.2) F20(-1.8,14.2) F21(-0.6,14.2) F23(0.6,14.2) F24(1.8,14.2) F25(3,14.2) F26(4.2,14.2) F27(5.4,14.2) F29(6.6,14.2) F30(7.8,14.2) F32(9,14.2) F33(10.2,14.2) F35(11.4,14.2) F36(12.6,14.2) F38(14,14) F39(15.1,13.8) F40(16,13.8) F41(16.9,13.8) F42(17.8,13.8) F43(18.7,13.8) G9(-11.4,13.4) G11(-10.2,13.4) G12(-9,13.4) G14(-7.8,13.4) G15(-6.6,13.4) G17(-5.4,13.4) G18(-4.2,13.4) G19(-3,13.4) G20(-1.8,13.4) G21(-0.6,13.4) G23(0.6,13.4) G24(1.8,13.4) G25(3,13.4) G26(4.2,13.4) G27(5.4,13.4) G29(6.6,13.4) G30(7.8,13.4) G32(9,13.4) G33(10.2,13.4) G35(11.4,13.4) H1(-18.7,12.6) H2(-17.8,12.6) H3(-16.9,12.6) H4(-16,12.6) H5(-15.1,12.6) H6(-14.2,12.6) H8(-12.6,12.6) H9(-11.4,12.6) H11(-10.2,12.6) H12(-9,12.6) H14(-7.8,12.6) H15(-6.6,12.6) H17(-5.4,12.6) H18(-4.2,12.6) H19(-3,12.6) H20(-1.8,12.6) H21(-0.6,12.6) H23(0.6,12.6) H24(1.8,12.6) H25(3,12.6) H26(4.2,12.6) H27(5.4,12.6) H29(6.6,12.6) H30(7.8,12.6) H32(9,12.6) H33(10.2,12.6) H35(11.4,12.6) H36(12.6,12.6) H38(14.2,12.6) H39(15.1,12.6) H40(16,12.6) H41(16.9,12.6) H42(17.8,12.6) H43(18.7,12.6) J1(-18.7,11.4) J2(-17.8,11.4) J3(-16.9,11.4) J4(-16,11.4) J5(-15.1,11.4) J6(-14.2,11.4) J7(-13.4,11.4) J8(-12.6,11.4) J9(-11.6,11.6) J11(-10.2,11.8) J12(-9,11.8) J14(-7.8,11.8) J15(-6.6,11.8) J17(-5.4,11.8) J18(-4.2,11.8) J19(-3,11.8) J20(-1.8,11.8) J21(-0.6,11.8) J23(0.6,11.8) J24(1.8,11.8) J25(3,11.8) J26(4.2,11.8) J27(5.4,11.8) J29(6.6,11.8) J30(7.8,11.8) J32(9,11.8) J33(10.2,11.8) J35(11.6,11.6) J36(12.6,11.4) J37(13.4,11.4) J38(14.2,11.4) J39(15.1,11.4) J40(16,11.4) J41(16.9,11.4) J42(17.8,11.4) J43(18.7,11.4) K12(-9,11) K14(-7.8,11) K15(-6.6,11) K17(-5.4,11) K18(-4.2,11) K19(-3,11) K20(-1.8,11) K21(-0.6,11) K23(0.6,11) K24(1.8,11) K25(3,11) K26(4.2,11) K27(5.4,11) K29(6.6,11) K30(7.8,11) K32(9,11) L1(-18.7,10.2) L2(-17.8,10.2) L3(-16.9,10.2) L4(-16,10.2) L5(-15.1,10.2) L6(-14.2,10.2) L7(-13.4,10.2) L8(-12.6,10.2) L9(-11.8,10.2) L11(-10.2,10.2) L12(-9,10.2) L14(-7.8,10.2) L15(-6.6,10.2) L17(-5.4,10.2) L18(-4.2,10.2) L19(-3,10.2) L20(-1.8,10.2) L21(-0.6,10.2) L23(0.6,10.2) L24(1.8,10.2) L25(3,10.2) L26(4.2,10.2) L27(5.4,10.2) L29(6.6,10.2) L30(7.8,10.2) L32(9,10.2) L33(10.2,10.2) L35(11.8,10.2) L36(12.6,10.2) L37(13.4,10.2) L38(14.2,10.2) L39(15.1,10.2) L40(16,10.2) L41(16.9,10.2) L42(17.8,10.2) L43(18.7,10.2) M1(-18.7,9) M2(-17.8,9) M3(-16.9,9) M4(-16,9) M5(-15.1,9) M6(-14.2,9) M7(-13.4,9) M8(-12.6,9) M9(-11.8,9) M10(-11,9) M11(-10.2,9) M12(-9.2,9.2) M14(-7.8,9.4) M15(-6.6,9.4) M17(-5.4,9.4) M18(-4.2,9.4) M19(-3,9.4) M20(-1.8,9.4) M21(-0.6,9.4) M23(0.6,9.4) M24(1.8,9.4) M25(3,9.4) M26(4.2,9.4) M27(5.4,9.4) M29(6.6,9.4) M30(7.8,9.4) M32(9.2,9.2) M33(10.2,9) M34(11,9) M35(11.8,9) M36(12.6,9) M37(13.4,9) M38(14.2,9) M39(15.1,9) M40(16,9) M41(16.9,9) M42(17.8,9) M43(18.7,9) N15(-6.6,8.6) N17(-5.4,8.6) N18(-4.2,8.6) N19(-3,8.6) N20(-1.8,8.6) N21(-0.6,8.6) N23(0.6,8.6) N24(1.8,8.6) N25(3,8.6) N26(4.2,8.6) N27(5.4,8.6) N29(6.6,8.6) P1(-18.7,7.8) P2(-17.8,7.8) P3(-16.9,7.8) P4(-16,7.8) P5(-15.1,7.8) P6(-14.2,7.8) P7(-13.4,7.8) P8(-12.6,7.8) P9(-11.8,7.8) P10(-11,7.8) P11(-10.2,7.8) P12(-9.4,7.8) P14(-7.8,7.8) P15(-6.6,7.8) P17(-5.4,7.8) P18(-4.2,7.8) P19(-3,7.8) P20(-1.8,7.8) P21(-0.6,7.8) P23(0.6,7.8) P24(1.8,7.8) P25(3,7.8) P26(4.2,7.8) P27(5.4,7.8) P29(6.6,7.8) P30(7.8,7.8) P32(9.4,7.8) P33(10.2,7.8) P34(11,7.8) P35(11.8,7.8) P36(12.6,7.8) P37(13.4,7.8) P38(14.2,7.8) P39(15.1,7.8) P40(16,7.8) P41(16.9,7.8) P42(17.8,7.8) P43(18.7,7.8) R1(-18.7,6.6) R2(-17.8,6.6) R3(-16.9,6.6) R4(-16,6.6) R5(-15.1,6.6) R6(-14.2,6.6) R7(-13.4,6.6) R8(-12.6,6.6) R9(-11.8,6.6) R10(-11,6.6) R11(-10.2,6.6) R12(-9.4,6.6) R13(-8.6,6.6) R14(-7.8,6.6) R15(-7,7) R16(-6,7) R17(-5,7) R18(-4,7) R19(-3,7) R20(-2,7) R21(-1,7) R22(0,7) R23(1,7) R24(2,7) R25(3,7) R26(4,7) R27(5,7) R28(6,7) R29(7,7) R30(7.8,6.6) R31(8.6,6.6) R32(9.4,6.6) R33(10.2,6.6) R34(11,6.6) R35(11.8,6.6) R36(12.6,6.6) R37(13.4,6.6) R38(14.2,6.6) R39(15.1,6.6) R40(16,6.6) R41(16.9,6.6) R42(17.8,6.6) R43(18.7,6.6) T15(-7,6) T16(-6,6) T17(-5,6) T18(-4,6) T19(-3,6) T20(-2,6) T21(-1,6) T22(0,6) T23(1,6) T24(2,6) T25(3,6) T26(4,6) T27(5,6) T28(6,6) T29(7,6) U1(-18.7,5.4) U2(-17.8,5.4) U3(-16.9,5.4) U4(-16,5.4) U5(-15.1,5.4) U6(-14.2,5.4) U7(-13.4,5.4) U8(-12.6,5.4) U9(-11.8,5.4) U10(-11,5.4) U11(-10.2,5.4) U12(-9.4,5.4) U13(-8.6,5.4) U14(-7.8,5.4) U15(-7,5) U16(-6,5) U17(-5,5) U18(-4,5) U19(-3,5) U20(-2,5) U21(-1,5) U22(0,5) U23(1,5) U24(2,5) U25(3,5) U26(4,5) U27(5,5) U28(6,5) U29(7,5) U30(7.8,5.4) U31(8.6,5.4) U32(9.4,5.4) U33(10.2,5.4) U34(11,5.4) U35(11.8,5.4) U36(12.6,5.4) U37(13.4,5.4) U38(14.2,5.4) U39(15.1,5.4) U40(16,5.4) U41(16.9,5.4) U42(17.8,5.4) U43(18.7,5.4) V1(-18.7,4.2) V2(-17.8,4.2) V3(-16.9,4.2) V4(-16,4.2) V5(-15.1,4.2) V6(-14.2,4.2) V7(-13.4,4.2) V8(-12.6,4.2) V9(-11.8,4.2) V10(-11,4.2) V11(-10.2,4.2) V12(-9.4,4.2) V13(-8.6,4.2) V14(-7.8,4.2) V15(-7,4) V16(-6,4) V17(-5,4) V18(-4,4) V19(-3,4) V20(-2,4) V21(-1,4) V22(0,4) V23(1,4) V24(2,4) V25(3,4) V26(4,4) V27(5,4) V28(6,4) V29(7,4) V30(7.8,4.2) V31(8.6,4.2) V32(9.4,4.2) V33(10.2,4.2) V34(11,4.2) V35(11.8,4.2) V36(12.6,4.2) V37(13.4,4.2) V38(14.2,4.2) V39(15.1,4.2) V40(16,4.2) V41(16.9,4.2) V42(17.8,4.2) V43(18.7,4.2) W1(-18.7,3) W2(-17.8,3) W3(-16.9,3) W4(-16,3) W5(-15.1,3) W6(-14.2,3) W7(-13.4,3) W8(-12.6,3) W9(-11.8,3) W10(-11,3) W11(-10.2,3) W12(-9.4,3) W13(-8.6,3) W14(-7.8,3) W15(-7,3) W16(-6,3) W17(-5,3) W18(-4,3) W19(-3,3) W20(-2,3) W21(-1,3) W22(0,3) W23(1,3) W24(2,3) W25(3,3) W26(4,3) W27(5,3) W28(6,3) W29(7,3) W30(7.8,3) W31(8.6,3) W32(9.4,3) W33(10.2,3) W34(11,3) W35(11.8,3) W36(12.6,3) W37(13.4,3) W38(14.2,3) W39(15.1,3) W40(16,3) W41(16.9,3) W42(17.8,3) W43(18.7,3) Y1(-18.7,1.8) Y2(-17.8,1.8) Y3(-16.9,1.8) Y4(-16,1.8) Y5(-15.1,1.8) Y6(-14.2,1.8) Y7(-13.4,1.8) Y8(-12.6,1.8) Y9(-11.8,1.8) Y10(-11,1.8) Y11(-10.2,1.8) Y12(-9.4,1.8) Y13(-8.6,1.8) Y14(-7.8,1.8) Y15(-7,2) Y16(-6,2) Y17(-5,2) Y18(-4,2) Y19(-3,2) Y20(-2,2) Y21(-1,2) Y22(0,2) Y23(1,2) Y24(2,2) Y25(3,2) Y26(4,2) Y27(5,2) Y28(6,2) Y29(7,2) Y30(7.8,1.8) Y31(8.6,1.8) Y32(9.4,1.8) Y33(10.2,1.8) Y34(11,1.8) Y35(11.8,1.8) Y36(12.6,1.8) Y37(13.4,1.8) Y38(14.2,1.8) Y39(15.1,1.8) Y40(16,1.8) Y41(16.9,1.8) Y42(17.8,1.8) Y43(18.7,1.8)
C402-TO0D2H28
  custom 0.152x0.152 smd: 1(0,0.457) 2(0,-0.457)
C402H22
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C603H35
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H36
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H40
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H42
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C805H50
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H54
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H56
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H58
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
CI1108M1VR0-NH
  rect 0.61x1.549 smd: 1(3.5,2.525) 2(2.5,2.525) 3(1.5,2.525) 4(0.5,2.525) 5(-0.5,2.525) 6(-1.5,2.525) 7(-2.5,2.525) 8(-3.5,2.525)
  rect 1.194x1.803 smd: 9(4.8,0) 10(-4.8,0)
CI2505P1V0B-R0-NH
  round 1.422 hole 1.016: 1(5,0) 2(2.5,0) 3(0,0) 4(-2.5,0) 5(-5,0)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CP3508P1H00-NH-U
  round 0.254 hole 3.302 unplated: (-2.35,-5.82) (2.35,-5.82)
  round 1.651 hole 1.016: 1(4.5,-1.5) 2(1.5,-1.5) 3(-1.5,-1.5) 4(-4.5,-1.5) 5(4.5,1.5) 6(1.5,1.5) 7(-1.5,1.5) 8(-4.5,1.5)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT3528H83
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H75
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
CT7343H83
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
CT7343H87
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
D402H24
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
DFN6F2-2H32
  rect 0.406x1.016 smd: 1(0.65,1)
  rect 0.406x0.914 smd: 2(0,1.051) 3(-0.65,1.051) 4(-0.65,-1.051) 5(0,-1.051) 6(0.65,-1.051)
DFN6J1D4H32
  rect 0.203x0.94 smd: 1(0.4,0.611) 2(0,0.611) 3(-0.4,0.611) 4(-0.4,-0.611) 5(0,-0.611) 6(0.4,-0.611)
DFN8F3-G2416-1H32
  rect 0.406x0.991 smd: 1(0.975,1.513) 2(0.325,1.513) 3(-0.325,1.513) 4(-0.975,1.513) 5(-0.975,-1.513) 6(-0.325,-1.513) 7(0.325,-1.513) 8(0.975,-1.513)
  rect 2.388x1.6 smd: 9(0,0)
DFN8F3-G2517H32
  rect 0.406x0.94 smd: 1(0.975,1.538) 2(0.325,1.538) 3(-0.325,1.538) 4(-0.975,1.538) 5(-0.975,-1.538)
  rect 0.025x0.025 smd: 6(-0.325,-1.538) 8(0.975,-1.538)
  custom 0.235x0.235 smd: 7(0.325,-1.538)
  rect 2.489x1.676 smd: 9(0,0)
DFN8G2-G1710-U1H40
  rect 0.305x0.686 smd: 1(0.75,1.106) 2(0.25,1.106) 3(-0.25,1.106) 4(-0.75,1.106) 5(-0.75,-1.106) 6(-0.25,-1.106) 7(0.25,-1.106) 8(0.75,-1.106)
  rect 1.702x0.94 smd: 9(0,0)
DFN8G2030-G16-1H32
  rect 0.305x0.991 smd: 1(0.75,1.513) 2(0.25,1.513) 3(-0.25,1.513) 4(-0.75,1.513) 5(-0.75,-1.513) 6(-0.25,-1.513) 7(0.25,-1.513) 8(0.75,-1.513)
  rect 1.6x1.6 smd: 9(0,0)
DFN12G4030-G360175H34
  rect 0.305x0.914 smd: 1(1.25,1.551) 5(-0.75,1.551) 6(-1.25,1.551) 7(-1.25,-1.551) 8(-0.75,-1.551) 9(-0.25,-1.551) 10(0.25,-1.551) 11(0.75,-1.551) 12(1.25,-1.551)
  rect 0.025x0.025 smd: 2(0.75,1.551) 4(-0.25,1.551)
  custom 0.229x0.229 smd: 3(0.25,1.551)
  rect 3.607x1.753 smd: 13(0,0)
DO214AAAK-1121H97
  rect 2.311x2.032 smd: A(0,2.322) K(0,-2.322)
ECAP-100D6D3H375
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
G6179HT0321-001
  rect 0.635x2.108 smd: 1(1.905,3.466) 2(0.635,3.466) 3(-0.635,3.466) 4(-1.905,3.466) 5(-1.905,-3.466) 6(-0.635,-3.466) 7(0.635,-3.466) 8(1.905,-3.466)
GAP-CLOSE-PWR
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GEN8D5X8R5X4D5-8-F-A
  round 0.254 hole 5.004x4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(3.136,1.664) 2(1.918,2.882) 3(-1.918,2.882) 4(-3.136,1.664) 5(-3.136,-1.664) 6(-1.918,-2.882) 7(1.918,-2.882) 8(3.136,-1.664)
GEN315R138-8-F-A-1
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.667,1.54) 2(1.54,2.667) 3(-1.54,2.667) 4(-2.667,1.54) 5(-2.667,-1.54) 6(-1.54,-2.667) 7(1.54,-2.667) 8(2.667,-1.54)
GEN315R178-8-F-A-1
  round 0.254 hole 4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.882,1.664) 2(1.664,2.882) 3(-1.664,2.882) 4(-2.882,1.664) 5(-2.882,-1.664) 6(-1.664,-2.882) 7(1.664,-2.882) 8(2.882,-1.664)
HL5507F
  round 0.254 hole 1.016 unplated: (5,0)
  round 1.321 hole 0.914: 1(-6,-1) 2(-6,1) 3(-4,-1) 4(-4,1) 5(-2,-1) 6(-2,1) 7(0,-1) 8(0,1) 9(2,-1) 10(2,1) 11(4,-1) 12(4,1) 13(6,-1) 14(6,1)
HOLE237R95
  round 6.02 hole 2.413: 1(0,0)
HOLE237R158
  round 6.02 hole 4.013: 1(0,0)
L402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L402H24
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L603H26
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
L603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
L805H44
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L3216H52
  rect 1.651x1.27 smd: 1(0,1.6) 2(0,-1.6)
L7066-1830-UH119
  rect 3.505x2.921 smd: 1(0,2.78) 2(0,-2.78)
L20125H44
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L109100-2030H138
  rect 3.505x3.15 smd: 1(0,4.619) 2(0,-4.619)
L112100-2030H158
  rect 3.505x3.15 smd: 1(0,4.769) 2(0,-4.769)
L112100-2135H158
  rect 4.013x3.251 smd: 1(0,4.72) 2(0,-4.72)
L125100-4P-1H24
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H37
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-4H28
  rect 0.762x0.432 smd: 1(-0.625,0.341) 2(0.625,0.341) 3(0.625,-0.341) 4(-0.625,-0.341)
L686647-127318H119
  rect 3.683x2.413 smd: 1(0,2.986) 2(0,-2.986)
LE18077-Z55D-4F
  round 0.991 hole 0.635: 1(3.81,0) 2(2.755,1.5) 3(1.055,1.5) 4(0,0) 5(-1.055,1.5) 6(-2.755,1.5) 7(-3.81,0)
  round 1.854 hole 1.372: 8(6.29,0) 9(-6.54,1)
LQFP128H63
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
MSOP8-1H44
  rect 0.356x1.524 smd: 1(-0.975,-2.055) 2(-0.325,-2.055) 3(0.325,-2.055) 4(0.975,-2.055) 5(0.975,2.055) 6(0.325,2.055) 7(-0.325,2.055) 8(-0.975,2.055)
NTC-402H22-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
NTC-603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
P254-1104S0AP-R-W
  round 1.651 hole 1.016: 1(-3.81,0) 2(-1.27,0) 3(1.27,0) 4(3.81,0)
POLYSW-2114H30
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-5PH45
  rect 0.762x1.524 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81)
  rect 5.283x5.08 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.032) 7(-0.635,2.032) 8(-1.905,2.032)
PPAK-8P-1-UH40
  rect 0.762x1.524 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81)
  rect 5.283x5.08 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.032) 7(-0.635,2.032) 8(-1.905,2.032)
PPAK-8PH48
  rect 0.762x1.524 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81)
  rect 5.283x5.08 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.032) 7(-0.635,2.032) 8(-1.905,2.032)
QFN16-G1D8-UH32
  rect 0.305x0.914 smd: 1(0.75,1.551) 2(0.25,1.551) 3(-0.25,1.551) 4(-0.75,1.551) 9(-0.75,-1.551) 10(-0.25,-1.551) 11(0.25,-1.551) 12(0.75,-1.551)
  rect 0.914x0.305 smd: 5(-1.551,0.75) 6(-1.551,0.25) 7(-1.551,-0.25) 8(-1.551,-0.75) 13(1.551,-0.75) 14(1.551,-0.25) 15(1.551,0.25) 16(1.551,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20G4525-G315115-UH40
  rect 0.965x0.305 smd: 1(2.301,0.25) 10(-2.301,0.25) 11(-2.301,-0.25) 20(2.301,-0.25)
  rect 0.305x0.965 smd: 2(1.75,1.301) 3(1.25,1.301) 4(0.75,1.301) 5(0.25,1.301) 6(-0.25,1.301) 7(-0.75,1.301) 8(-1.25,1.301) 9(-1.75,1.301) 12(-1.75,-1.301) 13(-1.25,-1.301) 14(-0.75,-1.301) 15(-0.25,-1.301) 16(0.25,-1.301) 17(0.75,-1.301) 18(1.25,-1.301) 19(1.75,-1.301)
  rect 3.15x1.143 smd: 21(0,0)
QFN20Z3-G1D1H36
  custom 0.064x0.064 smd: 1(0.9,1.424) 5(-0.9,1.424) 6(-1.424,0.9) 10(-1.424,-0.9) 11(-0.9,-1.424) 15(0.9,-1.424) 16(1.424,-0.9) 20(1.424,0.9)
  rect 0.254x1.168 smd: 2(0.45,1.424) 3(0,1.424) 4(-0.45,1.424) 12(-0.45,-1.424) 13(0,-1.424) 14(0.45,-1.424)
  rect 1.168x0.254 smd: 7(-1.424,0.45) 8(-1.424,0) 9(-1.424,-0.45) 17(1.424,-0.45) 18(1.424,0) 19(1.424,0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN20Z3-G1H36
  custom 0.064x0.064 smd: 1(0.9,1.424) 5(-0.9,1.424) 6(-1.424,0.9) 10(-1.424,-0.9) 11(-0.9,-1.424) 15(0.9,-1.424) 16(1.424,-0.9) 20(1.424,0.9)
  rect 0.254x1.168 smd: 2(0.45,1.424) 3(0,1.424) 4(-0.45,1.424) 12(-0.45,-1.424) 13(0,-1.424) 14(0.45,-1.424)
  rect 1.168x0.254 smd: 7(-1.424,0.45) 8(-1.424,0) 9(-1.424,-0.45) 17(1.424,-0.45) 18(1.424,0) 19(1.424,0.45)
  rect 0.991x0.991 smd: 21(0,0)
QFN22G4-G2PH42
  rect 0.305x0.914 smd: 1(1.25,2.051) 2(0.75,2.051) 3(0.25,2.051) 4(-0.25,2.051) 5(-0.75,2.051) 6(-1.25,2.051) 16(0.75,-2.051) 17(1.25,-2.051)
  custom 0.326x0.326 smd: 7(-2.051,1.25)
  rect 0.025x0.025 smd: 8(-2.051,0.75) 9(-2.051,0.25) 10(-2.051,-0.75) 13(-0.75,-2.051) 14(-0.25,-2.051) 15(0.25,-2.051)
  custom 0.232x0.232 smd: 11(-2.051,-1.25)
  custom 0.229x0.229 smd: 12(-1.25,-2.051)
  rect 0.914x0.305 smd: 18(2.051,-1.25) 19(2.051,-0.75) 20(2.051,-0.25) 21(2.051,0.25) 22(2.051,1.25)
QFN32G5-G3D6H24
  rect 0.305x0.914 smd: 1(1.75,2.551) 8(-1.75,2.551) 17(-1.75,-2.551) 24(1.75,-2.551)
  rect 0.305x0.991 smd: 2(1.25,2.513) 3(0.75,2.513) 4(0.25,2.513) 5(-0.25,2.513) 6(-0.75,2.513) 7(-1.25,2.513) 18(-1.25,-2.513) 19(-0.75,-2.513) 20(-0.25,-2.513) 21(0.25,-2.513) 22(0.75,-2.513) 23(1.25,-2.513)
  rect 0.914x0.305 smd: 9(-2.551,1.75) 16(-2.551,-1.75) 25(2.551,-1.75) 32(2.551,1.75)
  rect 0.991x0.305 smd: 10(-2.513,1.25) 11(-2.513,0.75) 12(-2.513,0.25) 13(-2.513,-0.25) 14(-2.513,-0.75) 15(-2.513,-1.25) 26(2.513,-1.25) 27(2.513,-0.75) 28(2.513,-0.25) 29(2.513,0.25) 30(2.513,0.75) 31(2.513,1.25)
  rect 3.607x3.607 smd: 33(0,0)
QFN40G6-G3P-2H32
  rect 0.305x0.914 smd: 1(2.25,3.025) 10(-2.25,3.025) 21(-2.25,-3.025) 30(2.25,-3.025)
  rect 0.305x0.965 smd: 2(1.75,3.025) 3(1.25,3.025) 4(0.75,3.025) 5(0.25,3.025) 6(-0.25,3.025) 7(-0.75,3.025) 8(-1.25,3.025) 9(-1.75,3.025) 22(-1.75,-3.025) 23(-1.25,-3.025) 24(-0.75,-3.025) 25(-0.25,-3.025) 26(0.25,-3.025) 27(0.75,-3.025) 28(1.25,-3.025) 29(1.75,-3.025)
  rect 0.914x0.305 smd: 11(-3.025,2.25) 20(-3.025,-2.25) 31(3.025,-2.25) 40(3.025,2.25)
  rect 0.965x0.305 smd: 12(-3.025,1.75) 13(-3.025,1.25) 14(-3.025,0.75) 15(-3.025,0.25) 16(-3.025,-0.25) 17(-3.025,-0.75) 18(-3.025,-1.25) 19(-3.025,-1.75) 32(3.025,-1.75) 33(3.025,-1.25) 34(3.025,-0.75) 35(3.025,-0.25) 36(3.025,0.25) 37(3.025,0.75) 38(3.025,1.25) 39(3.025,1.75)
  rect 2.108x1.6 smd: 41(1.2,1.48) 42(-1.2,1.48)
  rect 4.496x2.362 smd: 43(0,-0.925)
QFN48J6-G4D55H40
  rect 0.203x1.016 smd: 1(2.2,3) 2(1.8,3) 3(1.4,3) 4(1,3) 5(0.6,3) 6(0.2,3) 7(-0.2,3) 8(-0.6,3) 9(-1,3) 10(-1.4,3) 11(-1.8,3) 12(-2.2,3) 25(-2.2,-3) 26(-1.8,-3) 27(-1.4,-3) 28(-1,-3) 29(-0.6,-3) 30(-0.2,-3) 31(0.2,-3) 32(0.6,-3) 33(1,-3) 34(1.4,-3) 35(1.8,-3) 36(2.2,-3)
  rect 1.016x0.203 smd: 13(-3,2.2) 14(-3,1.8) 15(-3,1.4) 16(-3,1) 17(-3,0.6) 18(-3,0.2) 19(-3,-0.2) 20(-3,-0.6) 21(-3,-1) 22(-3,-1.4) 23(-3,-1.8) 24(-3,-2.2) 37(3,-2.2) 38(3,-1.8) 39(3,-1.4) 40(3,-1) 41(3,-0.6) 42(3,-0.2) 43(3,0.2) 44(3,0.6) 45(3,1) 46(3,1.4) 47(3,1.8) 48(3,2.2)
  rect 4.547x4.547 smd: 49(0,0)
QFN56J7-G4D85H36
  rect 0.203x1.041 smd: 1(2.6,3.424) 14(-2.6,3.424) 29(-2.6,-3.424) 42(2.6,-3.424)
  rect 0.203x1.168 smd: 2(2.2,3.424) 3(1.8,3.424) 4(1.4,3.424) 5(1,3.424) 6(0.6,3.424) 7(0.2,3.424) 8(-0.2,3.424) 9(-0.6,3.424) 10(-1,3.424) 11(-1.4,3.424) 12(-1.8,3.424) 13(-2.2,3.424) 30(-2.2,-3.424) 31(-1.8,-3.424) 32(-1.4,-3.424) 33(-1,-3.424) 34(-0.6,-3.424) 35(-0.2,-3.424) 36(0.2,-3.424) 37(0.6,-3.424) 38(1,-3.424) 39(1.4,-3.424) 40(1.8,-3.424) 41(2.2,-3.424)
  rect 1.041x0.203 smd: 15(-3.424,2.6) 28(-3.424,-2.6) 43(3.424,-2.6) 56(3.424,2.6)
  rect 1.168x0.203 smd: 16(-3.424,2.2) 17(-3.424,1.8) 18(-3.424,1.4) 19(-3.424,1) 20(-3.424,0.6) 21(-3.424,0.2) 22(-3.424,-0.2) 23(-3.424,-0.6) 24(-3.424,-1) 25(-3.424,-1.4) 26(-3.424,-1.8) 27(-3.424,-2.2) 44(3.424,-2.2) 45(3.424,-1.8) 46(3.424,-1.4) 47(3.424,-1) 48(3.424,-0.6) 49(3.424,-0.2) 50(3.424,0.2) 51(3.424,0.6) 52(3.424,1) 53(3.424,1.4) 54(3.424,1.8) 55(3.424,2.2)
  rect 4.851x4.851 smd: 57(0,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
R805H24
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
R1206H28
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R2512-27D4-4PH28
  rect 2.946x1.168 smd: 1(-1.85,1.524) 2(-1.85,-1.524) 3(1.85,-1.524) 4(1.85,1.524)
SC70-2D2-312H44
  custom 0.152x0.152 smd: 1(-0.65,-0.902) 2(0.65,-0.902) 3(0,0.902)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SC70-6H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SE361414H241
  rect 1.372x3.607 smd: 1(0,2.499) 2(0,-2.499)
SE361416H182
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SE361416H237
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SKT-BGA1331C564462H225
  round 0.508 smd: A3(-17,19) A37(17,19) AU1(-19,-17) AU2(-18,-17) AU3(-17,-17) AU37(17,-17) AU38(18,-17) AU39(19,-17) AV2(-18,-18) AV3(-17,-18) AV37(17,-18) AV38(18,-18) AW3(-17,-19) AW37(17,-19) B3(-17,18) B37(17,18) B38(18,18) C1(-19,17) C2(-18,17) C3(-17,17) C37(17,17) C38(18,17) C39(19,17)
  round 0.457 smd: A4(-16,19) A5(-15,19) A6(-14,19) A7(-13,19) A8(-12,19) A9(-11,19) A10(-10,19) A11(-9,19) A12(-8,19) A13(-7,19) A14(-6,19) A15(-5,19) A16(-4,19) A17(-3,19) A18(-2,19) A19(-1,19) A20(0,19) A21(1,19) A22(2,19) A23(3,19) A24(4,19) A25(5,19) A26(6,19) A27(7,19) A28(8,19) A29(9,19) A30(10,19) A31(11,19) A32(12,19) A33(13,19) A34(14,19) A35(15,19) A36(16,19) AA1(-19,-1) AA2(-18,-1) AA3(-17,-1) AA4(-16,-1) AA5(-15,-1) AA6(-14,-1) AA7(-13,-1) AA8(-12,-1) AA9(-11,-1) AA10(-10,-1) AA11(-9,-1) AA12(-8,-1) AA13(-7,-1) AA27(7,-1) AA28(8,-1) AA29(9,-1) AA30(10,-1) AA31(11,-1) AA32(12,-1) AA33(13,-1) AA34(14,-1) AA35(15,-1) AA36(16,-1) AA37(17,-1) AA38(18,-1) AA39(19,-1) AB1(-19,-2) AB2(-18,-2) AB3(-17,-2) AB4(-16,-2) AB5(-15,-2) AB6(-14,-2) AB7(-13,-2) AB8(-12,-2) AB9(-11,-2) AB10(-10,-2) AB11(-9,-2) AB12(-8,-2) AB13(-7,-2) AB27(7,-2) AB28(8,-2) AB29(9,-2) AB30(10,-2) AB31(11,-2) AB32(12,-2) AB33(13,-2) AB34(14,-2) AB35(15,-2) AB36(16,-2) AB37(17,-2) AB38(18,-2) AB39(19,-2) AC1(-19,-3) AC2(-18,-3) AC3(-17,-3) AC4(-16,-3) AC5(-15,-3) AC6(-14,-3) AC7(-13,-3) AC8(-12,-3) AC9(-11,-3) AC10(-10,-3) AC11(-9,-3) AC12(-8,-3) AC13(-7,-3) AC27(7,-3) AC28(8,-3) AC29(9,-3) AC30(10,-3) AC31(11,-3) AC32(12,-3) AC33(13,-3) AC34(14,-3) AC35(15,-3) AC36(16,-3) AC37(17,-3) AC38(18,-3) AC39(19,-3) AD1(-19,-4) AD2(-18,-4) AD3(-17,-4) AD4(-16,-4) AD5(-15,-4) AD6(-14,-4) AD7(-13,-4) AD8(-12,-4) AD9(-11,-4) AD10(-10,-4) AD11(-9,-4) AD12(-8,-4) AD13(-7,-4) AD27(7,-4) AD28(8,-4) AD29(9,-4) AD30(10,-4) AD31(11,-4) AD32(12,-4) AD33(13,-4) AD34(14,-4) AD35(15,-4) AD36(16,-4) AD37(17,-4) AD38(18,-4) AD39(19,-4) AE1(-19,-5) AE2(-18,-5) AE3(-17,-5) AE4(-16,-5) AE5(-15,-5) AE6(-14,-5) AE7(-13,-5) AE8(-12,-5) AE9(-11,-5) AE10(-10,-5) AE11(-9,-5) AE12(-8,-5) AE13(-7,-5) AE27(7,-5) AE28(8,-5) AE29(9,-5) AE30(10,-5) AE31(11,-5) AE32(12,-5) AE33(13,-5) AE34(14,-5) AE35(15,-5) AE36(16,-5) AE37(17,-5) AE38(18,-5) AE39(19,-5) AF1(-19,-6) AF2(-18,-6) AF3(-17,-6) AF4(-16,-6) AF5(-15,-6) AF6(-14,-6) AF7(-13,-6) AF8(-12,-6) AF9(-11,-6) AF10(-10,-6) AF11(-9,-6) AF12(-8,-6) AF13(-7,-6) AF27(7,-6) AF28(8,-6) AF29(9,-6) AF30(10,-6) AF31(11,-6) AF32(12,-6) AF33(13,-6) AF34(14,-6) AF35(15,-6) AF36(16,-6) AF37(17,-6) AF38(18,-6) AF39(19,-6) AG1(-19,-7) AG2(-18,-7) AG3(-17,-7) AG4(-16,-7) AG5(-15,-7) AG6(-14,-7) AG7(-13,-7) AG8(-12,-7) AG9(-11,-7) AG10(-10,-7) AG11(-9,-7) AG12(-8,-7) AG13(-7,-7) AG14(-6,-7) AG15(-5,-7) AG16(-4,-7) AG17(-3,-7) AG18(-2,-7) AG19(-1,-7) AG20(0,-7) AG21(1,-7) AG22(2,-7) AG23(3,-7) AG24(4,-7) AG25(5,-7) AG26(6,-7) AG27(7,-7) AG28(8,-7) AG29(9,-7) AG30(10,-7) AG31(11,-7) AG32(12,-7) AG33(13,-7) AG34(14,-7) AG35(15,-7) AG36(16,-7) AG37(17,-7) AG38(18,-7) AG39(19,-7) AH1(-19,-8) AH2(-18,-8) AH3(-17,-8) AH4(-16,-8) AH5(-15,-8) AH6(-14,-8) AH7(-13,-8) AH8(-12,-8) AH9(-11,-8) AH10(-10,-8) AH11(-9,-8) AH12(-8,-8) AH13(-7,-8) AH14(-6,-8) AH15(-5,-8) AH16(-4,-8) AH17(-3,-8) AH18(-2,-8) AH19(-1,-8) AH20(0,-8) AH21(1,-8) AH22(2,-8) AH23(3,-8) AH24(4,-8) AH25(5,-8) AH26(6,-8) AH27(7,-8) AH28(8,-8) AH29(9,-8) AH30(10,-8) AH31(11,-8) AH32(12,-8) AH33(13,-8) AH34(14,-8) AH35(15,-8) AH36(16,-8) AH37(17,-8) AH38(18,-8) AH39(19,-8) AJ1(-19,-9) AJ2(-18,-9) AJ3(-17,-9) AJ4(-16,-9) AJ5(-15,-9) AJ6(-14,-9) AJ7(-13,-9) AJ8(-12,-9) AJ9(-11,-9) AJ10(-10,-9) AJ11(-9,-9) AJ12(-8,-9) AJ13(-7,-9) AJ14(-6,-9) AJ15(-5,-9) AJ16(-4,-9) AJ17(-3,-9) AJ18(-2,-9) AJ19(-1,-9) AJ20(0,-9) AJ21(1,-9) AJ22(2,-9) AJ23(3,-9) AJ24(4,-9) AJ25(5,-9) AJ26(6,-9) AJ27(7,-9) AJ28(8,-9) AJ29(9,-9) AJ30(10,-9) AJ31(11,-9) AJ32(12,-9) AJ33(13,-9) AJ34(14,-9) AJ35(15,-9) AJ36(16,-9) AJ37(17,-9) AJ38(18,-9) AJ39(19,-9) AK1(-19,-10) AK2(-18,-10) AK3(-17,-10) AK4(-16,-10) AK5(-15,-10) AK6(-14,-10) AK7(-13,-10) AK8(-12,-10) AK9(-11,-10) AK10(-10,-10) AK11(-9,-10) AK12(-8,-10) AK13(-7,-10) AK14(-6,-10) AK15(-5,-10) AK18(-2,-10) AK19(-1,-10) AK20(0,-10) AK21(1,-10) AK22(2,-10) AK25(5,-10) AK26(6,-10) AK27(7,-10) AK28(8,-10) AK29(9,-10) AK30(10,-10) AK31(11,-10) AK32(12,-10) AK33(13,-10) AK34(14,-10) AK35(15,-10) AK36(16,-10) AK37(17,-10) AK38(18,-10) AK39(19,-10) AL1(-19,-11) AL2(-18,-11) AL3(-17,-11) AL4(-16,-11) AL5(-15,-11) AL6(-14,-11) AL7(-13,-11) AL8(-12,-11) AL9(-11,-11) AL10(-10,-11) AL11(-9,-11) AL12(-8,-11) AL13(-7,-11) AL14(-6,-11) AL15(-5,-11) AL16(-4,-11) AL17(-3,-11) AL18(-2,-11) AL19(-1,-11) AL20(0,-11) AL21(1,-11) AL22(2,-11) AL23(3,-11) AL24(4,-11) AL25(5,-11) AL26(6,-11) AL27(7,-11) AL28(8,-11) AL29(9,-11) AL30(10,-11) AL31(11,-11) AL32(12,-11) AL33(13,-11) AL34(14,-11) AL35(15,-11) AL36(16,-11) AL37(17,-11) AL38(18,-11) AL39(19,-11) AM1(-19,-12) AM2(-18,-12) AM3(-17,-12) AM4(-16,-12) AM5(-15,-12) AM6(-14,-12) AM7(-13,-12) AM8(-12,-12) AM9(-11,-12) AM10(-10,-12) AM11(-9,-12) AM12(-8,-12) AM13(-7,-12) AM14(-6,-12) AM15(-5,-12) AM16(-4,-12) AM17(-3,-12) AM18(-2,-12) AM19(-1,-12) AM20(0,-12) AM21(1,-12) AM22(2,-12) AM23(3,-12) AM24(4,-12) AM25(5,-12) AM26(6,-12) AM27(7,-12) AM28(8,-12) AM29(9,-12) AM30(10,-12) AM31(11,-12) AM32(12,-12) AM33(13,-12) AM34(14,-12) AM35(15,-12) AM36(16,-12) AM37(17,-12) AM38(18,-12) AM39(19,-12) AN1(-19,-13) AN2(-18,-13) AN3(-17,-13) AN4(-16,-13) AN5(-15,-13) AN6(-14,-13) AN7(-13,-13) AN8(-12,-13) AN9(-11,-13) AN10(-10,-13) AN11(-9,-13) AN12(-8,-13) AN13(-7,-13) AN14(-6,-13) AN15(-5,-13) AN16(-4,-13) AN17(-3,-13) AN18(-2,-13) AN19(-1,-13) AN20(0,-13) AN21(1,-13) AN22(2,-13) AN23(3,-13) AN24(4,-13) AN25(5,-13) AN26(6,-13) AN27(7,-13) AN28(8,-13) AN29(9,-13) AN30(10,-13) AN31(11,-13) AN32(12,-13) AN33(13,-13) AN34(14,-13) AN35(15,-13) AN36(16,-13) AN37(17,-13) AN38(18,-13) AN39(19,-13) AP1(-19,-14) AP2(-18,-14) AP3(-17,-14) AP4(-16,-14) AP5(-15,-14) AP6(-14,-14) AP7(-13,-14) AP8(-12,-14) AP9(-11,-14) AP10(-10,-14) AP11(-9,-14) AP12(-8,-14) AP13(-7,-14) AP14(-6,-14) AP15(-5,-14) AP16(-4,-14) AP17(-3,-14) AP18(-2,-14) AP19(-1,-14) AP20(0,-14) AP21(1,-14) AP22(2,-14) AP23(3,-14) AP24(4,-14) AP25(5,-14) AP26(6,-14) AP27(7,-14) AP28(8,-14) AP29(9,-14) AP30(10,-14) AP31(11,-14) AP32(12,-14) AP33(13,-14) AP34(14,-14) AP35(15,-14) AP36(16,-14) AP37(17,-14) AP38(18,-14) AP39(19,-14) AR1(-19,-15) AR2(-18,-15) AR3(-17,-15) AR4(-16,-15) AR5(-15,-15) AR6(-14,-15) AR7(-13,-15) AR8(-12,-15) AR9(-11,-15) AR10(-10,-15) AR11(-9,-15) AR12(-8,-15) AR13(-7,-15) AR14(-6,-15) AR15(-5,-15) AR16(-4,-15) AR17(-3,-15) AR18(-2,-15) AR19(-1,-15) AR20(0,-15) AR21(1,-15) AR22(2,-15) AR23(3,-15) AR24(4,-15) AR25(5,-15) AR26(6,-15) AR27(7,-15) AR28(8,-15) AR29(9,-15) AR30(10,-15) AR31(11,-15) AR32(12,-15) AR33(13,-15) AR34(14,-15) AR35(15,-15) AR36(16,-15) AR37(17,-15) AR38(18,-15) AR39(19,-15) AT1(-19,-16) AT2(-18,-16) AT3(-17,-16) AT4(-16,-16) AT5(-15,-16) AT6(-14,-16) AT7(-13,-16) AT8(-12,-16) AT9(-11,-16) AT10(-10,-16) AT11(-9,-16) AT12(-8,-16) AT13(-7,-16) AT14(-6,-16) AT15(-5,-16) AT16(-4,-16) AT17(-3,-16) AT18(-2,-16) AT19(-1,-16) AT20(0,-16) AT21(1,-16) AT22(2,-16) AT23(3,-16) AT24(4,-16) AT25(5,-16) AT26(6,-16) AT27(7,-16) AT28(8,-16) AT29(9,-16) AT30(10,-16) AT31(11,-16) AT32(12,-16) AT33(13,-16) AT34(14,-16) AT35(15,-16) AT36(16,-16) AT37(17,-16) AT38(18,-16) AT39(19,-16) AU4(-16,-17) AU5(-15,-17) AU6(-14,-17) AU7(-13,-17) AU8(-12,-17) AU9(-11,-17) AU10(-10,-17) AU11(-9,-17) AU12(-8,-17) AU13(-7,-17) AU14(-6,-17) AU15(-5,-17) AU16(-4,-17) AU17(-3,-17) AU18(-2,-17) AU19(-1,-17) AU20(0,-17) AU21(1,-17) AU22(2,-17) AU23(3,-17) AU24(4,-17) AU25(5,-17) AU26(6,-17) AU27(7,-17) AU28(8,-17) AU29(9,-17) AU30(10,-17) AU31(11,-17) AU32(12,-17) AU33(13,-17) AU34(14,-17) AU35(15,-17) AU36(16,-17) AV4(-16,-18) AV5(-15,-18) AV6(-14,-18) AV7(-13,-18) AV8(-12,-18) AV9(-11,-18) AV10(-10,-18) AV11(-9,-18) AV12(-8,-18) AV13(-7,-18) AV14(-6,-18) AV15(-5,-18) AV16(-4,-18) AV17(-3,-18) AV18(-2,-18) AV19(-1,-18) AV20(0,-18) AV21(1,-18) AV22(2,-18) AV23(3,-18) AV24(4,-18) AV25(5,-18) AV26(6,-18) AV27(7,-18) AV28(8,-18) AV29(9,-18) AV30(10,-18) AV31(11,-18) AV32(12,-18) AV33(13,-18) AV34(14,-18) AV35(15,-18) AV36(16,-18) AW4(-16,-19) AW5(-15,-19) AW6(-14,-19) AW7(-13,-19) AW8(-12,-19) AW9(-11,-19) AW10(-10,-19) AW11(-9,-19) AW12(-8,-19) AW13(-7,-19) AW14(-6,-19) AW15(-5,-19) AW16(-4,-19) AW17(-3,-19) AW18(-2,-19) AW19(-1,-19) AW20(0,-19) AW21(1,-19) AW22(2,-19) AW23(3,-19) AW24(4,-19) AW25(5,-19) AW26(6,-19) AW27(7,-19) AW28(8,-19) AW29(9,-19) AW30(10,-19) AW31(11,-19) AW32(12,-19) AW33(13,-19) AW34(14,-19) AW35(15,-19) AW36(16,-19) B4(-16,18) B5(-15,18) B6(-14,18) B7(-13,18) B8(-12,18) B9(-11,18) B10(-10,18) B11(-9,18) B12(-8,18) B13(-7,18) B14(-6,18) B15(-5,18) B16(-4,18) B17(-3,18) B18(-2,18) B19(-1,18) B20(0,18) B21(1,18) B22(2,18) B23(3,18) B24(4,18) B25(5,18) B26(6,18) B27(7,18) B28(8,18) B29(9,18) B30(10,18) B31(11,18) B32(12,18) B33(13,18) B34(14,18) B35(15,18) B36(16,18) C4(-16,17) C5(-15,17) C6(-14,17) C7(-13,17) C8(-12,17) C9(-11,17) C10(-10,17) C11(-9,17) C12(-8,17) C13(-7,17) C14(-6,17) C15(-5,17) C16(-4,17) C17(-3,17) C18(-2,17) C19(-1,17) C20(0,17) C21(1,17) C22(2,17) C23(3,17) C24(4,17) C25(5,17) C26(6,17) C27(7,17) C28(8,17) C29(9,17) C30(10,17) C31(11,17) C32(12,17) C33(13,17) C34(14,17) C35(15,17) C36(16,17) D1(-19,16) D2(-18,16) D3(-17,16) D4(-16,16) D5(-15,16) D6(-14,16) D7(-13,16) D8(-12,16) D9(-11,16) D10(-10,16) D11(-9,16) D12(-8,16) D13(-7,16) D14(-6,16) D15(-5,16) D16(-4,16) D17(-3,16) D18(-2,16) D19(-1,16) D20(0,16) D21(1,16) D22(2,16) D23(3,16) D24(4,16) D25(5,16) D26(6,16) D27(7,16) D28(8,16) D29(9,16) D30(10,16) D31(11,16) D32(12,16) D33(13,16) D34(14,16) D35(15,16) D36(16,16) D37(17,16) D38(18,16) D39(19,16) E1(-19,15) E2(-18,15) E3(-17,15) E4(-16,15) E5(-15,15) E6(-14,15) E7(-13,15) E8(-12,15) E9(-11,15) E10(-10,15) E11(-9,15) E12(-8,15) E13(-7,15) E14(-6,15) E15(-5,15) E16(-4,15) E17(-3,15) E18(-2,15) E19(-1,15) E20(0,15) E21(1,15) E22(2,15) E23(3,15) E24(4,15) E25(5,15) E26(6,15) E27(7,15) E28(8,15) E29(9,15) E30(10,15) E31(11,15) E32(12,15) E33(13,15) E34(14,15) E35(15,15) E36(16,15) E37(17,15) E38(18,15) E39(19,15) F1(-19,14) F2(-18,14) F3(-17,14) F4(-16,14) F5(-15,14) F6(-14,14) F7(-13,14) F8(-12,14) F9(-11,14) F10(-10,14) F11(-9,14) F12(-8,14) F13(-7,14) F14(-6,14) F15(-5,14) F16(-4,14) F17(-3,14) F18(-2,14) F19(-1,14) F20(0,14) F21(1,14) F22(2,14) F23(3,14) F24(4,14) F25(5,14) F26(6,14) F27(7,14) F28(8,14) F29(9,14) F30(10,14) F31(11,14) F32(12,14) F33(13,14) F34(14,14) F35(15,14) F36(16,14) F37(17,14) F38(18,14) F39(19,14) G1(-19,13) G2(-18,13) G3(-17,13) G4(-16,13) G5(-15,13) G6(-14,13) G7(-13,13) G8(-12,13) G9(-11,13) G10(-10,13) G11(-9,13) G12(-8,13) G13(-7,13) G14(-6,13) G15(-5,13) G16(-4,13) G17(-3,13) G18(-2,13) G19(-1,13) G20(0,13) G21(1,13) G22(2,13) G23(3,13) G24(4,13) G25(5,13) G26(6,13) G27(7,13) G28(8,13) G29(9,13) G30(10,13) G31(11,13) G32(12,13) G33(13,13) G34(14,13) G35(15,13) G36(16,13) G37(17,13) G38(18,13) G39(19,13) H1(-19,12) H2(-18,12) H3(-17,12) H4(-16,12) H5(-15,12) H6(-14,12) H7(-13,12) H8(-12,12) H9(-11,12) H10(-10,12) H11(-9,12) H12(-8,12) H13(-7,12) H14(-6,12) H15(-5,12) H16(-4,12) H17(-3,12) H18(-2,12) H19(-1,12) H20(0,12) H21(1,12) H22(2,12) H23(3,12) H24(4,12) H25(5,12) H26(6,12) H27(7,12) H28(8,12) H29(9,12) H30(10,12) H31(11,12) H32(12,12) H33(13,12) H34(14,12) H35(15,12) H36(16,12) H37(17,12) H38(18,12) H39(19,12) J1(-19,11) J2(-18,11) J3(-17,11) J4(-16,11) J5(-15,11) J6(-14,11) J7(-13,11) J8(-12,11) J9(-11,11) J10(-10,11) J11(-9,11) J12(-8,11) J13(-7,11) J14(-6,11) J15(-5,11) J16(-4,11) J17(-3,11) J18(-2,11) J19(-1,11) J20(0,11) J21(1,11) J22(2,11) J23(3,11) J24(4,11) J25(5,11) J26(6,11) J27(7,11) J28(8,11) J29(9,11) J30(10,11) J31(11,11) J32(12,11) J33(13,11) J34(14,11) J35(15,11) J36(16,11) J37(17,11) J38(18,11) J39(19,11) K1(-19,10) K2(-18,10) K3(-17,10) K4(-16,10) K5(-15,10) K6(-14,10) K7(-13,10) K8(-12,10) K9(-11,10) K10(-10,10) K11(-9,10) K12(-8,10) K13(-7,10) K14(-6,10) K15(-5,10) K18(-2,10) K19(-1,10) K20(0,10) K21(1,10) K22(2,10) K23(3,10) K26(6,10) K27(7,10) K28(8,10) K29(9,10) K30(10,10) K31(11,10) K32(12,10) K33(13,10) K34(14,10) K35(15,10) K36(16,10) K37(17,10) K38(18,10) K39(19,10) L1(-19,9) L2(-18,9) L3(-17,9) L4(-16,9) L5(-15,9) L6(-14,9) L7(-13,9) L8(-12,9) L9(-11,9) L10(-10,9) L11(-9,9) L12(-8,9) L13(-7,9) L14(-6,9) L15(-5,9) L16(-4,9) L17(-3,9) L18(-2,9) L19(-1,9) L20(0,9) L21(1,9) L22(2,9) L23(3,9) L24(4,9) L25(5,9) L26(6,9) L27(7,9) L28(8,9) L29(9,9) L30(10,9) L31(11,9) L32(12,9) L33(13,9) L34(14,9) L35(15,9) L36(16,9) L37(17,9) L38(18,9) L39(19,9) M1(-19,8) M2(-18,8) M3(-17,8) M4(-16,8) M5(-15,8) M6(-14,8) M7(-13,8) M8(-12,8) M9(-11,8) M10(-10,8) M11(-9,8) M12(-8,8) M13(-7,8) M14(-6,8) M15(-5,8) M16(-4,8) M17(-3,8) M18(-2,8) M19(-1,8) M20(0,8) M21(1,8) M22(2,8) M23(3,8) M24(4,8) M25(5,8) M26(6,8) M27(7,8) M28(8,8) M29(9,8) M30(10,8) M31(11,8) M32(12,8) M33(13,8) M34(14,8) M35(15,8) M36(16,8) M37(17,8) M38(18,8) M39(19,8) N1(-19,7) N2(-18,7) N3(-17,7) N4(-16,7) N5(-15,7) N6(-14,7) N7(-13,7) N8(-12,7) N9(-11,7) N10(-10,7) N11(-9,7) N12(-8,7) N13(-7,7) N14(-6,7) N15(-5,7) N16(-4,7) N17(-3,7) N18(-2,7) N19(-1,7) N20(0,7) N21(1,7) N22(2,7) N23(3,7) N24(4,7) N25(5,7) N26(6,7) N27(7,7) N28(8,7) N29(9,7) N30(10,7) N31(11,7) N32(12,7) N33(13,7) N34(14,7) N35(15,7) N36(16,7) N37(17,7) N38(18,7) N39(19,7) P1(-19,6) P2(-18,6) P3(-17,6) P4(-16,6) P5(-15,6) P6(-14,6) P7(-13,6) P8(-12,6) P9(-11,6) P10(-10,6) P11(-9,6) P12(-8,6) P13(-7,6) P27(7,6) P28(8,6) P29(9,6) P30(10,6) P31(11,6) P32(12,6) P33(13,6) P34(14,6) P35(15,6) P36(16,6) P37(17,6) P38(18,6) P39(19,6) R1(-19,5) R2(-18,5) R3(-17,5) R4(-16,5) R5(-15,5) R6(-14,5) R7(-13,5) R8(-12,5) R9(-11,5) R10(-10,5) R11(-9,5) R12(-8,5) R13(-7,5) R27(7,5) R28(8,5) R29(9,5) R30(10,5) R31(11,5) R32(12,5) R33(13,5) R34(14,5) R35(15,5) R36(16,5) R37(17,5) R38(18,5) R39(19,5) T1(-19,4) T2(-18,4) T3(-17,4) T4(-16,4) T5(-15,4) T6(-14,4) T7(-13,4) T8(-12,4) T9(-11,4) T10(-10,4) T11(-9,4) T12(-8,4) T13(-7,4) T27(7,4) T28(8,4) T29(9,4) T30(10,4) T31(11,4) T32(12,4) T33(13,4) T34(14,4) T35(15,4) T36(16,4) T37(17,4) T38(18,4) T39(19,4) U1(-19,3) U2(-18,3) U3(-17,3) U4(-16,3) U5(-15,3) U6(-14,3) U7(-13,3) U8(-12,3) U9(-11,3) U10(-10,3) U11(-9,3) U12(-8,3) U13(-7,3) U27(7,3) U28(8,3) U29(9,3) U30(10,3) U31(11,3) U32(12,3) U33(13,3) U34(14,3) U35(15,3) U36(16,3) U37(17,3) U38(18,3) U39(19,3) V1(-19,2) V2(-18,2) V3(-17,2) V4(-16,2) V5(-15,2) V6(-14,2) V7(-13,2) V8(-12,2) V9(-11,2) V10(-10,2) V11(-9,2) V12(-8,2) V13(-7,2) V27(7,2) V28(8,2) V29(9,2) V30(10,2) V31(11,2) V32(12,2) V33(13,2) V34(14,2) V35(15,2) V36(16,2) V37(17,2) V38(18,2) V39(19,2) W1(-19,1) W2(-18,1) W3(-17,1) W4(-16,1) W5(-15,1) W6(-14,1) W7(-13,1) W8(-12,1) W9(-11,1) W10(-10,1) W11(-9,1) W12(-8,1) W13(-7,1) W27(7,1) W28(8,1) W29(9,1) W30(10,1) W31(11,1) W32(12,1) W33(13,1) W34(14,1) W35(15,1) W36(16,1) W37(17,1) W38(18,1) W39(19,1) Y1(-19,0) Y2(-18,0) Y3(-17,0) Y4(-16,0) Y5(-15,0) Y6(-14,0) Y7(-13,0) Y8(-12,0) Y9(-11,0) Y10(-10,0) Y11(-9,0) Y12(-8,0) Y13(-7,0) Y27(7,0) Y28(8,0) Y29(9,0) Y30(10,0) Y31(11,0) Y32(12,0) Y33(13,0) Y34(14,0) Y35(15,0) Y36(16,0) Y37(17,0) Y38(18,0) Y39(19,0)
