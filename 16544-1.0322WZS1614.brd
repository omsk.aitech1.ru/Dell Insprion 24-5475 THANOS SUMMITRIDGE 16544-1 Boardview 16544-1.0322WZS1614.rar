# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1V_VDDCI_VGA: length 150.1
  TOP w0.381: GPU1.R20 67.97,187 v6(67.48,186.51) ; GPU1.Y15 v6(63.5,181.5) ; GPU1.R28 GPU1.T27 ; GPU1.T27 GPU1.U28 ; GPU1.T27 74.56,186.44 v6(74.52,186.44) 74.52,186.48 GPU1.R26 74,186.9 v6(73.53,186.44) 73.46,186.51 73.43,186.51 73,186.94 GPU1.R25 72.77,187 72.73,187.05 72.27,187.05 72.23,187 GPU1.R24 v6(71.5,186.5) ; GPU1.V29 GPU1.U28 ; GPU1.U28 v6(76.5,185.5) GPU1.T29 ; GPU1.AA14 62.2,180.78 v6(61.82,181.15) ; GPU1.V15 v6(63.5,183.5) GPU1.W15 ; GPU1.R16 v6(63.5,186.5) GPU1.T15 ; GPU1.AH15 63,174 v6(63.5,174.5) 64,175 GPU1.AG16 ; v6(68.78,188.21) 68.84,188.21 69.25,187.8 GPU1.P21 GPU1.P23 ; GPU1.AC14 62.2,179.25 v6(61.75,178.8) ; GPU1.R19 67,186.96 v6(66.52,186.49) 66.01,187 GPU1.R18 ; GPU1.AJ18 66,173.03 v1(65.5,173.53) 65.47,173.53 65,174 GPU1.AH17 ; GPU1.AF15 GPU1.AE15 63,177 v1(63.47,177.47) 63,177.94 GPU1.AD15 ; GPU1.AJ16 v6(63.5,173.5)
  TOP w0.508: v1(107.44,137.59) 108.46,137.59 109.58,136.47 117.96,136.47 119,137.52 119,139.2 PR260.1
  TOP w0.635: 110.08,217.94 PT42.1 ; PT42.1 111.14,219 ; PT42.1 109.03,219 ; PT42.1 110.08,220.05 ; PT43.1 111.11,211.18 ; PT43.1 110.06,210.12 ; PT43.1 109,211.18 ; PT43.1 110.06,212.23
  L3 w0.635: 109,211.18 PT43.1 ; PT43.1 111.11,211.18 ; PT43.1 110.06,212.23 ; PT43.1 110.06,210.12 ; PT42.1 111.14,219 ; PT42.1 109.03,219 ; PT42.1 110.08,217.94 ; PT42.1 110.08,220.05
  L4 w0.508: 88.39,182.63 88.39,181.79 89.08,181.1 90.45,181.1 91.16,181.81 100.56,181.81 103.69,184.94 105.71,184.94 109.32,181.33 109.32,173.08 107.82,171.58 107.82,170.46 107.37,170 105.25,170 104.1,168.86 104.1,167.49 104.75,166.85 104.75,157.48 105.98,156.25 105.98,145.66 106.58,145.06 106.58,138.46 v1(107.44,137.59)
  L4 w0.635: 110.08,217.94 PT42.1 ; PT42.1 111.14,219 ; PT42.1 109.03,219 ; 110.06,210.12 PT43.1 ; PT43.1 110.06,212.23 ; PT43.1 109,211.18 ; PT43.1 111.11,211.18
  BOTTOM w0.381: C700.1 66.56,172.58 66.08,173.06 65.97,173.06 v1(65.5,173.53) ; C702.1 77.19,184.14 76.95,184.39 76.95,184.51 C703.1 76.64,185.36 v6(76.5,185.5) ; C718.1 63.74,173.26 v6(63.5,173.5) 62.63,172.63 C725.1 62.42,172.35 C701.1 ; v6(73.53,186.44) 73.53,186.48 73.07,186.94 C723.1 ; v6(63.5,186.5) 63.21,186.79 C717.1 ; v6(71.5,186.5) 71.45,186.55 71.45,186.94 71.04,187.35 C716.1 70.73,187.47 70.7,187.49 70.6,187.53 70.49,187.54 70.25,187.54 C726.1 ; v6(61.82,181.15) 61.51,180.84 61.51,180.25 C724.1
  vias: v3(116.33,222.76) v3(117.6,218.06) v4(108.79,216.18) v4(108.81,214.78) v4(108.79,213.51) v4(110.03,216.18) v4(110.03,213.51) v4(110.06,214.78) v4(111.3,216.18) v4(111.33,214.78) v4(117.53,222.73) v4(117.5,221.46) v4(118.75,221.46) v4(118.77,222.73) v5(116.33,222.63) v6(64.01,188.19) v6(71.2,188.25)
1V_VDDCR_CPU: length 152
  TOP w0.254: CPU1.U2 173.11,180.89 173.11,180.56 173.55,180.12 173.88,180.12 CPU1.T3 174.46,179.54 174.46,177.46 CPU1.T6 ; CPU1.N6 177.5,177.5 177.5,179.53 177.02,180 CPU1.N3
  TOP w0.381: CPU1.W6 v6(171.46,177.46) ; v6(167.44,179.48) 167.46,179.48 167.98,180 CPU1.AB3 v6(167.5,180.5) CPU1.AC2 v6(167.5,181.5) ; CPU1.N6 v6(177.5,176.5) CPU1.M7 ; CPU1.AK9 v6(159.52,173.54) ; CPU1.N3 176.95,180 176,180.95 CPU1.P2 ; CPU1.AH6 v6(162.5,176.5) CPU1.AG7 ; CPU1.Y2 170.03,181 v6(170.5,180.53) 170.58,180.45 CPU1.W3 ; CPU1.AC10 CPU1.AD9 v6(165.5,173.5) CPU1.AE10 CPU1.AF11 v6(163.5,171.5) CPU1.AG12 v6(162.5,171.5) CPU1.AH11 v6(161.5,172.5) CPU1.AJ10 v6(161.49,173.48) ; CPU1.AC10 v6(167.5,173.5) CPU1.AB9 ; CPU1.AC10 CPU1.AD11 ; CPU1.AB13 v6(168.5,170.5) CPU1.AA12 v6(169.5,171.5) CPU1.Y11 ; CPU1.AV14 152,168.97 v6(152.53,168.44) CPU1.AU15 ; v6(161.5,166.5) CPU1.AH17 CPU1.AG18 ; CPU1.W10 v6(171.5,172.5) CPU1.V11 ; v6(161.5,181.5) CPU1.AJ2 v6(161.5,180.5) CPU1.AH3 ; CPU1.AM8 157.49,175.51 v6(157.48,175.51) 157.48,175.52 CPU1.AN7 ; CPU1.AG16 v6(162.5,167.5) CPU1.AH15 v6(161.5,168.5) CPU1.AJ14 ; CPU1.AP12 v6(156.55,170.49) CPU1.AN13 ; CPU1.AU9 v6(152.5,174.5) CPU1.AV8 ; CPU1.AG24 v6(162.46,159.54) CPU1.AH23 v6(161.5,160.5) CPU1.AJ22 v6(161.5,161.5) CPU1.AH21 ; CPU1.AG20 CPU1.AH19 v6(161.58,164.49) ; CPU1.V9 v6(172.5,173.5) CPU1.U10 ; CPU1.AP3 155.46,180.54 v6(155.45,180.54) 155.45,180.55 CPU1.AR2 ; CPU1.AF9 v6(163.5,173.5) CPU1.AG10 v6(162.5,173.5) CPU1.AH9 ; CPU1.AU12 v6(152.5,171.5) CPU1.AV11 ; CPU1.AD11 v6(165.5,171.5) CPU1.AE12 CPU1.AF13 v6(163.53,169.53) CPU1.AG14 v6(162.51,169.52) CPU1.AH13 v6(161.5,170.5) CPU1.AJ12 v6(160.5,171.5) CPU1.AK11 v6(159.5,172.5) CPU1.AL10 ; CPU1.AD11 CPU1.AC12 ; CPU1.AE6 v6(165.5,176.5) CPU1.AD7 ; CPU1.AH21 v6(162.5,161.5) CPU1.AG22 ; CPU1.AH21 v6(161.5,162.5) ; CPU1.AA7 v6(168.5,176.5) CPU1.AB6 ; CPU1.AP9 v6(156.46,173.48) CPU1.AN10 ; CPU1.AM2 v6(158.5,180.5) CPU1.AL3 ; CPU1.AU6 v6(153.5,176.5) ; v6(173.53,177.44) 173.53,177.43 173.96,177 CPU1.T6 CPU1.R7 ; CPU1.AK13 v6(159.5,170.5) CPU1.AL12 ; CPU1.AV5 v6(151.49,177.5) ; CPU1.AT4 v6(153.5,179.5) CPU1.AU3 ; CPU1.AK7 v6(159.51,176.52) CPU1.AL6 ; CPU1.AC12 v6(167.5,171.5) CPU1.AB11 v6(168.5,172.5) CPU1.AA10 v6(169.5,173.5) CPU1.Y9 ; CPU1.AC12 CPU1.AD13 165.79,169.81 165.53,169.55 v6(165.51,169.55) ; CPU1.AE3 v6(164.5,180.5) CPU1.AF2 v6(164.5,181.5) ; CPU1.AL14 v6(159.54,169.47) ; CPU1.T9 v6(173.5,174.5) ; CPU1.W12 v6(171.5,170.5) ; CPU1.AH27 v6(162.5,156.5) CPU1.AG26 v6(162.5,157.5) CPU1.AH25 v6(161.5,158.5) CPU1.AJ24
  L4 w0.406: 202.93,199.19 206.35,199.19 208.51,201.35 208.51,203.5 210.13,205.13 210.57,205.56 210.57,205.64 211.35,206.43 v1(211.35,206.96)
  L4 w0.635: 190.33,193.52 PT8.1 ; PT8.1 191.39,194.58 ; PT8.1 191.39,192.47 ; PT8.1 192.44,193.52 ; 175.55,193.34 PT11.1 ; PT11.1 176.61,194.4 ; PT11.1 177.66,193.34 ; PT11.1 176.61,192.29 ; PT12.1 183.95,197.12 ; PT12.1 183.95,195.01 ; PT12.1 185,196.06 ; PT12.1 182.89,196.06 ; PT7.1 199.84,196.09 ; PT7.1 198.78,197.14 ; PT7.1 198.78,195.03 ; PT7.1 197.73,196.09 ; 160.21,195.83 PT15.1 ; PT15.1 162.32,195.83 ; PT15.1 161.26,194.78 ; PT15.1 161.26,196.89 ; PT16.1 170.19,195.94 ; PT16.1 168.08,195.94 ; PT16.1 169.14,194.88 ; PT16.1 169.14,196.99
  BOTTOM w0.406: PR110.1 212.89,209.03 212.39,208.53 212.39,207.98 211.38,206.96 v1(211.35,206.96)
  BOTTOM w0.508: v6(152.53,168.44) 153.59,167.39 C36.1 ; C51.1 152.27,171.73 v6(152.5,171.5) ; v6(151.49,177.5) 151.34,177.65 C28.1 ; C56.1 155.73,180.82 v6(155.45,180.54) ; v6(158.5,180.5) 159.1,179.9 C50.1 ; C57.1 156.33,173.35 v6(156.46,173.48) 156.72,173.74 C27.1
  vias: v2(161.44,177.37) v2(162.33,163.47) v2(169.47,174.52) v2(172.61,180.47) v2(182.75,205.49) v2(195.96,200.41) v4(158.47,202.41) v4(158.47,201.35) v4(158.47,200.28) v4(159.54,202.41) v4(159.54,201.35) v4(159.54,200.28) v4(160.6,202.41) v4(160.6,201.35) v4(160.6,200.28) v4(163.8,202.56) v4(163.78,201.42) v4(164.85,202.54) v4(164.85,201.47) v4(165.91,202.54) v4(165.91,201.47) v4(166.98,202.54) v4(166.98,201.47) v4(168.05,202.54) v4(168.05,201.47) v4(169.11,202.54) v4(169.11,201.47) v4(170.05,205.41) v4(170.05,204.34) v4(170.18,202.54) v4(170.18,201.47) v4(171.48,202.56) v4(171.48,201.5) v4(172.54,202.56) v4(172.54,201.5) v4(173.61,202.56) v4(173.61,201.5) v4(174.68,202.56) v4(174.68,201.5) v4(175.74,202.56) v4(175.74,201.5) v4(176.81,202.56) v4(176.81,201.5) v4(181.41,202.67) v4(181.41,201.6) v4(181.41,200.53) v4(182.47,202.67) v4(182.47,201.6) v4(182.47,200.53) v4(183.54,202.67) v4(183.54,201.6) v4(183.54,200.53) v4(184.61,202.67) v4(184.61,201.6) v4(184.61,200.53) v4(185.67,202.67) v4(185.67,201.6) v4(185.67,200.53) v4(186.31,206.12) v4(186.31,205.1) v4(186.31,204.09) v4(186.74,202.67) v4(186.74,201.6) v4(186.74,200.53) v4(187.81,202.67) v4(187.81,201.6) v4(187.81,200.53) v4(188.87,201.6) v4(188.87,200.53) v4(189.94,201.6) v4(189.94,200.53) v4(191.01,201.6) v4(191.01,200.53) v4(192.07,201.6) v4(192.07,200.53) v4(193.14,201.6) v4(193.14,200.53) v4(194.21,201.6) v4(194.21,200.53) v4(197.03,202.72) v4(197.03,201.65) v4(198.17,202.74) v4(198.17,201.68) v4(199.24,202.74) v4(199.24,201.68) v4(200.3,202.74) v4(200.3,201.68) v4(201.37,202.74) v4(201.37,201.68) v4(202.44,202.74) v4(202.44,201.68) v6(155.56,172.54) v6(156.56,172.54) v6(158.53,172.54) v6(158.5,171.5) v6(158.51,170.49) v6(161.51,169.52) v6(161.5,167.5) v6(161.52,163.53) v6(161.5,159.54) v6(163.65,156.95) v6(164.13,167.51) v6(164.16,168.28) v6(164.24,157.58) v6(164.44,158.27) v6(164.59,159.69) v6(164.59,158.98) v6(164.74,161.59) v6(164.82,168.63) v6(164.77,167.87) v6(164.77,167.13) v6(164.8,163.86) v6(165.35,164.77) v6(165.51,168.83) v6(165.46,168.07) v6(166.12,164.77) v6(166.17,168.33) v6(166.78,160.45) v6(167,168.33) v6(167.54,169.42) v6(168.02,168.86) v6(168.51,169.4) v6(169.01,168.78) v6(169.24,168.1) v6(169.21,167.34) v6(169.21,164.8) v6(169.34,169.44) v6(171.5,180.5) v6(172.51,172.51)
1V_VDDCR_SOC: length 185.3
  TOP w0.254: CPU1.B20 CPU1.C19 ; CPU1.K6 180,177.35 180.46,177.81 180.46,179.19 180,179.65 CPU1.K3 179.88,180.12 179.55,180.12 179.11,180.56 179.11,180.89 CPU1.L2
  TOP w0.381: v6(184.49,170.52) 184.45,170.52 CPU1.F13 ; CPU1.C10 v6(187.5,173.5) ; CPU1.P11 v6(175.5,171.5) CPU1.R12 ; CPU1.L22 v6(178.5,161.5) CPU1.M21 v6(177.5,162.5) CPU1.N20 ; CPU1.K11 180.41,172.51 v6(180.48,172.51) 180.48,172.56 CPU1.J10 ; CPU1.N22 v6(177.5,160.5) CPU1.M23 v6(178.5,159.5) CPU1.L24 ; CPU1.L26 v6(178.5,157.5) CPU1.M25 v6(177.5,158.5) CPU1.N24 ; CPU1.L12 v6(179.5,171.5) ; CPU1.N10 v6(177.5,172.5) CPU1.M11 ; CPU1.M19 v6(178.5,164.5) CPU1.L18 ; CPU1.N16 v6(177.5,167.5) CPU1.M15 178.09,168 v6(178.49,168.4) 179,168.91 CPU1.L14 CPU1.K13 180.5,170.5 180.5,170.53 v6(180.51,170.54) 180.51,170.6 180.91,171 CPU1.J12 v6(181.45,171.45) ; CPU1.B5 v6(187.53,178.48) CPU1.C4 ; CPU1.F16 v6(183.5,167.5) CPU1.G15 ; CPU1.T13 v6(173.5,170.5) CPU1.U12 ; CPU1.P9 v6(175.5,173.5) CPU1.R10 ; CPU1.J16 181,167 v6(180.49,167.52) 180,168 CPU1.K15 ; CPU1.B17 188,166.02 v6(187.51,166.51) 187.02,167 CPU1.C16 ; CPU1.K9 v6(179.5,173.48) CPU1.L10 v6(178.51,173.51) CPU1.M9 ; CPU1.L20 v6(179.5,162.5) ; CPU1.K15 v6(179.5,167.5) CPU1.L16 CPU1.M17 v6(177.5,165.5) CPU1.N18 ; CPU1.K15 180.4,168.4 v6(180.5,168.4) 181,168.91 CPU1.J14 ; CPU1.K6 CPU1.J7 v6(181.51,175.49) ; CPU1.C19 v6(187.5,164.5) ; CPU1.B8 v6(187.5,174.5) ; v6(182.47,165.52) 183,165 CPU1.G18 ; CPU1.T11 v6(173.5,172.5) ; CPU1.B14 CPU1.C13 187.52,170.5 v6(187.52,170.51) ; CPU1.M13 v6(177.5,170.5) CPU1.N12 ; CPU1.B11 v6(188.5,172.5) ; CPU1.V13 v6(172.5,170.5) ; CPU1.N26 v6(177.5,156.5) ; CPU1.G12 v6(183.5,171.5) ; CPU1.C7 v6(187.51,175.49)
  TOP w0.406: CPU1.G9 v6(183.5,173.5) CPU1.F10 ; CPU1.G3 v6(182.5,180.5) CPU1.H2 ; CPU1.G6 v6(183.5,176.5) CPU1.F7 ; CPU1.C4 187,179 v6(186.47,179.52) 186,180 CPU1.D3 v6(185.5,180.5) CPU1.E2
  TOP w0.635: 222,160.74 PT19.1 ; PT19.1 222,162.85 ; PT19.1 223.05,161.8 ; PT19.1 220.94,161.8 ; PT20.1 214.12,162.85 ; PT20.1 213.07,161.8 ; PT20.1 214.12,160.74 ; PT20.1 215.18,161.8 ; 203.01,161.85 PT17.1 ; PT17.1 205.12,161.85 ; PT17.1 204.06,162.9 ; PT17.1 204.06,160.79
  L4 w0.635: PT19.1 222,162.85 ; PT19.1 223.05,161.8 ; PT19.1 220.94,161.8 ; PT19.1 222,160.74 ; 203.01,161.85 PT17.1 ; PT17.1 204.06,160.79 ; PT17.1 204.06,162.9 ; PT17.1 205.12,161.85 ; PT20.1 215.18,161.8 ; PT20.1 214.12,160.74 ; PT20.1 214.12,162.85 ; PT20.1 213.07,161.8 ; 202.91,171.55 PT18.1 ; PT18.1 205.02,171.55 ; PT18.1 203.96,172.61 ; PT18.1 203.96,170.5
  L6 w0.508: v1(132.41,206.81) 132.41,204.75 133.12,204.04 133.12,203.9 137.7,199.31 139.37,199.31 140.18,198.5 141.81,198.5 142.63,197.68 142.91,197.68 145.32,195.27 145.82,195.27 145.82,195.28 157.51,195.28 158.9,193.88 172.42,193.88 173.52,194.98 186.47,194.98 187.35,195.86 192.03,195.86 197.59,190.3 197.59,187.15 197.59,180.06 196.9,179.37 v1(196.52,179.37)
  BOTTOM w0.508: v1(198.12,172.06) 197.73,171.67 PR71.2
  BOTTOM w0.635: 203.96,172.61 PT18.1 205.02,171.55
  vias: v2(186.49,180.34) v2(187.58,168.78) v2(189.87,179.68) v2(191.01,171.27) v4(208.48,169.75) v4(208.61,167.92) v4(208.71,172.06) v4(209.3,170.81) v4(209.52,168.99) v4(209.52,167.03) v4(210.31,168.02) v4(210.39,169.85) v4(210.49,171.6) v4(211.28,166.8) v4(211.48,169.32) v4(211.46,168.02) v4(211.56,171.6) v4(211.68,164.24) v4(212.24,163.12) v4(216.89,168.15) v4(216.97,171.68) v4(217.02,166.75) v4(217.63,170.31) v4(218.03,171.68) v4(218.19,163.02) v4(218.44,166.09) v4(219.02,169.21) v4(219.18,167.69) v4(219.38,171.17) v4(219.84,166.12) v4(219.76,164.39) v4(220.34,170) v4(220.6,168.3) v4(221.16,171.25) v4(221.39,167.13) v4(221.79,169.09) v4(222.78,171.3) v4(223.06,167.72) v4(223.47,169.21) v4(224.51,166.12) v4(224.97,163.3) v4(224.97,160.81) v4(225.78,164.74) v4(225.78,162.26) v4(226.19,166.24) v4(227.03,163.6) v4(227.03,161.11) v4(227.91,166.34) v4(227.97,164.82) v5(212.98,170.18) v5(215.52,167.64) v6(170.89,161.49) v6(171.6,161.52) v6(175.21,162.43) v6(175.21,160.58) v6(175.31,166.75) v6(175.34,166.01) v6(175.34,161.67) v6(175.44,167.74) v6(175.36,165.18) v6(175.39,164.39) v6(175.36,163.53) v6(175.36,159.84) v6(175.57,168.48) v6(175.79,162.84) v6(175.81,160.98) v6(175.95,162.08) v6(175.92,159.33) v6(176.02,167.08) v6(176.12,163.83) v6(176.38,168.53) v6(176.35,167.72) v6(183.51,170.51) v6(188.47,173.46) v6(189.59,173.51) v6(190.17,176.3) v6(190.35,178.99) v6(190.58,173.56) v6(191.06,176.25) v6(191.34,174.37) v6(191.34,173.61)
3V_5V_POK: length 4.2
  TOP w0.114: PR64.2 102.16,23.51 102.04,23.62 TP117.1 101.3,23.57 PR63.2 101.45,24.83 PR65.2
5V_3D3V_S0_EN: length 7.2
  TOP w0.114: C929.1 141.35,13.47 v3(141.35,12.73) R861.2 ; C929.1 140.36,13.72 140.02,14.05 U33.3 ; C929.1 141.11,14.54 140.64,15.01 140.21,15.01 140.05,14.85 U33.5
5V_CODEC_DIGITAL_S0: length 5.6
  BOTTOM w0.508: v5(193.91,54.94) R2730.1 193.99,53.46 R2731.1 193.83,52.09 193.83,50.95 D6.K 193.73,50.8 L9.2
5V_CODEC_S0: length 1.4
  TOP w0.203: U6.45 197.15,43.96 197.08,44.04 v4(196.85,44.04)
  vias: v2(196.93,45.14)
5V_S0: length 123.6
  TOP w0.508: v4(166.62,13.08) 166.5,12.95 166.5,9.77 166.5,9.77 RPWRC1.7 ; v1(95.12,48.85) 93.4,48.85 90.4,45.85 89.53,45.85 89.07,46.3 88.42,46.3 87.96,45.85 v1(86.11,45.85)
  L4 w0.508: v1(86.11,45.85) 86.11,45.82 87.38,44.55 87.38,33.96 85.98,32.56 85.98,30.58 86.23,30.33 86.23,18.14 86.61,17.75 86.61,15.75 v4(87.76,14.61)
  L6 w0.305: 119.13,77.34 117.68,75.9 118.52,75.9 119.02,75.39 121.22,75.39 LPC1.8 121.14,77.34 119.13,77.34
  L6 w0.508: v1(95.12,48.85) 95.22,48.75 96.75,48.75 97.46,49.46 97.46,57.38 97.99,57.91 97.99,59.05 99.99,61.05 99.99,61.66 102.08,63.75 102.08,69.03 105.29,72.24 110.06,72.24 113.72,75.9 117.68,75.9
  L6 w1.27: 177.29,17.53 177.72,17.53 182.68,22.48
  BOTTOM w0.635: R2731.2 191.02,50.8 191.02,43.29 192.28,42.04 192.28,40.77 192.53,40.51
  vias: v1(174.86,15.91) v1(175.11,17.88) v1(183.67,23.09) v1(183.97,23.93) v2(133.53,9.42) v2(160.15,15.67) v2(171.32,15.75) v2(188.57,34.8) v4(88.27,13.34) v4(88.82,14.35) v4(136.09,12.57) v4(136.91,12.06) v5(87.63,11.23) v5(97.03,3.71) v5(124.76,5.36)
5V_S0_CT1: length 4.1
  TOP w0.203: 136.25,13.89 136.4,14.05 U33.12
  TOP w0.254: 136.25,13.89 135.56,13.89 134.81,13.14 C931.1 v3(134.81,11.67)
5V_S5: length 979.9
  TOP w0.203: U39.4 145.15,40.47 v1(145.19,40.44) ; U33.4 v1(140.44,14.45) ; PG10.2 PG9.1 PG15.1 PG22.2 PG30.2 PG233.2 PG232.1 138.63,32.69 139.19,32.13
  TOP w0.305: PU43.3 48.36,119.74 v1(48.16,119.94) 48.46,120.24 PU43.2 ; PU40.3 96.46,119.72 v1(96.29,119.89) 96.62,120.22 PU40.2 ; PU46.2 137.24,218.87 136.78,218.41 136.78,217.81 v1(136.91,217.68) 137.74,218.51 PU46.3 ; PU41.3 59.43,119.74 v1(59.26,119.91) 59.59,120.24 PU41.2 ; PU45.2 37.36,120.24 v1(37.03,119.91) 37.21,119.74 PU45.3 ; PU44.3 73.83,119.72 v1(73.46,120.09) 73.56,120.09 73.68,120.22 PU44.2 ; 100.39,40.32 100.14,40.32 99.85,40.61 U12.1 ; OSDC1.8 8.01,135.25 ; PU42.2 85.06,120.22 v1(84.76,119.91) 84.96,119.72 PU42.3
  TOP w0.406: C451.1 129.48,204.66 129.91,205.09 U17.4 ; U36.3 124.15,197.92 122.81,199.26
  TOP w0.508: v1(134.39,208) 134.95,207.44 135.15,207.44 PC418.1 136.08,207.26 136.2,207.39 PU53.6 ; PR287.2 47.39,120.57 48.02,119.94 v1(48.16,119.94) ; 121.28,199.01 121.28,193.55 121.79,193.04 v1(121.79,191.92) ; v1(123.83,201.93) 123.83,202.06 124.46,202.69 PU38.6 ; PR164.2 217.67,140.73 218.26,140.13 v1(218.26,140.11) 218.29,140.08 PR163.2 ; v1(10.62,132.46) 10.59,132.49 10.13,132.49 8.56,134.06 8.56,134.7 8.01,135.25 ; PR104.2 PR102.2 222.35,215.6 v1(222.96,214.99) ; PR301.2 72.26,120.26 PC357.1 73.31,120.24 v1(73.46,120.09) ; PR423.2 15.61,208.64 PR424.2 15.24,208.24 v1(15.24,207.01) ; v1(128.71,61.09) 128.71,60.31 PC486.1 129.51,60.3 129.92,60.71 PU56.6 ; v1(127.89,204.72) 127.95,204.66 C451.1 ; PR288.2 84.68,119.91 v1(84.76,119.91) ; v1(136.91,217.68) 137.67,216.92 PC365.1 137.42,216.34 136.98,215.91 136.98,215.75 136.64,215.4 PR313.2 136.24,214.62 v1(136.55,214.31) ; v1(95.07,62.94) 94.91,62.78 R385.1 ; PR154.1 224.38,202.56 225.32,203.5 225.32,208.51 224.13,209.7 219.81,209.7 218.34,208.24 217.35,208.24 v1(217.2,208.08) 217.2,208.08 217.04,207.92 217.04,206.2 216.61,205.77 PR145.1 ; PU55.6 106.12,160.73 ; PU51.6 138.3,65.46 138.05,65.2 PC433.1 137.92,65.2 137.41,65.71 v1(136.73,65.71) ; v1(96.29,119.89) 96.22,119.96 95.94,119.96 95.4,120.5 PR273.2 ; R2765.1 R2763.1 120.45,112.8 116.87,116.38 110.64,116.38 109.42,117.6 109.42,123.27 v1(109.65,123.5) ; PR84.2 222.71,225.58 v1(222.19,226.1) ; PR274.2 58.34,120.83 v1(59.26,119.91) ; R2759.1 128.22,129.41 128.52,129.11 v1(129.08,129.11) 130.38,129.11 PC262.1 131.67,127.81 PU37.6 ; PC268.1 122.68,200.41 122.68,199.64 ; v1(37.03,119.91) 36.58,119.91 36.19,120.3 PC358.1 36.07,120.44 36.07,120.95 PR302.2
  TOP w0.61: RPWRC1.6 v4(167.5,5.08) ; RPWRC1.8 v4(166.5,5.08)
  TOP w0.635: PC268.1 123.19,201.29 v1(123.83,201.93) ; 106.12,160.73 106.54,160.31 106.63,160.31 PC456.1 106.63,159.43 v1(106.93,159.13)
  L3 w0.508: v1(130.15,210.97) 129.54,210.36 129.54,205.61 128.65,204.72 v1(127.89,204.72) ; v1(96.29,119.89) 94.89,121.28 87.02,121.28 85.65,119.91 v1(84.76,119.91) 84.76,121.06 83.82,122 76.61,122 74.7,120.09 v1(73.46,120.09) 72.03,120.09 70.79,121.34 63.22,121.34 63.2,121.31 59.84,121.31 59.64,121.51 v1(59.64,121.63) 57.28,121.63 56.86,122.05 55.45,122.05 55.32,121.92 52.13,121.92 51.42,121.21 49.95,121.21 49.49,121.67 v1(49.15,121.67) 47.7,121.67 47.68,121.64 46.1,121.64 45.95,121.79 39.01,121.79 37.13,119.91 v1(37.03,119.91) ; v1(136.55,214.31) 136.27,214.03 136.27,208.66 135.53,207.92 134.47,207.92 v1(134.39,208) ; v1(202.13,183.46) 203.53,182.07 203.53,176.23 202.67,175.36 202.67,171 208.15,165.51 208.15,161.7 211.01,158.84 211.01,158.84 211.28,158.58 214.86,158.58 218.47,154.97 218.47,151.38 218.57,151.28 218.57,144.78 217.48,143.69 217.48,140.89 v1(218.26,140.11)
  L3 w1.016: v1(220.98,18.57) 221.46,18.08 221.46,15.43 221.49,15.4 221.49,15.38 221.92,14.95 221.92,14.94 222.61,14.25 222.61,12.8 221.46,11.66 221.46,8.56 218.87,5.97 209.55,5.97 208.91,6.6 192.17,6.6 189.58,9.19 185.01,9.19 ; v4(139.67,36.96) 139.67,37.08 137.21,39.55 132.33,39.55 130.28,41.61 121.76,41.61 121.41,41.96 111.96,41.96 110.67,40.67 108.97,40.67 103.2,34.9 102.11,34.9 101.4,34.19 v4(101.4,33.78)
  L4 w0.508: v1(195.73,54.51) 192.94,54.51 190.8,52.37 190.8,43.23 191.36,42.67 193.52,42.67 194.26,41.94 197.21,41.94 200.08,39.07 210.19,39.07 211.64,40.51 214.25,40.51 215.44,39.32 215.44,36.65 215.92,36.18 215.98,36.18 218.63,33.53 219.28,33.53 v1(219.3,33.5) ; v1(203.02,66.27) 204.01,67.26 211.76,67.26 212.75,66.27 216.31,66.27 v1(216.97,65.61) ; v1(218.26,140.11) 216.92,140.11 215.82,139.01 215.82,137.01 215.82,135.9 215.08,135.15 213.84,133.91 212.57,133.91 210.03,131.37 210.03,121.74 210.19,121.59 210.19,117.4 211.48,116.1 211.48,116 213.26,114.22 213.26,101.83 210.78,99.35 210.78,84.34 211.07,84.05 v1(211.07,83.19)
  L6 w0.508: v1(130.15,210.97) 130.28,210.97 131.83,209.42 132.59,209.42 134.01,208 v1(134.39,208) ; v1(106.93,159.13) 110.11,159.13 111.57,160.59 116.07,160.59 116.13,160.53 ; v4(96.22,84.15) 96.22,81.91 93.62,79.32 93.62,75.34 94.67,74.3 94.67,70.91 93.75,70 93.75,63.53 94.34,62.94 v1(95.07,62.94) ; v1(128.71,61.09) 129.02,61.39 129.41,61.39 129.51,61.49 131.52,61.49 135.74,65.71 v1(136.73,65.71) ; v1(15.24,207.01) 17.53,207.01 20.07,204.47 20.07,171.52 17.99,169.44 17.97,169.44 10.69,162.17 10.69,159.31 8.84,157.45 8.84,156.06 8.79,156.02 8.79,143.67 8.76,143.64 8.76,134.22 10.34,132.64 10.44,132.64 v1(10.62,132.46) ; v1(121.79,191.92) 121.79,190.86 116.48,185.55 116.48,183.16 115.39,182.07 115.39,168.97 116.13,168.23 116.13,160.53 ; 116.13,160.53 116.13,155.61 116.81,154.92 116.81,147.29 113.39,143.87 113.39,139.01 116.76,135.64 116.76,127.76 v1(114.83,125.83) ; v1(209.78,219.53) 211.46,221.21 211.46,226.47 213.13,228.14 216,228.14 217.35,226.8 220.75,226.8 221.41,226.14 222.15,226.14 v1(222.19,226.1) 222.22,226.1 222.48,225.83 222.48,215.47 v1(222.96,214.99) 223.01,214.93 223.01,213.46 218.47,208.91 218.03,208.91 v1(217.2,208.08) 217.2,208.08 216.2,207.09 213.04,207.09 211.57,205.61 210.31,205.61 206.55,201.85 205.38,201.85 204.55,201.02 204.55,196.73 203.66,195.84 203.66,194.03 200.33,190.7 200.33,188.29 200.33,185.27 v1(202.13,183.46)
  BOTTOM w0.203: 139.17,32.05 138.63,32.59 PG232.1 PG233.2 PG30.2 PG22.2 PG15.1 PG9.1 PG10.2 ; v1(209.78,219.53) 209.9,219.41 PU6.30
  BOTTOM w0.305: 150.64,212.19 151.01,212.55 PU32.21
  BOTTOM w0.508: v1(59.26,119.91) 59.26,120.74 PC308.1 59.19,121.12 59.64,121.56 v1(59.64,121.63) 59.55,121.71 PR278.2 ; v1(220.98,18.57) 220.98,21.92 223.1,24.04 223.1,29.71 v1(219.3,33.5) ; R2730.2 195.43,54.25 195.69,54.51 v1(195.73,54.51) 195.73,57.66 199.29,61.21 199.38,61.21 199.91,61.74 199.91,62.64 200.3,63.03 200.34,63.03 202.16,64.85 202.16,65.41 v1(203.02,66.27) ; v1(130.15,210.97) 129.41,210.24 127.25,210.24 126.51,210.97 124.99,210.97 122.17,208.15 122.17,202.82 123.06,201.93 v1(123.83,201.93) ; 150.64,212.19 150.64,212.18 150.32,211.86 150.32,211.85 149.77,211.3 147.52,211.3 PC208.1 145.29,209.68 135.69,209.68 134.44,208.43 134.44,208 v1(134.39,208) ; v1(136.91,217.68) 136.78,217.81 PR315.2 ; v1(48.16,119.94) 48.16,119.95 48.3,120.09 PC328.1 48.65,121.18 48.67,121.18 v1(49.15,121.67) 49.43,121.39 PR291.2 ; v1(216.97,65.61) 215.06,65.61 212.95,67.72 212.95,81.31 v1(211.07,83.19) ; v1(129.08,129.11) 128.93,128.96 118.14,128.96 115.01,125.83 v1(114.83,125.83) 113.49,124.49 110.64,124.49 109.92,123.76 109.91,123.76 v1(109.65,123.5) 109.64,123.49 108.13,123.49 105.94,121.31 98.45,121.31 97.75,120.61 PR277.2 96.71,120.61 96.6,120.73 PC307.1 96.14,120.69 96.14,120.04 v1(96.29,119.89) ; v1(218.26,140.11) 217.53,140.84 R2757.1 216.98,142.43 216.03,143.38 214.69,143.38 R2755.1 ; v1(37.03,119.91) 37.15,120.03 PR306.2 37.15,121.17 34.19,124.13 28.37,124.13 24.35,128.15 13.89,128.15 10.62,131.42 v1(10.62,132.46) ; v1(73.46,120.09) 73.55,120.18 PR305.2 ; v4(140.59,35.13) 140.77,34.95 141.78,34.95 142.24,34.5 142.95,34.5 143.56,35.1 143.56,36.88 145.1,38.42 C990.1 145.1,40.27 145.19,40.36 v1(145.19,40.44) ; v1(84.76,119.91) 84.76,120.23 84.59,120.4 PC327.1 85.17,120.98 85.29,121.11 PR292.2
  vias: v1(163.96,13.72) v1(164.85,13.72) v3(93.6,85.22) v3(140.08,31.88) v4(86.31,100.33) v4(102.97,82.73) v4(133.86,50.93) v4(138.43,12.45) v4(139.37,12.14) v4(139.67,36.04) v4(139.67,35.13) v4(139.67,34.21) v4(139.67,33.3) v4(140.59,36.96) v4(140.59,36.04) v4(140.59,34.21) v4(140.59,33.3) v4(175.67,12.12) v4(176.53,11.48) v4(182.09,6.5) v4(182.32,7.49) v5(135.76,46.23) v5(139.7,38.23) v5(140.21,31.62) v6(126.24,59.94)
5V_USB_CHAR_REAR: length 55.4
  TOP w0.203: U12.12 96.28,41.29 96.09,41.1 96.09,39.94
  TOP w0.61: RPWRC1.22 v4(159.5,5.11)
  L4 w1.016: v4(96.44,23.7) 96.44,23.64 97.32,22.77 98.64,22.77 99.36,22.05 99.36,19.24 100.67,17.94 100.67,16.17 105.71,11.13 110.13,11.13 111.63,9.63 113.35,9.63 113.4,9.68 114.51,9.68 114.53,9.65 115.29,9.65 115.31,9.68 122.4,9.68 124.51,11.79 127.91,11.79 128.17,12.05 129.28,12.05 129.7,11.63 131.83,11.63 132.64,12.44 132.64,12.57 134.85,14.79
  vias: v3(94.21,26.42) v4(153.14,19.86) v4(158.5,5.13) v4(159.11,11.33)
5V_USB_CHAR_SIDE: length 1.3
  TOP w0.305: U10.12 223.93,17.58 224.1,17.75
  vias: v2(226.57,23.62) v4(225.91,20.27) v4(226.44,26.29) v4(226.44,25.27)
12V_FAN: length 9.5
  TOP w0.635: FANC1.2 12,178.45 ; FANC1.2 10.82,177.27 ; FANC1.2 12,176.09 ; FANC1.2 13.18,177.27
  BOTTOM w0.635: 12,176.09 FANC1.2 ; FANC1.2 12,178.45 ; FANC1.2 13.18,177.27 ; FANC1.2 10.82,177.27
12V_PG: length 1.2
  TOP w0.114: TP118.1 8.21,199.12 PR342.1
12V_S0: length 9.4
  TOP w0.508: R254.1 15.05,174.31 v1(14.61,173.86)
  L6 w0.508: v1(14.73,181.86) 14.61,181.74 v1(14.61,173.86)
  vias: v1(15.49,181.36) v2(16,180.09)
19V_AMP_AVDD: length 12
  TOP w0.203: U8.37 190.87,25 190.37,24.51 190.37,23.47 189.59,22.68 C411.1 ; 207.39,23.34 207.82,23.77 208.03,23.77 208.29,24.04 U7.37
  TOP w0.508: C411.1 188.94,22.95 189.71,23.72 v1(189.76,23.72) ; v1(206.52,23.69) C377.1 206.99,22.84 207.39,23.24 207.39,23.34
  BOTTOM w0.508: v1(206.52,23.69) 207.42,24.59 C378.1
  vias: v2(188.09,24.43)
19V_AMP_PVDD: length 12.8
  TOP w0.203: U8.56 198.46,22.18 ; 192.33,22.4 192.33,22.41 U8.42 ; U7.42 209.17,21.44 209.17,21.44 ; U7.48 212,20.01 212.01,19.99 v4(212.01,19.79) ; 213.51,17.83 213.2,18.15 U7.51 ; U7.1 216.02,21.85 ; U8.43 192.66,22.18 192.66,22.17 ; U8.51 196.36,19.49 197,18.85 ; U7.56 215.39,21.21 ; U8.48 195.16,21.04 v4(194.94,20.83) ; 209.5,21.21 209.5,21.21 U7.43 ; U8.1 199.18,22.84
  vias: v1(210.69,19.91) v2(189.74,17.27) v2(193.42,21.34) v2(204.72,18.16) v2(213.97,20.83) v3(200.48,19.43) v3(217.81,18.29) v4(187.17,20.22) v4(188.24,20.22) v4(188.24,19.13) v4(191.77,21.62) v4(200.61,20.5) v4(201.52,20.47) v4(207.9,20.65) v4(217.45,19.53) v4(217.5,20.7)
19V_DCBATOUT: length 64.4
  TOP w0.203: PG60.1 PG59.1 PG58.1 ; 188.11,228.45 PG40.1 PG39.1 PG38.1 191.77,228.45 191.97,228.65 ; PG179.1 39.34,109.45 ; 128.91,108.97 129.08,108.79 PG136.1 PG133.1 PG131.1 129.08,106.73 128.78,106.43 ; 232.16,128.27 231.95,128.47 PG66.1 PG64.1 PG63.1 231.95,131.78 231.9,131.83 ; PG125.1 PG122.1 PG121.1 147.48,10.93 147.65,11.1
  TOP w0.254: PG168.1 50.85,109.83 ; PG170.1 51.61,109.8 ; PG180.1 70.92,109.07 ; PG48.1 159.69,229.72 ; PG109.1 152.72,226.68 ; PG112.1 151.96,226.74 ; PG106.1 151.2,226.74 ; PG54.1 PG53.1 PG55.1 217.6,199.31 ; PG166.1 52.37,109.73 ; 86.54,108.28 PG165.1 PG167.1 PG169.1 ; PG178.1 71.68,109.02 ; PG155.1 97.87,105.44 ; PG160.1 58.12,108.81 ; PG176.1 70.15,108.94 ; PG50.1 158.93,229.69 ; 175.31,229.87 PG43.1 ; PG157.1 97.1,105.38 ; PG49.1 160.45,229.69 ; 174.55,229.9 PG45.1 ; PG60.1 228.14,202.23 ; PG159.1 96.34,105.41 ; PG58.1 226.62,202.26 ; PG156.1 59.64,108.79 ; PG44.1 173.79,230.05 ; PG158.1 58.88,108.81
  TOP w0.305: PG177.1 PG175.1 PG179.1
  TOP w0.508: v4(160.67,5.12) 160.5,4.96 RPWRC1.20 ; PR233.2 117.35,141.2 v1(117.86,140.69) ; RPWRC1.18 161.5,4.49 162.03,5.01 v4(162.03,5.14)
  L3 w0.508: v1(117.86,140.69) 117.86,140.49 116.13,138.76 116.13,134.87 115.54,134.28 115.54,124.51 111,119.96 v1(111,118.24)
  BOTTOM w0.203: PG194.1 114.63,216.53 114.02,216.53 PG191.1 ; 106.68,14.35 106.88,14.15 PG7.1 PG19.1 PG13.1 106.88,11.63 106.81,11.56
  BOTTOM w0.254: 11.01,220.69 PG201.1 ; 11.61,204.9 PG143.1 ; 10.89,219.8 PG204.1 ; 11.35,204.14 PG144.1 ; 10.89,221.58 PG197.1
  BOTTOM w0.305: PG14.1 106.5,38.38 ; 148.16,227.81 PG185.1 ; 147.4,227.76 PG186.1 ; PG20.1 106.5,39.9 ; PG23.1 106.48,39.14 ; PG8.1 106.53,37.62 ; 146.63,227.76 PG187.1 ; PG28.1 106.5,36.86
  vias: v2(4.75,210.03) v2(7.82,136.04) v2(8.51,175.67) v2(18.8,113.41) v2(48.26,231.52) v2(104.6,11.43) v3(90.27,105.18) v3(206.76,225.96) v3(220.34,61.01) v3(229.44,214.33) v4(2.84,220.01) v4(2.82,218.57) v4(2.82,217.09) v4(3.02,179.58) v4(3.02,178.51) v4(3.02,177.44) v4(3.02,176.38) v4(4.09,220.62) v4(4.06,219.18) v4(4.06,217.7) v4(4.09,179.58) v4(4.09,178.51) v4(4.09,177.44) v4(4.09,176.38) v4(5.16,179.58) v4(5.16,178.51) v4(5.16,177.44) v4(5.16,176.38) v4(5.28,220.01) v4(5.26,218.57) v4(5.26,217.09) v4(6.22,179.58) v4(6.22,178.51) v4(6.22,177.44) v4(6.22,176.38) v4(11.43,106.48) v4(12.09,105.69) v4(18.67,227.61) v4(19.25,230.17) v4(19.74,231.72) v4(20.14,227.61) v4(20.73,230.17) v4(20.93,228.75) v4(21.21,231.72) v4(21.59,227.58) v4(22.17,230.15) v4(22.4,228.75) v4(22.66,231.7) v4(23.85,228.73) v4(34.95,106.55) v4(36.22,106.55) v4(37.54,106.55) v4(39.52,106.55) v4(40.03,231.55) v4(40.51,233.1) v4(41,106.55) v4(41.5,231.55) v4(41.99,233.1) v4(42.44,106.53) v4(42.95,231.52) v4(43.43,233.07) v4(44.78,106.63) v4(46.25,106.63) v4(47.7,106.6) v4(50.62,106.58) v4(52.1,106.58) v4(53.01,231.57) v4(53.49,233.12) v4(53.54,106.55) v4(54.48,231.57) v4(54.97,233.12) v4(55.93,231.55) v4(56.41,233.1) v4(57.68,106.65) v4(59.16,106.65) v4(60.6,106.63) v4(60.99,231.55) v4(61.47,233.1) v4(62.46,231.55) v4(62.94,233.1) v4(63.91,231.52) v4(64.39,233.07) v4(69.29,106.63) v4(70.76,106.63) v4(72.21,106.6) v4(81.15,33.91) v4(81.41,30.35) v4(81.53,79.76) v4(82.55,33.91) v4(86.82,106.86) v4(87.96,106.86) v4(89.05,106.86) v4(91.44,102.64) v4(92.46,103.5) v4(93.85,103.5) v4(99.29,232.36) v4(99.29,230.89) v4(99.8,229.21) v4(100.38,231.78) v4(100.86,233.32) v4(101.27,229.21) v4(101.85,231.78) v4(102.06,230.35) v4(102.34,233.32) v4(102.72,229.18) v4(103.3,231.75) v4(103.53,230.35) v4(103.78,233.3) v4(104.98,230.33) v4(113.36,226.44) v4(114.43,226.44) v4(128.04,106.55) v4(128.09,108.81) v4(128.07,107.72) v4(144.93,232.94) v4(144.93,231.47) v4(145.44,229.79) v4(146.02,232.36) v4(146.51,233.91) v4(146.91,229.79) v4(147.5,232.36) v4(147.7,230.94) v4(147.98,233.91) v4(148.36,229.77) v4(148.95,232.33) v4(149.17,230.94) v4(149.43,233.88) v4(149.43,4.06) v4(150.62,230.91) v4(150.59,4.31) v4(156.51,230.68) v4(157.99,230.68) v4(158.75,231.98) v4(159.44,230.66) v4(160.22,231.98) v4(161.09,230.63) v4(161.67,231.95) v4(162.56,230.63) v4(164.01,230.61) v4(168.88,230.71) v4(170.36,230.71) v4(171.81,230.68) v4(172.36,231.78) v4(173.84,231.78) v4(175.29,231.75) v4(182.37,13.21) v4(182.75,11.81) v4(187.6,232.46) v4(188.37,233.76) v4(189.05,232.44) v4(189.84,233.76) v4(190.17,5.94) v4(190.7,232.41) v4(191.29,233.73) v4(191.34,5.94) v4(217.2,232.64) v4(217.3,200.15) v4(217.83,231.57) v4(217.96,233.65) v4(218.29,200.15) v4(218.64,232.61) v4(219.28,231.55) v4(219.43,233.65) v4(219.43,203.3) v4(219.41,200.15) v4(219.48,201.27) v4(220.29,232.59) v4(220.88,233.63) v4(220.93,231.52) v4(223.27,61.47) v4(224.38,60.6) v4(225.4,61.47) v4(226.16,60.53) v4(228.7,222.5) v4(229.16,221.13) v4(229.92,222.43) v4(229.87,203.07) v4(230.61,221.11) v4(230.58,204.32) v4(231.29,203.07) v4(231.39,222.43) v4(231.75,204.34) v4(232.26,221.08) v4(232.61,203.02) v4(232.84,222.4) v4(233.12,204.32) v4(233.53,201.78) v4(233.68,94.06) v4(233.65,92.86) v4(233.76,203.07) v5(89.84,74.78) v5(91.01,100.81) v5(98.07,18.72) v5(107.37,224.16) v5(114.53,114.3) v5(133.4,230.45) v5(182.93,231.06) v5(214.83,232.74) v5(218.16,202.21)
19V_DCBATOUT_CAM:
  vias: v3(219.79,56.52) v3(221.59,53.54)
AGND: length 47.6
  TOP w0.203: v1(206.45,41.55) 206.44,41.56 U6.20 ; U6.42 198.33,45.59 197.76,46.15 197.76,46.71 197.29,47.18 R2617.1 ; U6.30 203.88,46.27 205.1,47.5 v1(205.33,47.5)
  TOP w0.406: U42.2 v1(213.14,59.41) ; U41.2 v1(206.12,56.45)
  TOP w0.508: C1124.1 209.01,57.17 v1(209.09,57.17) ; C1123.1 v1(211.01,63.44) ; v1(230.94,31.89) 230.47,31.89 229.86,32.5 SUSBC1.18 ; v1(213.06,42.16) 212.83,42.39 C330.2 211.43,42.98 C331.2 ; R2617.1 v1(197.1,46.35) ; v4(200.53,54.86) 199.61,54.86 199.06,54.32 199.06,54.03 198.73,53.69 C1122.2 198.46,52.66 R2618.1 198.46,51.78 197.95,51.26 C314.1
  TOP w0.61: v1(230.94,31.89) 230.94,31.88 231.31,31.5 SUSBC1.15
  BOTTOM w0.508: C332.2 210.1,42.26 C317.2 C316.2 ; C332.2 212.98,42.24 v1(213.06,42.16) ; C332.2 C329.2 ; v1(197.1,46.35) 198.13,47.38 R2630.2 198.13,49.77 197.21,50.69 Q68.S ; C341.2 C340.2 202.03,55.17 201.88,55.32 v1(201.93,55.37) ; C352.2 219.71,40.01 v1(219.58,40.13) C351.2 218.19,40.01 R305.2 ; R304.2 v1(221.94,41.75)
  vias: v1(192.3,44.81) v1(192.28,43.97) v1(203.33,58.04) v1(205.41,48.79) v1(207.57,50.62) v1(223.62,39.29) v2(204.09,56.41) v2(208.41,59.44) v2(209.75,54.74) v4(137.79,8.13) v4(138.79,8.13) v4(139.8,8.1) v4(202.06,57.78) v4(202.06,56.67)
GND: length 2905.5
  TOP w0.114: CPU1.H29 v6(181.5,154.5)
  TOP w0.127: PU29.3 v1(227.08,139.7) ; CPU1.A27 190.12,156 190.44,155.68 190.81,155.68 191.07,155.94 191.07,156.05 v6(191.25,156.23)
  TOP w0.203: v1(8.51,213.61) 9.06,213.07 PU48.20 ; PU48.14 10.57,211.6 v6(10.39,211.79) ; PU29.14 222,139.3 v1(221.89,139.19) ; KBC1.12 103.31,54.94 103.5,55.14 104.98,55.14 105.36,55.52 105.36,56.13 106.05,56.82 v1(106.1,56.82) ; v1(211.28,29.51) 211.28,29.06 211.6,28.74 U7.24 ; v1(217.25,23.14) 217.15,23.24 U7.4 ; U8.45 193.96,23.83 v6(194.23,24.1) 194.36,23.98 U8.46 ; U7.53 214,22.25 v6(213.11,23.14) ; PU48.2 7.3,211.6 ; 7.3,211.6 7.7,211.2 PU48.3 ; 7.3,211.6 v1(7.21,211.68) 7.53,212 PU48.1 ; U7.20 213.2,26.28 v6(213.11,26.19) ; KBC1.116 108.85,59.95 108.36,59.46 108.2,59.46 v1(108.05,59.31) ; U7.33 208.47,25.64 208.31,25.81 207.95,25.81 v1(207.92,25.83) 207.92,25.6 208.29,25.24 U7.34 ; v1(97.83,151.79) 97.81,151.8 U29.6 ; v1(194.51,30.63) 194.76,30.39 U8.24 ; U7.46 211.2,23.02 v6(211.07,23.14) 210.8,22.86 U7.45 ; KBC1.18 103.53,52.55 103.96,52.11 v1(103.96,52.1) ; U7.54 214.4,22.86 v6(214.12,23.14) ; v1(208.05,23.27) 208.08,23.24 U7.39 ; U8.34 191.13,26.2 190.88,26.46 190.88,26.97 v1(190.96,27.05) 191.41,26.6 U8.33 ; v1(226.82,138.43) 226.35,138.9 PU29.1 ; v1(99.26,99.14) 99.25,99.15 SSDC1.9 ; KBC1.89 119.3,56.54 119.89,57.13 v1(119.89,57.15) ; v1(190.88,24.1) 190.93,24.1 191.03,24.2 U8.39 ; U7.19 213.6,26.71 v6(214.12,26.19) ; PU48.7 9.46,210.46 v6(9.27,210.64) ; U8.19 196.76,30.13 v1(196.88,30.25) 196.82,30.25 196.36,29.78 U8.20 ; U8.4 200.54,24.2 v1(200.58,24.16) ; v6(196.27,24.1) 197.16,23.21 U8.53 ; U39.11 U39.15 ; v1(107.98,43.08) 107.98,43.21 108.85,44.08 KBC1.45 ; v1(104.19,58.1) 103.71,58.1 103.36,57.74 KBC1.5 ; CPU1.A36 189.29,146.71 189.29,146.71 189.89,146.11 v6(189.89,145.87) ; CPU1.H5 CPU1.H4 ; U33.11 v1(135.99,14.45) ; KBC1.78 119.2,52.15 119.49,51.86 v1(119.99,51.86) ; v6(197.28,24.1) 197.56,23.83 U8.54
  TOP w0.254: DIMM2.18 211.12,93.69 211.43,94 v6(211.96,94) 212.27,93.69 212.27,92.86 212.12,92.72 DIMM2.14 ; CPU1.U8 CPU1.U9 ; DIMM2.175 169.87,101.42 ; DIMM2.6 214.12,92.51 215.33,93.72 v6(216.11,93.72) ; DIMM2.10 213.12,92.48 213.25,92.6 213.25,92.88 213.25,92.88 213.25,94.29 v6(213.83,94.87) ; PU34.8 134.62,105.82 v1(134.42,105.61) 134.17,105.86 PU34.7 ; v6(61.68,185.98) 61.83,186.12 62.4,186.12 62.68,186.4 62.68,186.68 GPU1.R15 ; v1(117.22,156.59) 117.14,156.51 116.52,156.51 PR249.2 ; v6(159.51,145.55) 159.54,145.55 160,146 CPU1.AK37 ; PU33.8 147.02,14.83 v1(146.86,14.68) 146.76,14.68 146.57,14.88 PU33.7 ; CPU1.U5 CPU1.U4 ; v6(209.38,95.35) 209.49,95.24 209.49,95.24 210.12,94.61 DIMM2.22 ; PU34.18 v6(134.62,108.15) ; CPU1.F4 CPU1.E4 CPU1.E5 ; DIMM2.181 168.38,99.9 168.38,97.71 v6(167.9,97.23) ; v6(159.56,148.49) 160,148.05 CPU1.AK35 ; PU33.18 v1(147.02,19.68) ; 192.38,102.79 192.37,102.79 DIMM2.93 ; CPU1.L5 CPU1.L4 ; v6(83.7,216.1) VRAMA2.C14 v6(82.9,215.3) ; CPU1.P5 CPU1.P4
  TOP w0.279: DIMM1.235 154.87,117.02 ; 192.53,104.95 192.13,105.36 DIMM1.94 ; v1(194.25,90.04) 194.12,90.17 DIMM2.86 ; DIMM1.61 200.38,116.75 ; v6(167.79,109.15) 168.3,109.15 168.63,108.83 DIMM1.180 ; v6(204.59,90.11) 204.62,90.15 DIMM2.44 ; DIMM1.171 170.87,113.57 v6(170.16,112.86) ; v6(154.97,108.68) 155.41,108.68 156.12,107.97 DIMM1.230 156.12,104.69 ; DIMM1.175 169.87,117.13 ; v6(195.15,89.89) 195.12,89.92 DIMM2.82 ; DIMM1.19 210.87,116.81 ; 163.12,104.75 DIMM1.202 ; v6(167.8,111.36) 168.06,111.36 168.71,112.01 168.71,113.05 168.65,113.1 168.65,113.88 168.38,114.16 DIMM1.181 ; DIMM2.90 193.12,92.96 v6(192.92,93.17) 192.52,93.17 192.12,92.78 DIMM2.94 ; DIMM1.47 203.87,116.81 ; DIMM1.98 191.13,105.7 191.8,105.03 ; DIMM1.201 163.38,117.02 ; DIMM1.60 200.62,105.46 201.19,104.9 ; DIMM2.64 199.62,90.11 v6(199.6,90.09) ; DIMM1.31 207.87,116.81 ; v6(200.68,95.6) 200.82,95.6 201.67,94.74 201.67,94.54 201.69,94.52 201.69,92.81 201.62,92.74 DIMM2.56 ; DIMM1.106 189.13,104.85 ; DIMM1.5 214.37,116.75 ; DIMM1.36 206.62,104.55 v6(206.62,104.55) 206.01,104.55 205.62,104.93 DIMM1.40 ; DIMM1.65 199.38,116.81 ; 161.12,104.9 DIMM1.210 ; v6(203.65,90.21) 203.62,90.24 DIMM2.48 ; DIMM1.44 204.62,105.56 204.47,105.41 204.47,104.96 ; 210.12,105.12 DIMM1.22 ; DIMM1.90 193.13,108.09 193.12,108.09 193.76,108.72 v6(194.43,108.72) 194.43,108.3 194.12,107.99 194.13,107.99 DIMM1.86 ; DIMM2.60 200.62,90.12 v6(200.54,90.04) ; 201.62,105.34 DIMM1.56 ; DIMM1.15 211.87,116.75 ; DIMM1.168 171.63,109.73 171.62,109.74 171.62,110.19 171.62,110.19 171.62,110.35 170.64,111.33 170.26,111.33 v6(170.16,111.43) 170.29,111.56 170.33,111.56 171.67,112.9 171.67,113.13 171.87,113.34 DIMM1.167 ; 157.12,104.68 DIMM1.226 ; DIMM1.188 166.63,104.62 ; v6(190.76,105.08) 190.13,105.72 DIMM1.102 ; DIMM1.99 190.87,116.83 ; DIMM1.231 155.87,117.02 ; DIMM1.176 169.63,108.28 169.61,108.29 169.61,108.74 169.93,109.06 169.95,109.06 v6(170.16,109.28) 170.17,109.28 170.7,108.74 170.7,108.29 170.63,108.21 DIMM1.172 ; DIMM1.9 213.37,116.81 ; DIMM1.69 198.38,116.83 ; DIMM1.222 158.12,105.13 157.9,104.9 ; DIMM1.85 194.37,116.83 ; DIMM2.78 196.11,91.72 196.11,93.18 v6(196.14,93.22) ; v6(209.36,93.93) 209.3,93.93 208.8,93.43 208.8,92.99 209.12,92.66 DIMM2.26 ; DIMM1.189 166.38,113.64 167.24,112.78 v6(167.77,112.78) ; DIMM2.30 208.12,92.67 208.1,92.7 208.1,94.18 209.27,95.35 v6(209.38,95.35) ; DIMM1.6 214.12,104.77 ; DIMM2.72 197.62,94.34 196.62,95.34 196.35,95.34 v6(196.32,95.38) ; 199.62,105.16 DIMM1.64 ; 202.76,104.88 203.62,105.74 DIMM1.48 ; v6(206.68,94.18) 206.66,94.18 206.11,93.63 206.11,93.3 205.62,92.81 DIMM2.40 ; DIMM1.78 196.13,104.92 ; 213.12,105.29 DIMM1.10 ; DIMM1.247 151.87,117.02 ; 162.12,104.51 DIMM1.206 ; DIMM1.244 152.62,108.28 v6(152.81,108.46) ; DIMM1.82 195.13,104.88 ; DIMM1.205 162.38,117.02 ; DIMM1.77 196.37,116.75 ; DIMM1.43 204.87,116.75 ; v6(154.94,112.95) 154.89,113.01 154.69,113.01 153.87,113.83 153.87,114.35 153.87,114.35 DIMM1.239 ; 159.12,104.97 DIMM1.218 ; 209.12,104.98 DIMM1.26 ; DIMM1.223 157.87,117.02 ; DIMM1.30 208.12,108.51 208.74,109.12 209.68,109.12 v6(209.72,109.17) ; DIMM1.196 164.62,104.79 ; 154.12,104.86 DIMM1.238 ; DIMM1.103 189.87,116.83 ; DIMM1.251 150.87,113.97 v6(150.25,113.34) ; DIMM1.23 209.87,116.91 ; DIMM1.213 160.38,117.02 ; DIMM2.106 189.12,92.73 189.53,93.14 v1(189.53,93.16) ; DIMM1.197 164.38,117.02 ; DIMM1.81 195.37,116.81 ; 160.29,105 160.12,105.17 DIMM1.214 ; 150.62,105.14 DIMM1.252 ; DIMM1.243 152.87,117.02 ; DIMM1.27 208.87,116.75 ; DIMM1.217 159.38,117.02 ; DIMM1.185 167.38,117.13 ; DIMM1.2 215.81,106.9 v6(215.95,107.04) ; DIMM1.209 161.38,117.02 ; DIMM1.1 215.37,116.91 ; DIMM1.39 205.87,116.91 ; DIMM1.192 165.62,104.77 ; 198.62,104.81 DIMM1.68 ; DIMM1.35 206.87,116.83 ; DIMM1.193 165.38,113.85 165.37,113.85 165.41,113.81 165.41,113.36 v6(164.93,112.88) ; DIMM1.57 201.38,116.91 ; DIMM1.107 188.87,116.83 ; DIMM1.184 167.63,104.76 ; DIMM1.52 202.62,108.57 203.12,109.07 203.97,109.07 203.99,109.08 v6(204.01,109.08) ; DIMM1.89 193.37,116.84 ; DIMM1.73 197.37,116.91 ; DIMM2.36 v6(206.62,90.16) ; 211.12,105.29 DIMM1.18 ; 197.62,104.97 DIMM1.72 ; DIMM2.102 190.12,92.62 190.83,93.33 v1(190.83,93.4) 191.12,93.1 DIMM2.98 ; DIMM1.234 155.12,104.58 v6(154.97,104.42) ; DIMM1.93 192.37,116.83 ; 212.12,105.23 DIMM1.14 ; DIMM1.227 156.87,117.02 ; DIMM1.51 202.87,116.83
  TOP w0.3: VRAMB2.U14 46.15,227.05 v6(45.72,227.05) ; v6(45.7,223.44) 45.9,223.64 46.24,223.64 VRAMB2.N14 ; VRAMB2.N12 v6(47.5,223.3) ; VRAMB2.C4 v6(54.7,215.3) ; v6(46.7,214.5) VRAMB2.A14 ; VRAMB2.M5 53.1,222.9 v6(52.94,222.74) ; VRAMB2.R4 v6(54.7,225.7) ; v6(47.5,216.9) VRAMB2.E12 ; VRAMB2.R14 v6(45.72,225.3) ; VRAMB2.U12 v6(47.5,227.3) ; VRAMB2.K14 v6(46.7,221.7) ; VRAMB2.K2 v6(56.3,221.7)
  TOP w0.305: CPU1.E26 185.1,156.9 185.1,156.1 ; CPU1.E26 CPU1.F25 v6(183.5,158.5) CPU1.G24 ; CPU1.E26 CPU1.D25 ; CPU1.AM26 158,157.01 158.52,156.49 v6(158.52,156.44) ; CPU1.AD30 v6(165.5,153.5) CPU1.AE29 ; v6(59.2,150.3) VRAMD2.E12 v6(60,150.3) ; DIMM2.244 152.62,93.95 151.84,94.73 v6(151.07,94.73) ; VRAMD1.E12 v6(26.7,165.5) ; v6(39.65,119.35) 39.04,118.74 PU45.5 ; TYPEC1.5 v1(110.75,8.15) ; v6(75.6,213.7) 75.2,214.1 VRAMB1.U14 ; U24.1 22.44,109.46 22.71,109.73 22.71,110.21 22.58,110.34 ; VRAMD1.U12 v6(36.3,165.5) ; VRAMA1.H14 103.66,189.16 v6(103.7,189.16) 103.7,189.2 VRAMA1.H13 ; VRAMD2.U14 61.2,141.1 61.47,140.83 v6(61.77,140.83) ; PCH1.Y1 v6(150.6,40.2) ; CPU1.AR32 154.49,150.49 v6(154.41,150.49) ; v6(33.09,156.74) 33.09,156.69 32.7,156.3 VRAMD1.N1 32.7,156.22 v6(33.06,155.86) ; R54.1 136.75,174.73 v1(136.91,174.88) ; SSDC1.3 97.75,99.89 97.89,99.75 v1(97.89,99.03) ; CPU1.L28 v6(179.5,154.5) CPU1.K29 v6(180.5,154.5) ; v6(56.32,213.69) 56.34,213.71 56.34,213.74 VRAMB2.A1 ; v6(155.49,150.55) 155.54,150.5 155.54,150.46 CPU1.AP33 156,149.98 156.98,149 CPU1.AN34 ; v1(85.95,44.32) 85.88,44.25 RUSBC1.20 ; CPU1.L31 179,152.28 179.01,152.29 179.01,152.71 179,152.72 CPU1.L30 v6(178.5,153.5) ; VRAMD1.H1 v6(28.3,156.7) VRAMD1.H2 ; PCH1.K2 v6(151.4,48.2) ; VRAMC1.B10 v6(23.5,200.1) ; PCH1.H6 v6(154.6,49) PCH1.H5 ; CPU1.K33 CPU1.J34 CPU1.J35 v6(181.5,147.5) CPU1.H35 v6(182.5,147.5) ; v6(164.47,152.49) 164.97,152 CPU1.AE31 ; PCH1.H4 v6(153.8,49) ; CPU1.G39 CPU1.H38 v6(181.5,145.5) CPU1.J37 v6(181.5,146.5) ; CPU1.J13 CPU1.H14 ; VRAMD2.A12 v6(60,154.3) ; CPU1.Y28 v6(169.5,155.5) CPU1.AA27 ; v6(216.8,97.94) 215.29,97.94 214.37,98.86 DIMM2.5 ; DIMM2.192 v6(165.62,90.12) ; CPU1.G36 v6(182.5,146.5) ; CPU1.G36 CPU1.F37 CPU1.E38 ; CPU1.G36 v6(182.5,147.5) ; DIMM2.69 198.37,99.9 198.37,102.65 ; VRAMB2.T5 v6(53.9,226.5) ; v6(163.16,90.14) 163.12,90.18 DIMM2.202 ; VRAMA2.R12 v6(85.3,225.7) VRAMA2.R11 ; CPU1.W29 v6(171.5,153.5) CPU1.V30 ; VRAMA1.K13 VRAMA1.K14 v6(101.3,188.4) ; VRAMA1.P10 v6(98.9,191.6) ; CPU1.N29 v6(177.5,154.5) ; CPU1.AL27 159.09,156 v6(159.53,156.44) ; VRAMD1.L5 31.21,159.61 31.79,159.61 VRAMD1.M5 v6(32.3,159.1) ; TYPEC1.2 112.25,7.71 112.06,7.9 v1(112.06,8.18) ; VRAMA2.B5 v6(90.9,214.5) ; PU46.5 138.74,218.64 138.76,218.62 v1(138.76,218.54) ; CPU1.AV38 151.76,144.76 v6(151.36,144.76) ; CPU1.J1 181,182.62 181.03,182.65 181.06,182.65 v1(181.06,182.66) ; v6(203.81,93.89) 203.14,93.89 202.63,93.38 202.63,92.44 202.62,92.43 DIMM2.52 ; VRAMC1.G10 27.9,200.48 v6(27.5,200.08) 27.1,200.48 VRAMC1.F10 ; VRAMC1.F5 27.1,196.9 v6(27.26,197.06) ; DIMM2.171 170.87,98.08 170.56,97.76 170.31,97.76 v6(170.26,97.71) ; DIMM2.235 154.87,98.26 154.37,97.75 v6(154.03,97.75) 153.78,98 153.78,98.02 153.6,98.2 153.6,98.64 153.6,98.65 153.6,98.68 153.87,98.95 DIMM2.239 ; v6(25.1,157.5) VRAMD1.C3 v6(24.3,158.3) VRAMD1.C4 ; DISPC1.8 v1(85.16,62.75) ; v6(26.33,155.74) 26.31,155.76 26.31,155.82 26.3,155.83 26.3,156.03 VRAMD1.E1 ; R2716.2 129.26,152.21 C440.2 129.35,152.71 Q72.4 130.29,154.34 130.56,154.61 131.37,154.61 131.57,154.81 131.57,155.51 Q72.1 131.59,156.1 v1(132.28,156.79) ; VRAMA1.G10 v6(104.5,192.4) VRAMA1.F10 ; v6(98.3,42.01) 98.05,41.76 U12.14 ; v1(136.02,6.22) 136.25,6.46 LAUOC1.27 ; VRAMC1.R4 v6(34.7,195.3) VRAMC1.R3 v6(33.9,194.5) ; v6(99.7,196.4) VRAMA1.M5 100.18,196 100.29,195.89 100.71,195.89 100.82,196 VRAMA1.L5 ; DISPC1.33 v1(85.18,75.25) ; VRAMA2.D10 86.5,216.53 v6(86.12,216.91) ; v6(149.8,149.43) 150.57,149.43 CPU1.AW34 ; VRAMA1.F5 104.9,195.37 v6(104.7,195.17) ; VRAMB2.H1 v6(56.3,219.3) VRAMB2.H2 ; v6(162.15,90.19) 162.12,90.21 DIMM2.206 ; VRAMC2.A12 v6(36.3,176) ; DIMM2.172 170.62,91.7 170.62,90.69 170.2,90.27 v6(169.87,90.27) 169.63,90.51 DIMM2.176 ; v6(211.94,96.13) 211.79,96.28 211.71,96.28 210.19,97.8 210.19,98.71 209.86,99.05 209.86,99.88 DIMM2.23 ; VRAMB2.B5 v6(53.9,214.5) ; CPU1.D32 185.99,151.01 185.68,151.01 185.67,151 CPU1.E32 ; CPU1.D32 CPU1.C31 ; CPU1.D32 186,150.72 185.87,150.59 185.87,150.13 CPU1.D33 v6(186.5,149.5) CPU1.D34 CPU1.D35 CPU1.E35 CPU1.F35 ; CPU1.AN35 v6(156.5,148.5) CPU1.AP35 ; U10.14 222.63,18.28 222.63,18.29 v1(222.63,18.31) ; CPU1.AW16 v6(150.3,167) ; VRAMC2.R12 v6(25.1,176.8) ; VRAMD1.C12 v6(24.3,164.7) VRAMD1.C11 ; VRAMB1.N3 66.37,217.33 v6(66,217.7) ; GPU1.W34 81,183.06 v6(81.54,183.59) ; CPU1.AA31 169,152.03 v6(169.5,152.53) ; DISPC2.17 7.96,154.25 7.96,154.25 v1(8.13,154.25) ; WLAN1.33 180.61,49.75 v1(180.52,49.66) ; PCH1.AD17 v6(164.2,36.2) ; PCH1.L3 v6(152.2,46.6) PCH1.M3 ; VRAMB1.E3 66.4,223.7 v6(66,223.3) ; PCH1.M6 v6(154.6,45.8) PCH1.M5 ; v6(46.7,216.1) VRAMB2.C14 v6(45.9,215.3) ; v6(190.2,161.48) 190.2,161.52 190.03,161.69 190.03,161.72 189.72,162.03 189.03,162.03 CPU1.A21 ; VRAMB1.C14 75.22,225.35 v6(75.81,225.35) ; v6(159.48,153.45) 159.45,153.45 CPU1.AL30 ; PU26.4 220.36,205.98 219.89,205.51 v1(219.66,205.51) ; v6(26.56,167.3) 26.56,167.13 26.34,166.91 26.34,166.87 26.3,166.83 VRAMD1.E14 ; v6(61.98,119.1) 61.39,119.1 61.03,118.74 PU41.5 ; CPU1.AU39 152.97,144 v6(152.48,143.51) ; v6(47.5,215.3) VRAMB2.C12 v6(48.3,215.3) VRAMB2.C11 ; VRAMB2.U1 56.83,227.03 57.24,227.03 v6(57.26,227.05) ; VRAMD1.R12 v6(34.7,165.5) ; VRAMD2.R14 61.79,142.7 v6(61.84,142.65) ; v6(83.05,189.6) 83.05,189.45 GPU1.M36 ; 27.5,163.1 v6(27.5,163.08) ; 27.5,163.1 VRAMD1.F10 ; 27.5,163.1 VRAMD1.G10 ; v6(64.24,226.96) 64.27,226.93 VRAMB1.A1 ; v6(34.7,164.7) 34.3,164.3 VRAMD1.R11 ; DISPC1.14 v1(85.16,65.75) ; CPU1.AK31 160,151.94 v6(160.47,151.46) 160.94,151 CPU1.AJ32 ; C1160.2 126.52,46.64 v1(126.52,46.86) ; v6(169.5,153.5) CPU1.Y30 CPU1.W31 ; v1(85.7,36.53) 85.47,36.75 RUSBC1.5 ; VRAMA2.G5 90.38,218.78 90.38,218.22 VRAMA2.F5 v6(90.9,217.7) ; DIMM2.47 203.87,102.02 202.17,103.73 ; CPU1.E5 v6(185.5,177.5) CPU1.D6 ; v6(79.85,184.8) 79.4,184.35 GPU1.V32 ; TYPEC1.11 107.75,8.12 107.75,8.13 v1(107.75,8.15) ; v6(68.42,221.68) 68,222.1 VRAMB1.G5 ; VRAMC2.E12 v6(32.3,176.8) ; v6(47.56,213.59) 47.6,213.63 47.6,213.74 47.9,214.04 VRAMB2.A12 ; VRAMC2.L5 27.9,181.87 v6(28.22,181.55) ; SSDC1.1 97.25,98.38 ; CPU1.AT34 154.06,149 154.42,148.64 v6(154.42,148.52) 154.46,148.56 154.53,148.56 154.54,148.57 154.57,148.57 CPU1.AR34 ; 204.64,102.77 204.87,102.54 DIMM2.43 204.87,97.45 206.01,96.32 v6(206.62,96.32) ; v6(28.29,159.1) 28.29,159.11 VRAMD1.G5 ; v6(171.62,90.17) 171.62,91.7 DIMM2.168 ; v6(98.9,198.8) VRAMA1.N1 v6(98.9,199.6) ; PU41.37 62.62,120.74 62.26,120.37 v6(61.98,120.37) ; v6(74.8,216.12) 74.8,216.1 75.17,215.73 VRAMB1.R14 75.2,215.7 75.57,215.33 v6(75.6,215.33) ; PCH1.N3 v6(152.2,45) PCH1.P3 ; DISPC1.27 v1(85.18,72.25) ; v6(155.99,94.72) 155.99,94.65 156.12,94.51 DIMM2.230 ; VRAMC2.A3 v6(35.5,184) ; v6(66.02,216.14) 66.05,216.11 66.05,216.05 66.37,215.73 VRAMB1.R3 66.4,215.7 66.78,215.32 v6(66.81,215.32) 66.82,215.32 67.2,215.7 VRAMB1.R4 ; TYPEC1.32 97.25,8.15 v1(97.29,8.18) ; v6(34.7,167.1) VRAMD1.R14 v6(33.9,166.3) ; v6(98.1,198) VRAMA1.R3 v6(97.3,197.2) VRAMA1.R4 ; VRAMB1.E14 75.66,223.73 v6(75.74,223.65) ; 91.44,5.59 93.93,5.59 94.25,5.91 TYPEC1.38 ; CPU1.AL35 158.77,148 158.73,147.96 158.31,147.96 158.27,148 CPU1.AM35 ; CPU1.AL35 158.95,147.95 158.95,147.05 CPU1.AL36 ; CPU1.AL35 159.49,148.49 v6(159.56,148.49) ; DIMM2.103 189.87,102.91 ; VRAMB1.M10 72,218.14 v6(72.4,218.54) 72.01,218.93 VRAMB1.L10 ; v6(83.85,184.8) 83.4,184.35 GPU1.V37 ; CPU1.AN37 CPU1.AM38 158.4,144.6 158.4,144.55 v6(158.42,144.52) 158.45,144.5 158.5,144.5 CPU1.AL39 ; v1(134.62,222) 134.76,221.86 PU46.37 ; VRAMB1.C1 64.33,225.33 v6(64.22,225.22) ; CPU1.AV32 151.51,151.49 151.51,151.49 v6(151.49,151.5) 151.45,151.54 151.45,151.55 CPU1.AW31 ; v6(32.3,175.2) VRAMC2.E14 33.04,174.46 33.04,174.4 v6(33.05,174.4) ; v6(28.25,196.93) 27.9,196.57 VRAMC1.G5 ; v6(99.7,189.2) VRAMA1.N14 v6(98.9,188.4) ; VRAMC2.R11 v6(24.3,176.8) ; v1(180.91,48.75) WLAN1.29 ; v6(155.54,147.49) 155.51,147.49 CPU1.AR35 ; v6(97.3,188.4) VRAMA1.R14 97.7,188.81 97.31,189.19 97.31,189.2 v6(97.31,189.2) ; v6(61.57,151.09) 61.2,150.71 VRAMD2.E14 ; GPU1.AM2 52.2,171.15 v6(52.65,171.6) 53.1,172.05 GPU1.AK3 53.1,172.5 GPU1.AJ4 ; VRAMA1.G5 104.1,195.79 v6(103.78,195.48) ; v6(33.08,185.61) 32.7,185.24 VRAMC2.E1 32.71,185.2 v6(33.1,184.81) ; PCH1.F17 163.8,51.02 164.13,51.36 164.19,51.36 v6(164.21,51.38) ; CPU1.D22 v6(185.5,161.5) ; v6(185.5,161.5) CPU1.E21 ; v6(185.5,161.5) CPU1.D21 CPU1.E20 CPU1.F19 ; v6(159.85,97.53) 159.92,97.53 159.97,97.59 160.06,97.59 161.37,98.9 DIMM2.209 ; CPU1.G27 v6(182.5,155.5) ; PCH1.AC14 v6(161,37) ; VRAMA2.L10 86.52,222.1 v6(86.92,222.5) 86.52,222.9 VRAMA2.M10 ; VRAMA1.C4 v6(107.7,197.2) ; VRAMB1.C3 66.4,225.33 66,224.93 v6(66,224.9) ; v6(32.3,166.3) VRAMD1.N14 32.99,166.99 32.99,167.07 v6(33.06,167.13) ; PCH1.M4 v6(153.8,45.8) ; v6(74,223.3) 74,223.33 VRAMB1.E12 ; CPU1.AU30 v6(153.5,152.5) ; v6(53.9,217.7) VRAMB2.F5 53.39,218.21 53.39,218.79 VRAMB2.G5 ; VRAMD2.B10 v6(58.4,153.5) ; VRAMA1.R12 v6(98.1,190.8) VRAMA1.R11 ; v6(73.2,224.9) 73.6,225.3 VRAMB1.C12 ; DISPC1.39 84.93,78.25 v1(85.14,78.46) 84.85,78.75 DISPC1.40 ; PCH1.AA5 v6(153.8,38.6) ; v1(181.11,52.95) 181.21,52.95 181.41,52.75 WLAN1.45 ; 156.92,102.57 156.87,102.52 DIMM2.227 ; v6(200.68,97.75) 200.88,97.75 201.37,98.25 201.37,99.9 DIMM2.57 ; v1(132.75,6.2) LAUOC1.20 ; CPU1.J17 181.08,166.08 181.92,166.08 CPU1.H17 ; VRAMB2.C1 57.1,215.3 57.1,215.29 v6(57.13,215.26) ; VRAMB1.B5 67.97,226.13 v6(67.6,226.5) ; VRAMB2.P10 v6(49.9,224.9) ; v6(83.05,183.6) 82.6,183.15 GPU1.W36 ; VRAMC1.H14 v6(28.3,203.3) VRAMC1.H13 ; VRAMB1.K2 65.46,219.59 64.94,219.59 VRAMB1.K1 64.8,219.7 64.41,219.31 v6(64.41,219.3) ; GPU1.C40 86.35,196.9 v6(86.8,197.35) ; v1(85.14,61.37) 85.12,61.37 85,61.25 DISPC1.5 ; TYPEC1.29 v1(98.75,8.15) ; VRAMB2.H13 v6(46.7,219.3) VRAMB2.H14 ; DISPC2.8 8.09,149.75 8.09,149.75 v1(8.13,149.75) ; VRAMB1.A14 75.32,227.05 v6(75.78,227.05) ; DIMM2.89 193.37,98.95 194,98.32 v6(194.21,98.32) 194.37,98.48 DIMM2.85 ; VRAMA1.C14 107.3,188.25 v6(107.35,188.2) ; v1(85.22,48.64) 85.11,48.75 RUSBC1.29 ; PCH1.J3 v6(152.2,48.2) PCH1.K3 ; RUSBC1.8 84.66,38.25 85.29,38.89 85.95,38.89 v1(86.06,38.99) 86.03,38.99 85.27,39.75 RUSBC1.11 ; WLAN1.7 181.36,43.25 v1(181.13,43.48) ; CPU1.C1 187.46,182 188.57,183.11 v1(188.57,183.39) ; CPU1.AU21 v6(152.5,162.5) CPU1.AV20 ; GPU1.D41 87.35,196.65 87.35,196.68 v6(87.42,196.75) ; 171.42,102.06 171.87,101.61 DIMM2.167 ; VRAMC1.L10 v6(31.5,200.9) VRAMC1.M10 ; v6(153.5,151.4) 153.6,151.4 CPU1.AT32 ; VRAMC1.R11 34.3,201.3 v6(34.7,201.7) ; 199.37,99.9 199.37,102.7 ; 199.37,99.9 DIMM2.65 ; 199.37,99.9 199.37,96.78 199.04,96.44 198.99,96.44 198.78,96.24 v6(198.74,96.24) ; DISPC1.23 84.97,70.25 v1(85.17,70.05) 84.86,69.75 DISPC1.22 ; v6(33.1,177.61) 33.49,178 VRAMC2.D10 ; VRAMB2.T10 v6(49.9,226.5) ; v6(53.6,150.3) VRAMD2.F5 54,149.82 54.11,149.71 54.11,149.21 VRAMD2.G5 ; VRAMB2.B10 v6(49.1,214.5) ; VRAMB2.U3 v6(55.5,227.3) ; VRAMA1.U14 v6(96.5,189.2) ; VRAMA1.M10 v6(100.5,191.6) VRAMA1.L10 ; v6(22.92,192.63) 22.92,193.12 VRAMC1.A1 ; v6(151.38,93.39) 151.42,93.39 151.62,93.19 DIMM2.248 ; VRAMC1.T5 v6(35.5,196.1) ; VRAMC2.P10 v6(25.1,177.6) ; VRAMA2.C11 85.7,215.68 v6(85.31,215.28) ; v6(154.44,146.48) 154.44,146.44 CPU1.AT37 ; v6(72.4,226.5) 72.03,226.13 VRAMB1.B10 ; CPU1.F35 CPU1.G35 v6(182.5,147.5) ; CPU1.F35 CPU1.F34 v6(183.5,149.5) CPU1.G33 CPU1.H32 ; VRAMB1.A3 66.01,227.32 66.01,227.32 v6(66.01,227.33) ; VRAMB2.R11 v6(48.3,225.7) VRAMB2.R12 ; 205.6,102.9 205.87,102.63 DIMM2.39 205.87,98.26 206.4,97.74 v6(206.63,97.74) ; VRAMA1.C12 106.91,190.79 v6(106.91,190.83) ; CPU1.C31 186.5,152.5 ; CPU1.C31 187.45,151.55 v6(187.45,151.49) ; VRAMB1.H13 74.43,221.33 v6(74.8,221.7) 75.17,221.33 VRAMB1.H14 ; VRAMD1.C14 24.7,167.27 v6(24.69,167.28) ; CPU1.C34 187.45,148.55 v6(187.45,148.54) 187.46,148.54 CPU1.B35 ; DIMM2.77 196.37,103.08 ; v6(24.63,155.67) 24.63,155.7 24.7,155.76 24.7,156.05 VRAMD1.C1 ; TYPEC1.35 v1(95.75,8.15) ; 160.38,101.42 160.37,101.42 DIMM2.213 ; v6(107.26,199.8) 107.3,199.76 VRAMA1.C1 ; 208.36,102.98 208.36,102.78 207.87,102.29 DIMM2.31 ; CPU1.AW19 150.46,164 150.38,164.08 v6(149.94,164.08) ; TYPEC1.23 101.75,8.13 v1(101.77,8.15) ; VRAMB1.U3 66.74,213.79 v6(66.74,213.67) ; VRAMC1.C12 v6(24.3,201.7) VRAMC1.C11 ; v6(72.4,224.9) 72.03,224.53 VRAMB1.D10 ; VRAMC1.A3 23.04,194.9 v6(22.66,194.52) ; CPU1.U27 v6(173.5,155.5) CPU1.T28 v6(174.47,154.53) CPU1.R29 ; VRAMC1.N12 v6(33.1,202.5) ; VRAMB2.D10 v6(49.1,216.9) ; VRAMC1.U1 v6(36.3,193.7) ; v6(50.85,119.1) 50.27,119.1 49.91,118.74 PU43.5 ; v6(80.8,196.45) 80.35,196 GPU1.D33 ; PCH1.M1 v6(150.6,46.6) ; VRAMC1.E3 v6(25.9,194.5) ; PCH1.H3 v6(152.2,49.8) PCH1.G3 ; v6(164.31,97.75) 164.71,97.75 165.37,98.42 DIMM2.193 ; CPU1.R27 175.44,155.56 v6(175.44,155.47) ; LAUOC1.1 123.25,5.27 ; v6(196.35,96.09) 196.45,96.19 196.5,96.19 197.37,97.06 DIMM2.73 ; VRAMC1.E14 26.3,203.83 26.34,203.87 26.34,204.08 v6(26.56,204.3) ; v1(22.28,111.48) 22.58,111.18 22.58,110.34 ; CPU1.AH26 v6(161.5,156.5) CPU1.AJ27 v6(160.5,155.5) CPU1.AK28 ; CPU1.K28 v6(179.5,155.5) ; 159.37,101.42 DIMM2.217 ; WLAN1.39 181.27,51.25 v1(180.97,50.95) ; CPU1.AR27 CPU1.AT28 v6(154.5,154.5) ; WLAN1.18 v1(191.9,46) ; PU43.37 51.5,120.81 51.05,120.37 v6(50.85,120.37) ; v6(22.61,165.48) 22.99,165.1 VRAMD1.A12 ; VRAMC2.H2 v6(30.7,184.8) VRAMC2.H1 ; CPU1.H23 v6(181.5,160.5) CPU1.J22 ; v6(45.9,216.9) VRAMB2.E14 46.66,217.66 46.66,217.7 v6(46.68,217.73) ; VRAMC2.U14 23.1,174.8 22.95,174.65 22.95,174.22 v6(22.95,174.22) ; PCH1.H2 v6(151.4,49.8) ; WLAN1.36 191.39,50.5 191.72,50.83 v1(192.25,50.83) ; DISPC1.21 84.97,69.25 v1(85.17,69.05) 84.86,68.75 DISPC1.20 ; v6(67.6,217.7) 68,218.1 VRAMB1.M5 68.11,218.24 68.11,218.82 VRAMB1.L5 ; v6(65.2,213.7) 65.2,213.73 VRAMB1.U1 ; v6(76.73,120.4) 77.02,120.69 PU44.37 ; v6(27.26,160.06) 27.1,159.9 VRAMD1.F5 ; DIMM2.99 190.87,102.25 v6(190.93,102.31) ; v6(59.2,143.12) 59.6,142.72 VRAMD2.R12 ; 185.1,156.1 185.14,156.14 185.86,156.14 CPU1.D27 CPU1.C28 ; 185.1,156.1 CPU1.E27 ; VRAMC1.T10 v6(35.5,200.9) ; CPU1.J25 v6(180.55,158.45) ; DIMM2.184 167.63,92.72 167.59,92.76 167.59,93.39 167.04,93.94 167.04,94.08 166.71,94.4 166.69,94.4 v6(166.54,94.56) ; CPU1.B32 v6(188.5,150.5) CPU1.A33 ; v6(53.05,221.8) 53.2,221.8 VRAMB2.L5 ; VRAMD2.P10 v6(58.4,143.1) ; GPU1.E5 54.42,195.58 v6(54.31,195.58) ; VRAMD1.T10 v6(35.5,163.9) ; v6(24.66,192.66) 24.7,192.7 VRAMC1.C1 ; CPU1.AT29 153.57,153.57 v6(153.48,153.57) ; v1(181.38,54.51) 181.64,54.25 WLAN1.51 ; DIMM2.210 161.11,91.68 161.11,90.29 v6(161.18,90.21) ; SSDC1.27 v1(103.75,102.19) ; VRAMD1.K13 v6(30.7,166.3) VRAMD1.K14 ; v6(86.14,214.51) 86.14,214.51 86.14,214.54 VRAMA2.B10 ; v6(22.87,155.68) 22.87,155.74 22.87,155.74 22.87,156.07 VRAMD1.A1 ; v6(184,182.65) CPU1.F1 ; PU42.37 88.12,120.76 87.71,120.35 v6(87.48,120.35) ; v6(50.22,142.78) 50.3,142.7 VRAMD2.R1 ; VRAMC2.R14 24.7,174.54 24.7,174.24 v6(24.65,174.19) ; VRAMA1.C3 v6(106.9,198) ; VRAMD2.R3 v6(52.8,142.3) VRAMD2.R4 ; v6(73.19,216.14) 73.19,216.11 ; 73.19,216.11 73.57,215.73 VRAMB1.R12 ; 73.19,216.11 73.19,216.09 72.83,215.73 VRAMB1.R11 ; v6(62.8,168.55) 63.25,169 GPU1.AP15 ; TYPEC1.17 v1(104.75,8.15) ; v6(46.7,221.7) VRAMB2.K13 ; v6(89.94,222.74) 90.1,222.9 VRAMA2.M5 ; v6(92.5,224.9) VRAMA2.R3 v6(91.7,225.7) VRAMA2.R4 ; DIMM2.214 160.12,92.83 160.2,92.9 160.2,93.58 v6(159.92,93.85) 159.43,93.85 159.03,93.45 159.03,92.95 159.12,92.86 DIMM2.218 ; v6(61.6,152.7) VRAMD2.C14 v6(60.8,151.9) ; VRAMA1.H2 v6(103.7,198.8) VRAMA1.H1 ; v6(22.65,157.53) 23.03,157.9 VRAMD1.A3 ; v6(32.3,203.3) VRAMC1.N14 v6(33.1,204.1) ; VRAMA2.P10 v6(86.9,224.9) ; DISPC2.39 8.16,165.25 v1(8.28,165.13) ; VRAMB1.U12 73.6,214.1 v6(74,213.7) ; VRAMB1.F10 72,222.9 v6(71.6,222.5) 71.97,222.13 VRAMB1.G10 ; VRAMA1.E1 v6(105.3,198.8) ; CPU1.AJ26 v6(160.5,157.5) ; RUSBC1.26 v1(85.34,47.25) ; CPU1.AK25 159.98,158 v6(159.51,158.47) 159,158.98 CPU1.AL24 ; VRAMD2.M10 v6(57.6,145.5) VRAMD2.L10 ; U21.3 216.3,131.92 216.28,131.91 216.28,131.06 v1(216.41,130.94) ; CPU1.AM29 v6(157.5,153.5) ; VRAMC2.G10 v6(31.5,177.6) VRAMC2.F10 ; v6(27.15,181.43) 27.1,181.48 VRAMC2.M5 ; 22.58,110.34 22.35,110.11 U24.2 ; DIMM2.205 162.37,98.27 161.87,97.76 161.83,97.76 v6(161.6,97.53) ; VRAMD2.U12 v6(60,140.7) ; VRAMD2.K2 v6(51.2,146.3) VRAMD2.K1 ; 181.48,179.49 181,179.01 CPU1.J4 ; 181.48,179.49 181.48,179.45 181.93,179 CPU1.H4 ; 181.48,179.49 v6(181.48,179.5) ; 152.62,104.93 DIMM1.244 ; CPU1.AW37 149.34,146 v6(148.86,145.52) ; VRAMA2.K13 v6(83.7,221.7) VRAMA2.K14 ; CPU1.N27 v6(177.5,155.5) ; VRAMD1.M10 v6(31.5,163.9) VRAMD1.L10 ; GPU1.AD37 83.4,178.05 83.83,177.62 v6(83.85,177.62) ; PCH1.L6 v6(154.6,46.6) ; VRAMB1.K13 VRAMB1.K14 75.2,219.7 v6(75.6,219.3) ; CPU1.AN31 157.5,151.5 v6(157.5,151.41) 157.59,151.41 CPU1.AM32 ; v6(157.12,90.16) 157.12,90.17 DIMM2.226 ; U26.11 120.07,96.65 v6(120.35,96.93) ; CPU1.D36 v6(186.5,146.5) CPU1.C37 ; v6(32.3,196.1) VRAMC1.M5 31.79,196.61 31.21,196.61 VRAMC1.L5 ; VRAMA2.U1 93.85,227.05 v6(94.26,227.05) ; v6(166.48,93.13) 166.48,93.11 166.62,92.96 166.62,91.7 DIMM2.188 ; VRAMB2.M10 49.52,222.9 v6(49.92,222.5) 49.52,222.1 VRAMB2.L10 ; v6(99.01,120.35) 99.19,120.35 99.66,120.81 PU40.37 ; v6(26.35,174.24) 26.3,174.29 26.3,174.58 VRAMC2.N14 ; VRAMA1.B10 v6(108.5,191.6) ; SSDC1.39 106.75,102.37 v1(106.73,102.39) ; VRAMA1.U3 v6(95.7,197.2) ; VRAMB1.H1 64.83,221.33 v6(65.2,221.7) 65.57,221.33 VRAMB1.H2 ; v6(33.9,175.2) VRAMC2.C14 v6(34.7,174.4) ; PU21.4 216.09,203.39 216.31,203.61 216.31,204.17 v1(216.28,204.19) ; PU42.5 86.53,118.72 86.89,119.08 v6(87.48,119.08) ; PCH1.K1 v6(150.6,48.2) ; v6(99.7,190) VRAMA1.N12 v6(99.7,190.8) ; DIMM2.180 168.62,91.7 168.62,90.27 v6(168.4,90.04) ; VRAMD2.H2 v6(51.2,148.7) VRAMD2.H1 ; DISPC2.30 8.02,160.75 8.03,160.76 v1(8.15,160.76) ; DIMM2.196 v6(164.62,90.15) ; v6(33.9,203.3) VRAMC1.R14 v6(34.7,204.1) ; VRAMA2.A1 93.7,214.03 v6(93.33,213.66) ; VRAMD2.A3 v6(52.8,154.3) ; CPU1.D31 186.5,152.5 ; 186.5,152.5 CPU1.D30 ; DIMM2.61 200.37,99.9 200.37,102.64 ; VRAMC2.K2 v6(28.3,184.8) VRAMC2.K1 ; CPU1.A3 v6(189.5,180.5) ; CPU1.U29 v6(173.5,153.5) CPU1.T30 ; VRAMD1.K2 30.48,156.92 30.48,156.48 VRAMD1.K1 v6(30.7,155.9) ; VRAMC2.U1 23.1,185.74 v6(23.04,185.8) ; v6(22.95,167.31) 22.95,166.85 VRAMD1.A14 ; DISPC2.33 8.11,162.25 8.13,162.23 v1(8.15,162.23) ; VRAMC1.N1 v6(33.1,193.7) ; v6(92.5,217.67) 92.47,217.67 VRAMA2.E3 ; v6(150.35,169.86) 150.48,170 CPU1.AW13 ; v6(68.6,222.74) 68.41,222.93 VRAMB1.F5 ; v6(158.52,149.46) 158.55,149.49 158.55,149.55 CPU1.AL33 ; VRAMC2.N1 v6(26.7,184.8) ; v6(99.01,119.08) 98.42,119.08 98.07,118.72 PU40.5 ; v6(154.13,94.21) 154.21,94.13 154.53,94.13 154.57,94.09 154.63,94.09 155.12,93.59 DIMM2.234 ; OSDC1.10 6.49,134.25 v1(5.59,134.24) 6.1,134.75 OSDC1.9 ; v6(36.3,174.4) VRAMC2.A14 v6(35.5,175.2) ; v6(32.3,182.4) VRAMC2.F5 31.79,181.89 31.21,181.89 VRAMC2.G5 ; VRAMA2.K2 v6(93.3,221.7) VRAMA2.K1 ; VRAMC1.K2 30.41,193.99 30.41,193.41 VRAMC1.K1 v6(30.7,192.9) ; VRAMD2.C1 v6(51.2,152.7) ; v1(181.23,60.07) 181.41,60.25 WLAN1.75 182.72,60.57 WLAN1.76 ; PCH1.K5 v6(154.6,47.4) PCH1.K6 ; VRAMB1.A12 73.97,227.3 73.97,227.3 v6(74,227.33) ; VRAMB1.N1 64.41,216.94 v6(64.41,216.92) ; CPU1.AK22 160.4,160.6 160.49,160.51 v6(160.49,160.47) 160.53,160.47 CPU1.AJ23 ; CPU1.AJ28 v6(161.5,155.5) ; CPU1.AV17 CPU1.AU18 v6(152.5,164.5) ; v6(26.7,202.49) 26.31,202.1 VRAMC1.E12 ; v1(130.25,6.22) 130.25,6.27 130.25,6.28 LAUOC1.15 ; VRAMD1.T5 v6(35.5,159.1) ; v6(82.7,223.44) 82.9,223.64 83.11,223.64 83.17,223.7 VRAMA2.N14 ; DIMM2.19 210.87,102.94 210.75,103.07 ; VRAMD1.N3 32.68,157.9 v6(32.29,157.51) ; PR256.2 118.4,155 118.94,155.54 PC289.2 ; VRAMB2.N1 57.17,223.7 v6(57.24,223.63) ; VRAMC2.C11 v6(33.9,176.8) VRAMC2.C12 ; VRAMA2.C4 v6(91.7,215.3) ; VRAMA1.E3 105.7,197.63 v6(105.33,197.99) ; v1(85.62,41.25) RUSBC1.14 ; v6(36.33,195.29) 35.94,194.9 VRAMC1.U3 ; v6(212.1,102.51) 211.87,102.28 DIMM2.15 ; VRAMC2.A1 v6(36.3,184.8) ; CPU1.D24 186,159.05 185.49,159.56 v6(185.49,159.57) ; v6(73.2,217.7) 73.57,217.33 VRAMB1.N12 ; VRAMC2.U3 23.02,183.6 v6(22.65,183.97) ; TYPEC1.14 v1(106.25,8.15) ; VRAMC2.C1 v6(34.7,185.6) ; VRAMD1.U3 v6(36.3,158.3) ; v6(64.35,216.07) 64.43,216.07 64.77,215.73 VRAMB1.R1 ; v1(85.6,34.8) 85.14,34.8 84.69,35.25 RUSBC1.2 ; CPU1.AH33 v6(162.5,150.5) CPU1.AG32 ; 155.85,102.92 155.87,102.9 DIMM2.231 ; VRAMD2.A1 v6(51.2,154.3) ; VRAMB2.F10 v6(49.1,218.5) VRAMB2.G10 ; VRAMC2.K13 28.69,175.6 v6(28.3,175.21) 28.7,174.8 VRAMC2.K14 ; CPU1.AR38 v6(155.5,145.5) ; PCH1.AD11 PCH1.AD12 ; CPU1.C28 CPU1.D29 185.99,153.99 185.01,153.99 CPU1.E29 CPU1.F28 ; CPU1.C28 CPU1.B29 ; DIMM2.1 216.29,99.9 v6(216.8,99.39) ; v6(33.9,157.5) VRAMD1.R3 v6(34.7,158.3) VRAMD1.R4 ; VRAMD1.H14 v6(28.3,166.3) VRAMD1.H13 ; DISPC2.36 v1(8.14,163.75) ; PCH1.AB14 v6(161,37.8) ; v6(85.55,193.2) 85.55,193.05 GPU1.H39 ; v1(8.13,152.75) 8.01,152.75 8.01,152.75 DISPC2.14 ; VRAMD2.K14 v6(60.8,146.3) VRAMD2.K13 ; CPU1.AC27 v6(167.5,155.5) CPU1.AB28 v6(168.5,154.5) CPU1.AA29 ; v6(203.77,96.31) 203.21,96.31 202.87,96.65 DIMM2.51 ; VRAMC1.H2 v6(28.3,193.7) VRAMC1.H1 ; PCH1.AA4 v6(153,38.6) ; DIMM2.222 158.12,90.22 v6(158.16,90.19) ; v1(85.67,43.1) 85.32,42.75 85.01,42.75 85.01,42.75 RUSBC1.17 ; VRAMC2.M10 v6(27.5,178.4) VRAMC2.L10 ; v6(162.46,154.53) 162.53,154.53 163,155 CPU1.AG28 ; VRAMB1.T5 68,214.9 v6(67.6,214.5) ; CPU1.AG27 163.47,155.53 163.47,155.53 v6(163.51,155.49) 163.99,155 CPU1.AF28 ; DIMM2.243 152.87,96.52 153.78,95.62 v6(153.98,95.62) ; DIMM2.189 166.37,98.54 166.45,98.47 v6(166.45,98.46) ; CPU1.AW22 151.48,160.52 v6(151.48,160.52) 152,160 CPU1.AV23 ; VRAMB1.T10 72,214.88 72.37,214.51 v6(72.38,214.51) ; PCH1.F5 v6(154.6,50.6) PCH1.G6 v6(154.6,49.8) ; VRAMB2.N3 v6(55.5,224.1) ; v6(109.35,189.98) 109.32,189.98 VRAMA1.A12 ; CPU1.AJ35 CPU1.AK35 CPU1.AJ36 ; CPU1.AB30 v6(167.5,153.5) CPU1.AC29 v6(166.5,154.5) CPU1.AD28 v6(165.5,155.5) CPU1.AE27 ; CPU1.A18 188.98,165 v6(188.5,164.52) 188,164.02 188,164.01 ; v6(93.31,216.92) 93.35,216.92 93.7,217.27 VRAMA2.E1 93.72,217.3 94.03,216.98 v6(94.13,216.98) ; VRAMC1.R12 34.31,202.1 v6(34.7,202.49) ; v6(84.52,213.69) 84.9,214.07 VRAMA2.A12 ; CPU1.A24 189.62,159 v6(189.64,158.99) ; v6(75.63,217.02) 75.51,217.02 VRAMB1.N14 ; VRAMC2.T5 v6(23.45,181.55) ; v6(36.38,202.5) 35.98,202.1 VRAMC1.U12 ; v6(22.65,175.98) 23.08,176.4 VRAMC2.U12 ; VRAMD2.A14 v6(60.8,153.5) ; LAUOC1.2 123.75,5.28 ; v1(99.26,99.14) 99.29,99.16 100.33,99.16 100.75,99.58 SSDC1.15 ; v6(105.65,188.26) 105.7,188.31 VRAMA1.E14 ; RUSBC1.23 v1(85.22,45.75) ; v6(95.66,198.86) 95.66,198.86 96,199.2 VRAMA1.U1 ; WLAN1.24 v1(191.87,47.5) ; CPU1.K30 v6(179.5,153.5) ; CPU1.AT22 v6(154.5,160.5) CPU1.AR23 ; v6(54.7,225.7) VRAMB2.R3 v6(55.5,224.9) ; VRAMA2.H14 v6(83.7,219.3) VRAMA2.H13 ; DIMM2.223 157.87,98.67 v6(157.34,98.13) ; v6(25.1,194.5) VRAMC1.C3 v6(24.3,195.3) VRAMC1.C4 ; 166.63,90.15 v6(166.59,90.12) ; v6(58.42,141.5) 58.02,141.9 VRAMD2.T10 ; v6(185.49,159.57) 185.44,159.57 185.01,160 CPU1.E23 CPU1.F22 ; v6(185.49,159.57) 185.54,159.57 185.97,160 CPU1.D23 CPU1.C22 CPU1.B23 ; v6(154.12,90.09) DIMM2.238 ; CPU1.AT13 154,170.03 v1(154.46,170.48) ; v1(8.13,147.95) 8.11,147.95 7.81,148.25 DISPC2.5 ; DIMM2.81 195.37,102.91 ; VRAMA2.U3 v6(92.5,227.3) ; CPU1.D39 186,143.46 185.92,143.38 185.92,143.01 185.59,142.68 185.16,142.68 v6(185.15,142.66) ; DIMM2.252 150.62,92.84 149.64,93.83 v6(149.64,94.13) ; VRAMC2.R4 v6(24.3,183.2) ; v6(61.74,144.35) 61.69,144.3 VRAMD2.N14 ; v6(153.45,157.48) 153.52,157.48 CPU1.AT26 CPU1.AR26 ; VRAMD2.E3 v6(52,150.3) ; CPU1.V28 v6(171.5,155.5) CPU1.W27 ; VRAMD1.N12 v6(33.1,165.5) ; GPU1.AC34 81,179.07 v6(80.72,178.79) ; WLAN1.57 181.41,55.75 v1(181.41,55.75) ; CPU1.F31 183.52,151.52 v6(183.43,151.52) ; v6(54.42,146.3) 54.02,145.9 VRAMD2.L5 ; PCH1.P2 v6(151.4,45) ; v6(83.2,195.55) 83.05,195.55 GPU1.E36 ; GPU1.C5 55.15,196.9 v6(55.6,196.45) 56.05,196 GPU1.D6 ; CPU1.AW28 150.44,154.44 149.86,154.44 v6(149.63,154.21) ; DISPC1.17 v1(85.16,67.25) ; VRAMD2.N1 v6(51.2,144.7) ; CPU1.M28 v6(178.5,154.5) CPU1.L29 ; VRAMC2.B5 v6(35.5,182.4) ; PU45.37 40.4,120.97 39.83,120.4 v6(39.62,120.4) ; VRAMD2.B5 v6(53.6,153.5) ; CPU1.A30 190,153 191.03,151.97 v6(191.03,151.28) ; VRAMA2.N12 v6(84.5,223.3) ; CPU1.AJ25 v6(161.5,157.5) ; CPU1.AT33 v6(153.5,150.5) CPU1.AU33 ; VRAMD1.R1 v6(34.7,155.9) ; v6(82.74,227.05) 82.85,226.94 83.17,226.94 83.21,226.9 VRAMA2.U14 ; CPU1.AG29 163.53,153.47 v6(163.56,153.47) 163.56,153.44 CPU1.AF30 ; LAUOC1.7 v1(126.25,6.22) ; VRAMA1.A3 v6(109.3,198) ; PCH1.D10 PCH1.C10 ; DISPC2.2 8.04,146.75 8.04,146.75 v1(8.13,146.75) ; DIMM2.247 151.87,101.4 ; v6(90.05,221.75) 90.4,222.1 VRAMA2.L5 ; v6(60,152.7) VRAMD2.C12 v6(59.2,151.9) VRAMD2.C11 ; v6(50.4,151.1) VRAMD2.E1 51.18,151.08 v6(51.2,151.08) ; VRAMA2.R14 v6(82.72,225.3) ; U26.5 121.66,97.15 v6(121.41,96.9) ; PCH1.E24 v6(169,52.2) ; v6(83.69,217.73) 83.3,217.35 VRAMA2.E14 83.23,217.3 v6(82.89,216.96) ; CPU1.AP27 CPU1.AN28 ; v6(122.4,96.9) 122.65,96.65 U26.20 ; DIMM2.107 188.87,102.91 ; PCH1.M2 v6(151.4,46.6) ; PCH1.P1 v6(150.6,45) ; v6(72.39,216.92) 72,216.53 VRAMB1.P10 ; CPU1.AN22 v6(156.5,161.5) ; PCH1.C15 v6(161.8,53.8) ; CPU1.AG30 v6(163.5,152.5) ; VRAMC2.R3 v6(25.1,184) ; PCH1.W4 v6(153,41) PCH1.W3 ; VRAMC2.C4 34.41,182.91 34.41,183.41 34.3,183.52 VRAMC2.C3 v6(33.9,184) ; VRAMA2.T10 v6(86.9,226.5) ; VRAMD2.T5 v6(54.4,141.5) ; VRAMA1.K2 101.59,198.51 101.59,199.01 101.7,199.12 VRAMA1.K1 v6(101.3,199.6) ; 91.19,7.11 91.35,6.95 TYPEC1.40 ; v6(58.4,151.09) 58,151.49 VRAMD2.D10 ; v6(216.12,92.3) 216.12,92.25 215.57,91.7 DIMM2.2 ; v6(94.24,223.63) 94.04,223.63 94.04,223.63 93.77,223.63 VRAMA2.N1 ; CPU1.H26 v6(181.5,156.5) ; OSDC1.2 6.17,138.25 v1(6.17,138.25) ; TYPEC1.20 v1(103.25,8.15) ; v6(55.5,216.1) VRAMB2.C3 v6(54.7,215.3) ; v6(209.63,102.9) 209.55,102.9 208.87,102.23 DIMM2.27 ; SSDC1.57 111.25,101.68 110.95,101.98 v1(110.11,101.98) 109.75,101.62 SSDC1.51 ; DISPC1.11 v1(85.16,64.25) ; CPU1.AC31 166.58,152.42 v6(166.58,152.5) ; VRAMC1.A14 23.1,203.79 22.95,203.94 22.95,204.32 v6(22.95,204.32) ; VRAMD2.U3 v6(52,140.7) ; v1(192.58,49.5) 192.57,49.52 192.21,49.52 191.69,49 WLAN1.30 ; v6(149.5,98.06) 149.55,98.06 149.58,98.09 150.12,98.09 150.87,98.84 DIMM2.251 ; VRAMA2.F10 86.5,218.11 v6(86.1,218.51) 86.49,218.9 VRAMA2.G10 ; PCH1.F4 v6(153,50.6) ; v6(94.37,225.34) 93.74,225.34 VRAMA2.R1 ; CPU1.B26 v6(188.5,157.5) ; v6(54.6,145.26) 54.44,145.1 VRAMD2.M5 ; VRAMD1.P10 v6(33.1,163.9) ; PU44.5 75.43,118.72 75.77,119.05 v6(76.63,119.05) ; VRAMD2.H13 VRAMD2.H14 v6(61.6,148.7) ; VRAMD2.N12 v6(60,144.7) ; VRAMC1.D10 v6(25.1,200.1) ; TYPEC1.8 v1(109.25,8.15) ; VRAMA1.T10 v6(96.5,191.6) ; v6(57.1,216.9) VRAMB2.E1 v6(56.3,216.9) ; VRAMB2.R1 57.23,225.3 57.29,225.36 v6(57.3,225.36) ; PCH1.F1 150.68,51 v6(150.5,51.18) ; v6(30.7,174.4) VRAMC2.H14 VRAMC2.H13 ; v1(8.13,151.25) 8.08,151.25 8.08,151.25 DISPC2.11 ; VRAMA2.H2 v6(93.3,219.3) VRAMA2.H1 ; CPU1.J28 v6(180.5,155.5) ; DIMM2.185 167.37,101.44 ; DIMM2.68 198.62,92.82 198.78,92.97 198.78,93.53 v6(198.4,93.91) ; VRAMD2.G10 v6(58.4,149.5) VRAMD2.F10 ; v1(180.37,46.74) 180.77,46.74 181.29,47.25 WLAN1.23 ; v6(66.8,225.73) 66.85,225.68 66.85,225.65 67.17,225.33 VRAMB1.C4 ; CPU1.AV29 v6(152.5,153.5) ; VRAMC2.R1 24.7,185.7 v6(24.78,185.78) ; VRAMA1.C11 v6(107.7,190.8) ; PCH1.C11 PCH1.C12 PCH1.C13 ; VRAMA2.U12 v6(84.5,227.3) ; PCH1.K4 v6(153.8,47.4) ; v6(156.01,143.36) 156.01,143.39 155.91,143.48 155.91,143.91 CPU1.AP39 ; CPU1.U31 v6(172.5,152.5) ; v6(156.55,152.51) 156.49,152.51 CPU1.AP30 ; WLAN1.63 v1(181.28,57.25) ; v6(97.26,199.62) 97.69,199.2 VRAMA1.R1 ; v1(105.26,102.23) 105.25,102.23 SSDC1.33 ; VRAMD2.C4 v6(52.8,152.7) VRAMD2.C3 v6(52,151.9) ; VRAMD1.E3 v6(25.9,157.5) ; VRAMC1.R1 v6(34.71,192.89) ; PCH1.N6 v6(154.6,45) ; VRAMD2.R11 v6(59.2,142.3) ; VRAMA1.E12 v6(105.3,190) ; DIMM2.9 213.37,97.98 213.99,97.37 v6(214.36,97.37) ; VRAMC1.A12 22.99,202.1 v6(22.58,202.51) ; v6(153.47,147.53) 153.47,147.47 CPU1.AU36 CPU1.AV35 ; CPU1.AH28 v6(161.5,154.5) ; PCH1.D26 v6(170.6,53) ; VRAMB1.C11 72.83,225.33 73.2,225.69 v6(73.2,225.72) ; VRAMA1.D10 v6(106.91,191.59) ; CPU1.K21 v6(179.5,161.5) ; VRAMD1.B10 v6(23.5,163.1) ; v6(26.7,184) VRAMC2.N3 ; v1(108.15,102.59) 108.25,102.49 SSDC1.45 ; VRAMA2.A14 v6(82.9,213.7) ; VRAMA1.T5 v6(96.5,196.4) ; VRAMA1.B5 v6(108.5,196.4) ; VRAMC1.B5 v6(23.5,196.1) ; v6(24.7,204.44) VRAMC1.C14 ; v6(65.2,223.3) 64.8,223.7 VRAMB1.E1 ; VRAMC1.K14 v6(30.7,203.3) VRAMC1.K13 ; DIMM2.197 164.37,101.3 ; VRAMA1.A1 108.9,199.5 v6(109.21,199.81) ; SSDC1.21 102.25,102.3 v1(102.31,102.36) ; VRAMD2.N3 v6(52,144.7) ; PCH1.AC12 PCH1.AC11 ; DIMM2.35 206.87,102.94 206.73,103.08 ; VRAMA1.U12 v6(95.7,190) ; VRAMD1.D10 v6(25.1,163.1) ; DISPC1.36 v1(85.23,76.75) ; CPU1.AT16 154.01,167 v6(154.49,166.53) 154.49,166.5 154.99,166 CPU1.AR17 ; VRAMA2.C3 v6(92.5,216.1) ; DIMM2.201 163.37,97.2 162.29,96.11 v6(161.57,96.11) ; VRAMC2.T10 v6(23.5,177.6) ; VRAMA2.T5 v6(90.9,226.5) ; CPU1.AJ38 CPU1.AK37 ; VRAMA2.C1 93.7,215.69 v6(94.1,215.29) ; CPU1.AV26 CPU1.AU26 ; PCH1.B8 v6(157,54.6) PCH1.B9 ; VRAMD1.B5 v6(23.5,159.1) ; VRAMC1.E1 26.3,192.77 v6(26.36,192.71) ; PCH1.J6 v6(154.6,48.2) ; VRAMC2.N12 v6(26.7,176) ; PCH1.AA6 v6(154.6,38.6) ; v6(56.3,221.7) VRAMB2.K1 ; VRAMB2.A3 v6(54.7,213.7) ; PCH1.AA3 v6(152.2,38.6) ; VRAMC2.B10 v6(35.5,177.6) ; DIMM1.248 151.62,104.92 ; VRAMD1.U14 v6(36.3,167.1) ; VRAMC2.E3 v6(32.3,184) ; PCH1.C16 v6(162.6,53.8) ; WLAN1.69 v1(181.38,58.75) ; VRAMA2.N3 v6(92.5,224.1) ; VRAMC1.N3 v6(32.3,194.5) ; VRAMC1.P10 v6(33.1,200.9) ; VRAMC1.U14 v6(35.5,203.3) ; VRAMA1.N3 v6(99.7,198) ; PCH1.A25 v6(169.8,55.4) ; VRAMA2.E12 v6(84.5,216.9) ; v6(50.19,141.02) 50.27,141.1 VRAMD2.U1 ; TYPEC1.26 v1(100.25,8.15) ; v6(84.5,215.3) VRAMA2.C12 ; DISPC2.27 v1(8.14,159.25) ; VRAMA2.A3 v6(91.7,213.7) ; PCH1.Y2 v6(151.4,40.2) ; VRAMB2.E3 v6(55.5,217.7) ; v1(85.14,59.51) 84.9,59.75 DISPC1.2 ; DISPC1.30 v1(85.18,73.75)
  TOP w0.356: v1(140.41,97.13) 140.04,96.76 SRCON1.4 ; PCH1.AD6 154.62,36.98 v6(154.61,36.98) 154.6,36.97 154.57,36.97 PCH1.AD5 ; GPU1.Y36 82.6,182.05 v6(82.25,182.4) ; PCH1.B24 v6(169.8,54.6) ; PCH1.P21 v6(166.6,44.2) PCH1.R21 ; PCH1.C17 v6(164.2,53.8) ; PCH1.AC4 v6(153,37.8) ; PR186.2 144.95,216.24 v1(144.81,216.38) ; PCH1.G23 v6(168.2,50.6) ; v6(168.2,50.6) PCH1.G22 ; v6(168.2,50.6) PCH1.F22 ; PCH1.AC20 v6(166.6,37) PCH1.AD20 PCH1.AD19 ; CPU1.AR27 CPU1.AP27 ; PCH1.AF15 v6(162.6,35.4) PCH1.AE15 ; PCH1.AA17 v6(163.4,38.6) ; PCH1.AA24 v6(169,38.6) ; PCH1.AA14 v6(161,38.6) ; PCH1.AD15 v6(162.6,36.2) PCH1.AD16 ; PCH1.C10 v6(158.6,53.8) PCH1.C11 ; VRAMA1.A14 109.27,188.8 v6(109.43,188.64) ; Q86.1 v1(122.4,112.49) ; v1(215.58,141.65) Q25.1 ; PCH1.AD24 v6(169,36.2) ; PCH1.N21 v6(166.6,45.8) PCH1.M21 ; v6(161.8,53.8) PCH1.C14 v6(161,53.8) PCH1.C13 ; PCH1.AF23 v6(168.2,35.4) PCH1.AE23 ; PCH1.AA15 v6(162.6,38.6) PCH1.AA16 ; PCH1.C18 v6(165,53.8) ; PCH1.AC24 v6(169,37) ; U36.5 127.78,196.71 128.14,196.34 v1(128.14,195.45) ; GPU1.BA18 65.65,163.1 v6(65.2,162.65) 64.75,162.2 GPU1.BB17 ; PCH1.AD22 v6(168.2,37) ; PCH1.M24 PCH1.N23 v6(169,45) PCH1.P24 ; PCH1.F15 162.2,51 v6(162.59,51.38) 162.97,51 PCH1.F16 ; PCH1.AB17 v6(164.2,37.8) PCH1.AC17 ; CPU1.B19 188,164.01 ; PCH1.AF11 v6(158.6,35.4) PCH1.AE11 ; PCH1.K24 v6(169,47.4) PCH1.K23 ; CPU1.G21 183,161.98 183.47,161.51 v6(183.47,161.45) 183.54,161.45 183.98,161 CPU1.F22 ; Q86.4 127.9,111.19 v1(128.21,111.5) ; PCH1.E10 PCH1.E9 v6(157,52.2) ; PCH1.F13 PCH1.F12 ; PCH1.F13 v6(161,51.4) PCH1.F14 v6(161,50.6) PCH1.F13 ; PCH1.H22 v6(168.2,49.8) PCH1.H23 ; PCH1.D19 v6(165.8,53) ; PCH1.F19 165.38,51 v6(165,51.38) 164.61,51 PCH1.F18 164.57,51 164.21,51.36 v6(164.21,51.38) ; PCH1.AD12 v6(160.2,36.2) PCH1.AD13 ; PCH1.AB24 v6(169,37.8) ; PCH1.AC1 v6(150.6,37.8) ; PCH1.D22 v6(168.2,52.2) ; PCH1.AA18 v6(164.2,38.6) ; PCH1.AF19 v6(165.8,35.4) PCH1.AE19 ; PCH1.L21 v6(166.6,47.4) ; v1(203.68,145.39) 203.69,145.39 U20.1 ; PCH1.H1 v6(151.4,49.8) ; PCH1.N26 v6(171.4,45) ; PCH1.AD18 v6(164.2,36.2) ; PCH1.G26 v6(171.4,50.6) ; PCH1.J23 v6(168.2,49) PCH1.J22 ; RN2413.1 213.47,157.39 v1(213.26,157.18) 213.7,156.74 RN2413.2 ; PCH1.AC2 v6(151.4,37.8) ; PCH1.AA13 v6(160.2,38.6) ; v6(160.2,38.6) PCH1.AA12 ; v6(160.2,38.6) PCH1.AB12 ; PCH1.AC22 v6(167.4,37) ; GPU1.BA23 70.11,162.61 v1(70.08,162.61) 69.89,162.61 GPU1.BA21 ; PCH1.F9 v6(157.8,50.6) PCH1.F10 PCH1.F11 ; GPU1.AU25 73.58,166.02 73.58,165.35 74.04,164.9 GPU1.AW26 ; PCH1.AA10 v6(157.8,38.6) ; PCH1.AE13 v6(161,35.4) PCH1.AF13 ; PCH1.AB23 v6(168.2,37.8) ; PCH1.AA19 v6(165.8,38.6) PCH1.AA20 ; 91.44,5.59 TYPEC1.45 ; PCH1.AB10 158.53,37.86 158.57,37.86 v6(158.6,37.84) 158.63,37.81 158.63,37.77 PCH1.AC11 ; PCH1.J26 v6(170.6,49) PCH1.J25 ; PCH1.D23 v6(169,52.2) ; PCH1.G25 v6(169.8,50.6) PCH1.G24 ; PCH1.AA21 v6(166.6,38.6) ; PCH1.AE25 v6(170.6,35.4) ; v6(34.7,155.9) 34.8,155.8 35.41,155.8 35.9,156.3 VRAMD1.U1 ; PCH1.D20 v6(166.6,53) ; PCH1.AD14 v6(161,36.2) ; PCH1.AF25 v6(170.6,34.6) ; PCH1.F1 PCH1.F2 PCH1.F3 v6(153,50.6) ; PCH1.AD21 v6(167.4,36.2) ; PCH1.W21 v6(167.4,40.2) ; PCH1.P4 153.53,44.47 154.04,44.47 154.18,44.6 PCH1.P5 v6(154.6,45) PCH1.P6 ; PCH1.M7 PCH1.M6 ; PCH1.AB22 v6(167.4,37.8) ; CPU1.J31 CPU1.K30 ; PCH1.AC3 v6(152.2,37.8) ; v6(182.5,153.5) CPU1.G30 ; PCH1.AB20 v6(165.8,37.8)
  TOP w0.381: v6(52.65,168) 52.2,167.55 GPU1.AT2 ; CPU1.AC13 v6(167.5,170.5) ; GPU1.AJ29 76.6,172.6 GPU1.AK29 76.75,172.2 77.13,171.82 v6(77.18,171.82) ; GPU1.AG23 70.92,175 v6(70.41,175.51) ; CPU1.R11 CPU1.T12 ; CPU1.T12 CPU1.R13 v6(175.5,170.5) CPU1.P12 ; CPU1.T12 v6(173.5,171.5) CPU1.U11 ; CPU1.J15 181.4,168.4 v6(181.49,168.4) 181.49,168.49 CPU1.H14 ; CPU1.K26 v6(179.5,157.5) CPU1.L25 ; CPU1.AU26 153,157.04 v6(153.45,157.48) ; v6(70.02,166.18) 70.44,166.6 GPU1.AU23 ; R521.1 112.59,188.25 112.73,188.39 v1(113.31,188.39) 113.33,188.37 113.33,187.48 112.99,187.13 R528.1 ; CPU1.AN4 v6(157.5,178.5) CPU1.AM5 ; CPU1.AT1 154,182.28 153.95,182.33 v6(153.95,182.7) ; CPU1.J11 v6(180.5,171.5) CPU1.K12 179.56,170.56 179.53,170.56 v6(179.52,170.55) 179.51,170.54 179.51,170.51 CPU1.L13 CPU1.M14 ; v1(35.28,119.35) 35.3,119.37 PC358.2 ; v1(61.8,177.57) 61.87,177.65 61.87,177.83 62.2,178.15 GPU1.AD14 ; CPU1.AD4 v6(165.5,179.5) ; v6(64,166.95) 64.45,167.4 GPU1.AT17 ; GPU1.AC27 74.52,179.48 v6(74.42,179.48) 74.42,179.42 GPU1.AC26 ; v6(87.35,182.4) 86.9,182.85 GPU1.W41 ; CPU1.R8 v6(175.5,174.5) ; v6(175.5,174.5) CPU1.P8 ; v6(175.5,174.5) CPU1.R9 ; GPU1.AU24 71.95,166.6 v6(72.4,166.15) 72.85,166.6 GPU1.AU25 ; GPU1.L14 62.05,190.2 v6(61.6,190.65) ; CPU1.F17 v6(184.5,166.5) CPU1.E17 ; CPU1.T10 v6(173.5,173.5) CPU1.U9 ; v6(189.49,167.52) 189.48,167.52 CPU1.A15 ; CPU1.AD12 v6(165.5,170.5) CPU1.AE13 ; v6(79.6,165.35) 79.15,164.9 GPU1.AW32 ; v6(79.6,165.35) 80.05,165.8 GPU1.AV33 ; v6(79.6,165.35) 79.15,165.8 GPU1.AV32 ; v6(88.2,161.8) GPU1.BB43 v6(89.15,161.85) ; v6(88.2,161.8) GPU1.BC42 ; v6(88.2,161.8) GPU1.BB42 ; CPU1.M10 v6(177.5,173.5) CPU1.N9 ; GPU1.AA9 58.2,180.75 v6(57.75,181.2) ; v6(57.75,188.4) 58.2,187.95 GPU1.P9 58.2,187.55 v6(58.55,187.2) ; GPU1.AR33 80.05,168.2 v6(79.6,167.75) 79.15,168.2 GPU1.AR32 ; GPU1.AW41 86.9,165.36 v6(87.17,165.63) ; GPU1.AE23 70.93,177 v6(70.43,176.5) 70,176.94 GPU1.AE22 ; GPU1.BA36 82.75,163.1 v6(83.2,162.65) 83.65,163.1 GPU1.BA38 ; GPU1.AP30 77.95,169 78.32,168.63 v6(78.46,168.63) ; v6(61.6,197.35) 62.05,196.9 GPU1.C14 62.65,196.45 ; GPU1.AC40 86,179.25 v6(86.45,178.8) 86,178.35 GPU1.AD40 ; GPU1.L12 60.85,190.2 v6(60.4,190.65) ; GPU1.AV4 54,166.1 v6(53.55,165.65) ; GPU1.AD26 74.45,178.45 v6(74.45,178.49) 74.51,178.49 GPU1.AD27 ; v6(55.35,178.8) 55.8,179.25 GPU1.AC6 ; CPU1.D25 CPU1.C25 ; CPU1.C25 CPU1.B26 ; CPU1.C25 CPU1.D24 ; CPU1.AK4 v6(160.5,178.5) CPU1.AJ5 ; v6(157.54,181.56) 157.1,182 CPU1.AN1 ; CPU1.AA1 169,182.69 v1(169,182.69) ; CPU1.J9 181.46,174.46 v6(181.46,174.53) 181.46,174.54 CPU1.J8 ; GPU1.AV38 84.27,166 v6(84.59,165.68) ; CPU1.AH24 v6(162.53,158.47) CPU1.AG25 ; CPU1.AK14 v6(160.5,168.5) ; R2641.2 106.49,151.9 106.81,152.22 v1(107.39,152.22) ; CPU1.P4 v6(175.5,179.5) CPU1.R4 ; C518.2 12.62,137.85 v1(12.34,138.13) ; GPU1.W22 70,182.98 v6(70.46,182.52) 70.94,183 GPU1.W23 ; v6(87.35,168) 87.8,167.55 GPU1.AT42 GPU1.AT43 89.47,167.4 89.69,167.61 v6(89.76,167.61) ; v6(87.35,168) 86.9,168.45 GPU1.AR41 ; v6(87.35,168) 86.9,167.55 GPU1.AT41 86.9,167.12 v6(87.21,166.8) ; v6(55.5,194.5) GPU1.F6 v6(56.6,193.4) GPU1.H8 GPU1.J9 v6(59.3,190.7) ; v6(74.42,185.52) 74,185.1 GPU1.U26 ; v6(74.42,185.52) 74.42,185.57 74,185.99 GPU1.T26 ; v6(74.42,185.52) 74.47,185.52 74.99,185 GPU1.U27 ; v6(178.5,156.5) CPU1.L27 ; v6(71.2,189.85) 70.75,189.4 GPU1.M23 ; CPU1.A9 v6(189.5,174.5) ; GPU1.AG26 74.45,175.45 v6(74.45,175.46) 74.54,175.46 GPU1.AG27 ; GPU1.H27 75.55,192.6 v6(76,193.05) ; GPU1.T28 v6(76.5,186.5) ; v6(84.59,165.68) 85.1,166.19 GPU1.AV39 ; v6(84.59,165.68) 85.05,165.22 GPU1.AW39 85.05,164.92 v6(85.73,164.25) ; CPU1.D19 v6(186.5,164.5) CPU1.D18 ; GPU1.AA15 v6(63.5,180.5) GPU1.AB15 ; CPU1.K27 v6(179.5,156.5) ; CPU1.L4 179,179.04 178.54,179.5 v6(178.51,179.5) 178.01,179 CPU1.M4 ; GPU1.AJ36 82.75,173.25 82.75,172.57 82.6,172.43 GPU1.AK36 82.6,172.09 83.03,171.65 v6(83.03,171.55) 83.4,171.18 GPU1.AM37 ; GPU1.AJ36 82.93,173.73 82.93,174.13 GPU1.AG37 83.4,174.45 v6(83.85,174) ; GPU1.AJ36 81.8,174.2 GPU1.AG35 ; CPU1.AH10 v6(162.5,172.5) CPU1.AG11 ; GPU1.U30 77.4,185 GPU1.U29 GPU1.V30 77.8,184.35 v6(78.25,184.8) ; v6(52.65,175.2) 52.2,174.75 GPU1.AG2 ; CPU1.V4 v6(172.5,179.5) CPU1.U4 ; v6(153.45,158.48) 153,158.93 CPU1.AU24 ; CPU1.AD10 v6(165.5,172.5) CPU1.AE11 ; CPU1.AC8 v6(167.5,175.5) CPU1.AB7 ; CPU1.L17 v6(178.5,165.5) CPU1.M18 v6(177.5,164.5) CPU1.N19 ; v6(56.15,176.4) 55.8,176.05 GPU1.AF6 ; v6(70.41,175.51) 70.89,176 GPU1.AF23 ; v6(70.41,175.51) 70,175.92 GPU1.AF22 ; v6(70.41,175.51) 70,175.11 GPU1.AG22 ; PC122.2 218.69,225.03 218.69,224.2 217.54,223.05 216.92,223.05 PC119.2 ; GPU1.A2 52.09,198.7 v6(51.76,198.37) 52.3,197.83 GPU1.B2 ; v6(61.68,185.98) 61.77,185.98 62.2,185.55 GPU1.U14 62.6,185 GPU1.U15 ; v6(85.68,165.57) 86,165.9 GPU1.AV40 86,166.45 v6(86.35,166.8) 86,167.15 GPU1.AT40 86.16,167.56 86.16,168.44 GPU1.AR40 86,168.75 86.12,168.87 86.12,169.4 86,169.52 GPU1.AN40 ; GPU1.BA33 80.37,163.1 v6(80.82,163.55) 81.27,163.1 GPU1.BA35 ; CPU1.L11 v6(179.5,172.5) CPU1.K10 ; CPU1.AL11 v6(159.5,171.5) CPU1.AK12 CPU1.AJ13 ; GPU1.AD5 54.9,177.92 54.8,177.83 54.8,177.8 GPU1.AE4 ; GPU1.U23 70.9,185 v6(70.43,184.53) 70,184.97 GPU1.U22 ; CPU1.AF8 v6(163.5,174.5) CPU1.AG9 ; CPU1.AF8 CPU1.AE7 ; CPU1.AF8 v6(163.5,175.5) CPU1.AG8 ; GPU1.Y35 81.8,181.95 v6(82.25,182.4) ; GPU1.AM32 79.2,172 GPU1.AK32 79.4,172.35 v6(79.85,172.8) ; 86.9,172.05 GPU1.AK41 ; 86.9,172.05 v6(86.45,171.6) 86,172.05 GPU1.AK40 86,172.46 86.13,172.59 86.13,173.22 ; 86.9,172.05 v6(87.35,171.6) ; CPU1.Y12 v6(169.5,170.5) CPU1.AA13 ; v6(154.52,177.43) 154.52,177.52 CPU1.AR5 ; CPU1.U13 173.47,169.53 v1(173.47,169.52) ; GPU1.AA22 70,180.93 v6(70.41,180.52) 70.89,181 GPU1.AA23 ; GPU1.AP25 72.75,169.25 v6(72.4,169.25) 72.07,169.58 72.06,169.58 71.84,169.8 GPU1.AN24 ; GPU1.AD22 70,177.95 v6(70.43,177.52) 70.91,178 GPU1.AD23 ; v6(77.17,168.71) 77.04,168.71 76.75,169 GPU1.AP29 ; U28.4 114.72,161 v1(114.43,161.29) ; v6(60.4,193.05) 60.85,192.6 GPU1.H12 ; CPU1.AM11 157.51,172.49 v6(157.51,172.5) ; GPU1.AB23 70.91,180 v6(70.41,179.5) 70.41,179.55 70,179.96 GPU1.AB22 ; CPU1.M27 v6(178.5,155.5) ; v6(73.6,196.45) 74.05,196.9 GPU1.C26 74.48,196.9 74.57,197 74.6,197 GPU1.B27 ; v6(65.49,186.55) 65.04,187 GPU1.R17 ; GPU1.AW2 52.2,164.85 v6(51.75,164.4) ; v6(66.4,168.55) 66.85,169 GPU1.AP19 ; GPU1.AV9 58.47,165.8 v6(58,165.33) ; GPU1.A6 v6(56.2,199.4) ; CPU1.AP24 v6(156.5,158.5) CPU1.AN25 ; PC275.2 109.65,154.46 v1(109.52,154.33) ; v6(55.35,188.4) 55.8,187.95 GPU1.P6 ; CPU1.AK10 160.51,172.49 v6(160.53,172.49) 160.58,172.44 160.58,172.42 CPU1.AJ11 v6(161.5,171.5) CPU1.AH12 v6(162.5,170.5) CPU1.AG13 ; GPU1.W26 74,183.09 v6(74.42,183.51) 74.94,183 GPU1.W27 ; CPU1.AW22 150.32,161 149.8,160.48 149.8,159.07 150.86,158 CPU1.AW25 ; v6(80.8,167.75) 81.15,167.4 GPU1.AT35 ; v6(86.45,187.2) 86.9,187.65 GPU1.P41 86.9,187.87 87.8,188.77 GPU1.M42 ; GPU1.AN36 82.6,170.1 v6(82.32,170.38) 82.32,170.5 81.83,171 GPU1.AM35 ; v6(80.65,189.6) 80.2,189.15 GPU1.M33 ; v6(158.55,169.52) 158.52,169.52 CPU1.AM14 ; GPU1.AD2 52.2,178.35 v6(52.65,178.8) ; CPU1.AH14 v6(162.5,168.5) CPU1.AG15 ; CPU1.D15 185.6,168.4 v6(185.5,168.4) 185.5,168.5 CPU1.E14 ; v6(83.05,186) 82.6,185.55 GPU1.U36 ; GPU1.AA33 80.2,180.41 v6(79.81,180.01) 79.81,180.16 79.4,180.57 GPU1.AA32 ; GPU1.J35 v6(82.1,192.1) ; v6(163.5,172.5) CPU1.AF10 CPU1.AE9 ; CPU1.AV2 v6(151.5,181.5) ; v6(178.54,174.49) 178.54,174.54 CPU1.L8 ; v6(178.54,174.49) 178.54,174.46 178.99,174 CPU1.L9 ; v6(178.54,174.49) 178.03,175 CPU1.M8 ; CPU1.AG23 v6(162.5,160.5) CPU1.AH22 ; GPU1.B20 68.31,197.8 v6(68.82,197.29) 68.82,197.25 69.17,196.9 GPU1.C21 ; v6(58,197.35) 58.45,196.9 GPU1.C9 59.39,196.11 59.44,196.11 59.55,196 GPU1.D11 ; GPU1.C18 65.65,196.9 v6(65.2,197.35) ; GPU1.V6 55.8,183.95 v6(56.15,183.6) ; GPU1.AK24 71.85,172.2 v6(72.4,171.65) ; CPU1.E8 v6(184.5,175.5) ; v1(163,182.68) CPU1.AG1 ; GPU1.AR9 58.4,169.02 v6(58.58,169.2) ; CPU1.AR8 v6(154.5,175.5) CPU1.AT7 ; CPU1.W13 171.53,169.47 v1(171.58,169.47) ; v6(52.65,181.2) 52.2,181.65 GPU1.Y2 ; GPU1.AT26 74.35,167.4 74.82,166.93 v6(74.83,166.93) 74.97,167.08 75.1,167.08 75.37,167.36 75.37,167.37 GPU1.AT27 ; GPU1.M2 52.2,188.85 v6(52.65,188.4) ; CPU1.L15 v6(178.5,167.5) CPU1.M16 CPU1.N17 ; v1(166,182.68) CPU1.AD1 ; GPU1.AF36 82.6,175.88 82.77,176.05 82.77,176.14 82.8,176.17 82.8,176.63 82.6,176.82 GPU1.AE36 82.6,177.25 82.19,177.66 v6(82.19,177.7) 82.15,177.7 81.8,178.05 GPU1.AD35 ; v6(55.35,181.2) 55.8,180.75 GPU1.AA6 ; v6(78.4,197.35) 77.95,196.9 GPU1.C30 77,196.1 76.97,196.1 76.88,196 GPU1.D29 ; v6(71.2,194.65) 70.75,194.2 GPU1.F23 ; CPU1.V1 172,182.63 v6(171.93,182.7) ; v6(171.48,176.45) 171.51,176.45 171.61,176.36 CPU1.V7 ; GPU1.AC22 70,178.92 v6(70.41,178.51) 70.9,179 GPU1.AC23 ; GPU1.AA26 74,181.06 v6(74.42,181.48) 74.52,181.48 75,181.01 GPU1.AA27 ; CPU1.K22 v6(179.5,161.5) CPU1.L21 v6(178.5,162.5) CPU1.M20 ; v6(74.8,170.15) 74.35,170.6 GPU1.AM26 ; GPU1.AB26 74.45,180.45 v6(74.45,180.47) 74.53,180.47 GPU1.AB27 ; v6(57.75,178.8) 57.4,178.45 GPU1.AD8 ; GPU1.BA30 77.95,163.1 v6(78.4,163.55) 78.85,163.1 GPU1.BA32 ; GPU1.H26 74.35,192.6 v6(74.8,193.05) ; PC291.2 126.43,155.38 v1(126.57,155.24) ; GPU1.AV1 v6(50.5,166.2) ; GPU1.Y26 74.42,182.42 v6(74.42,182.47) 74.53,182.47 GPU1.Y27 ; GPU1.BC6 v6(56.2,160.6) ; CPU1.J17 180.75,166 180.5,165.75 v6(180.5,165.5) CPU1.K18 v6(179.5,164.5) CPU1.L19 ; v6(87.35,192) 86.9,191.55 GPU1.J41 86.9,191.25 v6(86.45,190.8) 86,190.35 GPU1.L40 ; CPU1.A12 189.55,171 v6(189.75,171.2) ; GPU1.AK27 75.61,172.2 v6(75.96,171.85) ; GPU1.AK18 65.65,172.2 v6(65.2,171.75) 64.75,172.2 GPU1.AK17 64.21,172.2 v6(63.99,171.98) 63.77,172.2 GPU1.AK15 63.4,172.6 GPU1.AJ15 ; 61.75,162.65 GPU1.BA14 62.35,163.1 v6(62.8,163.55) ; v6(87.35,175.2) 87.35,175.31 86.9,175.76 GPU1.AF41 ; CPU1.AT10 154.48,172.52 v6(154.49,172.52) 154.49,172.51 CPU1.AR11 ; GPU1.H32 79.15,192.6 v6(79.6,193.05) ; GPU1.L4 54,190.48 53.9,190.57 53.9,190.6 GPU1.J3 ; CPU1.AJ8 161.49,174.51 v6(161.49,174.42) 161.42,174.42 CPU1.AJ9 ; GPU1.AF26 74.45,176.45 v6(74.45,176.48) 74.52,176.48 GPU1.AF27 ; v6(174.96,182.85) 175,182.81 CPU1.R1 ; GPU1.AW33 80.35,164.9 v6(80.8,165.35) 81.25,164.9 GPU1.AW35 ; CPU1.N11 v6(177.5,171.5) CPU1.M12 ; GPU1.BA40 85.9,163.1 v6(85.45,162.65) GPU1.BA39 ; GPU1.A29 76.6,199.39 v6(76.57,199.42) ; v6(71.2,192.25) 71.55,192.6 GPU1.H24 ; v6(77.19,165.23) 77.19,165.17 76.92,164.9 GPU1.AW29 ; v6(77.19,165.23) 77.52,164.9 GPU1.AW30 ; v6(77.19,165.23) 76.62,165.8 GPU1.AV29 ; v6(77.19,165.23) 77.76,165.8 GPU1.AV30 ; GPU1.AE26 74,177.07 74.4,177.47 v6(74.4,177.5) 74.57,177.5 75,177.07 GPU1.AE27 ; GPU1.AJ14 62.2,173.19 v6(61.82,172.81) ; GPU1.Y22 70,181.92 70.02,181.9 v6(70.41,181.51) 70.9,182 GPU1.Y23 ; CPU1.AW7 150.26,176 150.22,176.05 v1(150.22,176.05) ; GPU1.V27 74.93,184 v6(74.42,184.51) 74,184.08 GPU1.V26 ; CPU1.K20 v6(180.5,162.5) ; v6(87.2,164.42) 86.9,164.12 GPU1.AY41 86.9,162.82 v6(86.73,162.65) ; GPU1.A33 v6(80.2,199.4) ; GPU1.R27 75,187.4 GPU1.P27 75.68,187.8 75.77,187.7 76.23,187.7 76.32,187.8 GPU1.P29 76.6,187.4 GPU1.R29 77.4,186.6 GPU1.R30 77.8,186.41 v6(78.27,185.94) ; CPU1.AC9 v6(167.5,174.5) ; GPU1.AH16 v6(64.5,173.5) GPU1.AJ17 ; CPU1.AB12 v6(168.5,171.5) ; GPU1.H20 68.45,192.6 v6(68.8,192.25) ; PQ2.S 17.49,144.56 16.71,145.34 v1(15.8,145.34) ; CPU1.P10 v6(175.5,172.5) ; v6(167.46,178.46) 167.46,178.46 CPU1.AC5 ; GPU1.H2 52.2,192.45 v6(52.65,192) ; GPU1.AC15 v6(63.48,179.47) ; CPU1.AL9 v6(158.49,174.5) ; GPU1.L32 79.15,190.2 v6(79.6,190.65) ; v6(50.62,193.78) 50.63,193.8 GPU1.F1 ; GPU1.AY3 v6(52.58,163.28) ; GPU1.V22 70,183.97 v6(70.43,183.54) 70.89,184 GPU1.V23 ; CPU1.G7 v6(182.45,175.45) CPU1.H8 ; CPU1.Y5 v6(169.5,177.5) CPU1.AA6 ; GPU1.AC41 86.9,179.25 v6(87.35,178.8) ; GPU1.C23 70.75,196.9 v6(71.2,197.35) ; v6(61.8,174.02) 62.2,174.42 GPU1.AG14 62.6,175 GPU1.AG15 ; CPU1.AG17 v6(162.5,166.5) CPU1.AH16 ; CPU1.AB10 v6(168.5,173.5) CPU1.AA9 CPU1.Y8 ; CPU1.M14 177.53,168.53 177.53,168.43 v6(177.5,168.4) 177.4,168.4 CPU1.N15 ; CPU1.M14 CPU1.N13 ; v6(150.46,179.35) 150.46,179.35 150.81,179 CPU1.AW4 ; CPU1.H11 v6(182.5,172.5) ; GPU1.L1 v6(50.6,190.2) ; v6(180.47,160.45) 180.47,160.43 180.04,160 CPU1.K23 ; v6(77.2,170.95) 77.05,170.95 GPU1.AL29 ; GPU1.V3 52.2,185.1 GPU1.U2 ; GPU1.AR36 81.8,168.6 GPU1.AR35 81.4,168.4 v6(80.6,169.2) 80.2,169.6 GPU1.AN33 ; GPU1.AN12 61.25,169.8 v6(61.6,170.15) 62.05,170.6 GPU1.AM14 ; R524.1 111.69,191.65 111.28,191.24 v1(111.23,191.24) ; PC289.2 118.94,156.17 118.53,156.58 117.6,156.58 117.58,156.57 117.25,156.57 v1(117.22,156.59) ; GPU1.T23 70.91,186 v6(70.43,185.52) 70,185.96 GPU1.T22 ; GPU1.AC33 80.2,179.15 v6(79.85,178.8) 79.85,178.62 79.66,178.42 79.66,178.41 79.44,178.2 GPU1.AD32 ; CPU1.D9 v6(186.5,174.5) ; CPU1.AK1 160.01,182 v6(160.46,182.45) ; CPU1.N21 v6(177.5,161.5) ; CPU1.AF5 163.49,178.51 v6(163.47,178.51) 163.47,178.53 CPU1.AG4 ; v6(186.5,171.51) 186.5,171.5 CPU1.D12 ; v6(76,162.4) 76.6,163 GPU1.BA29 ; v6(55.35,168) 55.8,168.45 GPU1.AR6 ; v6(155.5,168.48) 155,168.99 CPU1.AR14 ; R2640.2 v1(104.14,147.15) ; v6(177.93,182.65) 178,182.58 CPU1.M1 ; GPU1.M26 74.65,189.85 ; CPU1.AA11 v6(169.5,172.5) CPU1.Y10 ; CPU1.AP6 v6(155.5,176.5) ; GPU1.BA4 v6(52.95,162.25) ; v6(70,171.17) 70.21,171.17 70.44,171.4 GPU1.AL23 ; GPU1.AA36 82.6,180.45 v6(83.05,180) 82.6,179.55 GPU1.AC36 ; CPU1.N25 v6(177.5,157.5) CPU1.M26 ; GPU1.AK12 60.6,172.05 v6(60.15,171.6) 59.8,171.25 GPU1.AM11 59.35,170.55 v6(59.35,170.4) ; GPU1.F14 61.75,194.65 ; GPU1.AW43 89.08,164.62 v6(89.08,164.33) ; CPU1.AW10 v1(150.32,173) ; GPU1.B36 82.45,197.8 v6(82,197.35) 81.55,196.9 GPU1.C35 ; v6(161.5,154.5) CPU1.AH29 ; CPU1.N23 v6(177.5,159.5) CPU1.M24 ; CPU1.AG21 v6(162.5,162.5) CPU1.AH20 ; GPU1.AT38 84.2,167.25 v6(84.65,166.8) 85.1,167.25 GPU1.AT39 ; CPU1.AH18 v6(162.5,164.5) CPU1.AG19 ; GPU1.H17 64.15,193.05 ; GPU1.AM18 65.65,170.6 v6(65.2,170.15) ; v6(55.55,163.5) 56.05,164 GPU1.AY6 ; CPU1.AG31 v6(163.5,152.5) ; CPU1.AA4 v6(168.5,179.5) ; CPU1.AC11 v6(167.5,172.5) ; GPU1.AW38 83.7,164.9 v6(83.2,164.4) 82.7,164.9 GPU1.AW36 ; v6(185.5,172.5) CPU1.E11 ; GPU1.K29 77.05,191.45 ; CPU1.A6 v6(189.65,177) ; GPU1.L43 v6(89.42,190.2) ; CPU1.AF12 v6(163.5,170.5)
  TOP w0.4: GPU1.U42 87.35,184.95 v6(87.35,184.8) ; v6(58.55,172.8) 58.55,172.95 GPU1.AJ10 ; GPU1.W10 58.55,183.45 v6(58.55,183.6) ; GPU1.J21 68.95,192.25 v6(68.8,192.25) ; v6(56.95,170.4) 56.95,170.55 GPU1.AM8 ; v6(51.7,160.85) 51.85,160.85 GPU1.BC2 ; v6(52.65,175.2) 52.65,175.35 GPU1.AF3 53.1,175.95 v6(53.55,176.4) 53.55,176.55 GPU1.AE4 ; v6(74.8,170.15) 75.11,169.84 75.25,169.84 75.3,169.8 GPU1.AN27 ; v6(56.95,174) 56.95,174.15 GPU1.AG8 ; GPU1.AF12 60.15,175.35 v6(60.15,175.2) ; v6(63.4,199.4) GPU1.A15 ; GPU1.M21 68.95,189.85 v6(68.8,189.85) ; GPU1.AE10 58.55,176.55 v6(58.55,176.4) ; GPU1.AN1 v6(50.6,169.8) ; v6(59.35,170.4) v6(58.58,169.2) ; GPU1.F40 86.45,194.25 v6(86.45,194.4) ; GPU1.B43 89.15,198.15 v6(89.15,198.3) ; GPU1.A19 v6(67,199.4) ; v6(60.15,178.8) 60.15,178.95 GPU1.AC12 ; v6(78.4,189.85) 78.25,189.85 GPU1.M30 ; GPU1.AG10 58.55,174.15 v6(58.55,174) ; v6(84.65,188.4) 84.65,188.25 GPU1.P38 ; GPU1.AA40 86.11,180.71 86.11,181.43 86.06,181.48 86.06,181.74 GPU1.Y40 86.45,182.25 v6(86.45,182.4) 86.45,182.55 GPU1.W40 ; GPU1.BB18 GPU1.BC18 ; GPU1.BB18 v6(65.2,162.65) ; GPU1.BB18 65.93,162.2 v6(66.4,162.68) ; GPU1.B12 61.15,197.8 v6(61.6,197.35) ; v6(78.4,197.35) 78.55,197.35 GPU1.B32 ; GPU1.R10 58.55,187.05 v6(58.55,187.2) ; v6(52.65,192) 52.65,191.85 GPU1.J3 ; GPU1.F21 68.94,194.66 v6(68.8,194.66) ; GPU1.AT12 60.55,166.95 v6(60.4,166.95) ; GPU1.AL25 v6(72.4,171.65) ; GPU1.AC32 79.4,179.33 79.71,179.01 79.71,178.98 79.78,178.92 79.78,178.87 v6(79.85,178.8) ; v6(73.6,191.45) 73.45,191.45 GPU1.K25 ; GPU1.Y8 57.4,181.55 v6(57.75,181.2) ; v6(79.85,177.6) 79.85,177.45 GPU1.AE32 79.85,176.55 v6(79.85,176.4) 79.85,176.25 GPU1.AF32 79.85,175.35 v6(79.85,175.2) 79.85,175.05 GPU1.AG32 79.85,174.15 v6(79.85,174) 79.85,173.85 GPU1.AJ32 79.85,172.95 v6(79.85,172.8) ; GPU1.AY18 65.95,164 v6(66.4,163.55) ; v6(68.8,166.95) 68.95,166.95 GPU1.AT21 ; GPU1.A25 73,198.77 73.02,198.79 73.02,199.3 73,199.32 v6(73,199.4) ; v6(62.8,163.55) 62.95,163.55 GPU1.AY15 ; GPU1.AV14 61.75,165.35 v6(61.6,165.35) ; GPU1.AY19 66.55,163.55 v6(66.4,163.55) ; GPU1.AJ40 86.13,173.22 ; GPU1.AV20 67.75,165.35 v6(67.6,165.35) ; v6(59.3,190.7) GPU1.L11 59.8,190.05 v6(59.35,189.6) 59.35,189.45 GPU1.M11 59.8,188.85 v6(59.35,188.4) 59.35,188.25 GPU1.P11 ; GPU1.P24 72.25,188.25 v6(72.4,188.25) ; v6(60.15,181.2) 60.15,181.05 GPU1.AA12 ; GPU1.B17 64.75,197.8 v6(65.2,197.35) ; GPU1.C18 66.25,196.45 66.55,196.45 GPU1.D19 ; v6(67.6,171.75) 67.75,171.75 GPU1.AK20 ; v6(73.59,162.69) 73.65,162.75 73.85,162.75 GPU1.BA26 74.05,163.1 v6(73.6,163.55) 73.45,163.55 GPU1.AY25 ; GPU1.P32 79.85,188.25 v6(79.85,188.4) ; GPU1.D15 62.95,196.45 62.65,196.45 ; GPU1.F38 v6(84.5,194.5) ; v6(65.2,188.25) 65.65,187.8 GPU1.P18 ; v6(76,162.4) 75.4,163 GPU1.BA27 ; GPU1.H42 87.8,192.45 v6(87.35,192) ; 61.75,194.65 v6(61.6,194.65) ; GPU1.Y37 83.4,181.9 83.85,182.35 v6(83.85,182.4) 84.2,182.75 GPU1.W38 ; GPU1.R43 v6(89.38,186.6) ; GPU1.K27 75.85,191.45 v6(76,191.45) ; GPU1.AK6 55.35,171.75 v6(55.35,171.6) ; GPU1.AE1 v6(50.6,177) ; v6(50.77,161.8) 50.8,161.8 GPU1.BB1 ; v6(52.65,188.4) 52.65,188.25 GPU1.P3 53.55,187.35 53.55,187.05 GPU1.R4 ; GPU1.A38 v6(83.8,199.4) ; v6(57.75,188.4) 57.4,188.75 GPU1.M8 56.95,189.45 v6(56.95,189.6) 56.6,189.95 GPU1.L7 56.15,190.65 v6(56.15,190.8) 55.8,191.15 GPU1.J6 55.7,191.4 55.15,191.95 v6(55.15,192) 54.9,192.25 GPU1.H5 54.45,193.05 v6(54.45,193.2) 54,193.65 GPU1.F4 53.55,194.25 v6(53.55,194.4) 53.55,194.55 GPU1.E3 ; GPU1.BB12 61.15,162.2 v6(61.6,162.65) 61.75,162.65 ; GPU1.AN4 53.55,169.35 v6(53.55,169.2) 53.1,168.75 GPU1.AR3 52.65,168.15 v6(52.65,168) ; v6(55.35,168) 54.9,167.55 GPU1.AT5 55.33,166.98 v6(55.33,166.8) 55.33,166.68 GPU1.AV6 GPU1.AW5 v6(54.4,164.4) ; v6(62.8,191.45) 62.95,191.45 GPU1.K15 ; v6(51.76,198.37) 51.3,197.91 GPU1.B1 ; v6(66.4,191.45) 66.55,191.45 GPU1.K19 ; GPU1.AG40 v6(86.45,175.2) GPU1.AF40 86,176.04 86.13,176.17 86.13,176.82 GPU1.AE40 ; v6(85.6,198.25) 85.45,198.25 GPU1.B39 ; GPU1.R40 86.45,187.05 v6(86.45,187.2) ; GPU1.AC3 52.65,178.95 v6(52.65,178.8) ; v6(52.65,181.2) 52.65,181.05 GPU1.AA3 ; v6(55.35,181.2) 54.9,181.65 GPU1.Y5 54.45,182.25 54.45,182.4 54,182.85 GPU1.W4 53.55,183.45 v6(53.55,183.6) 53.1,184.05 GPU1.V3 ; 77.05,191.45 v6(77.2,191.45) ; 64.15,193.05 v6(64,193.05) ; GPU1.AU19 66.55,166.15 v6(66.4,166.15) 65.95,166.6 GPU1.AU18 ; GPU1.W39 85.55,182.55 v6(85.55,182.4) ; v6(65.2,189.85) 65.35,189.85 GPU1.M18 ; v6(84.65,192) 84.65,191.85 GPU1.J38 ; v6(71.2,197.35) 71.35,197.35 GPU1.B24 ; GPU1.BB8 57.55,162.2 v6(58,162.65) 58.15,162.65 GPU1.BA9 v6(59.2,163.55) 59.35,163.55 GPU1.AY11 ; GPU1.F9 58.6,194.25 v6(58,194.85) 57.75,195.1 GPU1.E8 56.95,195.55 v6(56.8,195.55) ; GPU1.F30 78.25,194.65 v6(78.4,194.65) ; GPU1.B8 57.55,197.8 v6(58,197.35) ; v6(54.4,161.75) 54.55,161.75 GPU1.BB5 ; GPU1.W1 v6(50.6,183) ; GPU1.AW8 56.93,164.42 v6(56.83,164.42) ; GPU1.R1 v6(50.6,186.6) ; GPU1.BB2 v6(51.8,161.8) ; v6(88.23,195.66) 88.23,195.43 GPU1.E42 ; GPU1.BC11 v6(59.8,160.58) ; v6(73.6,193.85) 73.95,194.2 GPU1.F26 ; v6(83.85,170.4) 83.85,170.55 GPU1.AM37 ; v6(73.6,196.45) 73.45,196.45 GPU1.D25 72.55,195.55 72.25,195.55 GPU1.E24 71.65,195.1 v6(71.2,194.65) ; GPU1.F35 81.85,194.65 v6(82,194.65) ; GPU1.R34 81.45,187.05 v6(81.45,187.2) ; GPU1.V12 60.17,184.63 v6(60.17,184.84) ; GPU1.AJ1 v6(50.6,173.4) ; v6(78.25,182.4) 78.25,182.25 GPU1.Y30 ; GPU1.A42 88.15,199.15 v6(88.3,199.15) ; GPU1.AM40 v6(86.45,171.6) ; GPU1.F43 v6(89.4,193.8) ; v6(84.4,196.45) 84.25,196.45 GPU1.D38 ; v6(56.95,186) 56.95,185.85 GPU1.U8 ; 74.65,189.85 v6(74.8,189.85) ; v6(66.4,163.55) 65.95,163.1 GPU1.BA18 ; GPU1.F18 66.05,194.2 v6(66.4,193.85) ; v6(56.95,175.2) 56.95,175.35 GPU1.AF8 ; GPU1.B42 v6(88.2,198.2) ; v6(85.55,195.55) GPU1.E39 ; GPU1.BC15 v6(63.4,160.62) ; v6(59.8,199.4) GPU1.A11
  TOP w0.406: CPU1.AG30 162.78,153 162.72,153.06 162.23,153.06 162.17,153 CPU1.AH30 CPU1.AH29 ; PQ11.4 126.19,215.42 v1(126.6,215.83) ; v6(153.48,153.57) 153.48,153.48 CPU1.AU30 v6(152.5,153.5) ; CPU1.AU27 CPU1.AU26 153.15,156.85 153.85,156.85 CPU1.AT26 CPU1.AT27 CPU1.AT28 ; CPU1.AP36 155.95,147 155.54,147.41 v6(155.54,147.49) ; CPU1.W9 v6(171.5,173.5) CPU1.V10 ; CPU1.AP30 155.71,153 155.69,152.98 155.23,152.98 155.21,153 CPU1.AR30 154.5,153.5 CPU1.AT29 v6(154.5,154.5) CPU1.AR29 ; v6(153.5,152.5) CPU1.AT31 154.5,151.5 CPU1.AR32 155.45,150.55 v6(155.49,150.55) ; Q25.4 212.98,143.69 v1(212.72,143.94) ; CPU1.H20 182,163 v6(181.45,163.54) 181,164 CPU1.J19 ; CPU1.W11 v6(171.5,171.5) CPU1.V12 ; CPU1.D19 CPU1.E20 ; v1(129.29,213.74) 129.27,213.73 PQ11.1 ; v1(205.69,148.34) 205.69,148.06 205.77,147.98 U20.4 ; v1(206.12,155.07) 205.58,155.61 U38.2 ; CPU1.AR27 CPU1.AR26 ; U3.3 v1(110.79,77.84)
  TOP w0.457: PC276.2 105.11,143.97 105.11,142.68 PC507.2 ; v1(114.43,161.29) 114.34,161.38 R559.1
  TOP w0.5: GPU1.P17 GPU1.R17 ; GPU1.P24 GPU1.R23 v6(70.5,186.5) GPU1.R22 v6(69.5,186.5) GPU1.R21 v6(68.5,186.5)
  TOP w0.508: v1(138.05,165.26) 138.24,165.46 R2687.2 ; C997.2 146.81,39.88 147.14,40.2 v1(147.14,40.71) ; PR57.2 98.48,25.93 98.27,25.73 97.66,25.73 v1(97.64,25.76) 97.64,26.38 PR61.2 ; R53.1 133.16,172.28 132.78,172.66 R2693.1 132.56,172.87 v1(131.9,173.53) 131.57,173.2 C2532.2 ; R2617.2 197.1,48.26 v1(196.47,48.9) ; C2528.2 140.14,157.85 v1(140.21,157.91) ; RPWRC1.17 161.5,8.81 v1(161.04,9.27) 160.98,9.27 160.5,8.79 RPWRC1.19 ; PC357.2 72.28,118.7 72.87,118.11 v1(73.3,118.11) ; C640.2 101.11,151.23 v1(100.66,151.23) ; TYPEC1.41 115.15,3.52 115.82,2.84 115.82,1.86 ; C461.2 207.94,143.9 v1(208.58,143.26) 208.29,142.96 R392.2 ; PR115.2 214.55,209.73 215.11,210.29 v1(215.37,210.29) ; PR24.1 186.87,25.32 v1(186.84,25.3) 186.49,25.3 186.38,25.19 Q16.S ; v1(211.02,145.75) 210.85,145.57 Q23.E ; R247.2 v1(180.22,22.18) ; PC169.2 212.67,206.27 212.75,206.35 212.75,207.54 213.44,208.23 v1(213.61,208.23) ; R476.2 108.69,205.6 C592.2 110.17,205.58 PC380.2 110.66,206.36 110.21,206.81 v1(109.6,206.81) ; v6(164.72,164.85) 164.72,165.13 165.28,165.68 PC26.2 ; R144.1 140.63,158.01 140.61,157.99 140.28,157.99 v1(140.21,157.91) ; Q67.G 98.83,52.03 v1(99.18,52.03) ; 125.89,168.16 127.32,166.74 Q53.S 128.21,165.51 C947.2 ; 125.89,168.16 v1(125.88,168.17) ; 125.89,168.16 C637.2 ; R517.1 118.75,158.37 118.32,158.8 117.29,158.8 v1(117.12,158.62) 117.11,158.64 C630.2 ; v1(141.63,168.61) 142.53,168.61 C17.1 ; SUSBC1.8 226.59,27.5 v1(226.34,27.25) ; R145.1 174.94,32.32 v1(174.88,32.26) ; v1(136.96,175.92) 137.26,175.61 X2.2 ; v1(8.51,202.69) 8.59,202.62 PC245.1 ; v1(126.11,201.9) 125.67,201.46 C970.2 ; v6(164.85,162.71) 165.18,162.38 165.68,162.38 PC25.2 ; 122.81,139.32 122.73,139.39 PC281.2 122.73,141.07 122.71,141.1 PR418.2 ; PC461.2 93.98,160.21 v1(93.98,160.78) ; PC461.2 PC460.2 ; PC461.2 94.75,159.05 R2534.2 ; PR330.2 v1(7.45,207.23) ; R123.1 169.42,59.44 v1(169.93,59.94) 170.56,59.31 R151.1 ; PC195.2 229.15,142.2 v1(229.32,142.02) PC194.2 ; X3.4 v1(171.89,27.49) ; v1(123.7,215.01) 123.89,214.82 PC272.2 ; PC234.2 140.46,112.5 v1(140.46,111.43) 140.46,110.67 140.26,110.46 PC243.2 ; R523.2 R522.2 95.52,205.13 R507.1 ; v1(100.69,154.94) 101.14,154.48 C641.2 ; v1(128.93,124.99) 129.74,124.99 130.05,124.69 PR389.2 ; v1(95.33,55.4) 95.61,55.12 C283.2 ; R134.2 138.8,144.09 138.13,144.09 v1(138.05,144.02) ; v1(104.14,147.15) 103.93,147.15 103.35,146.58 103.35,145.01 104.39,143.97 PC276.2 105.33,143.97 105.87,143.43 PC409.2 ; CPU1.AJ29 v6(161.5,154.5) ; v1(112.65,71.86) 112.34,72.16 U2505.4 ; v1(197.87,36.32) 197.71,36.17 C2525.2 ; v1(221.11,212.52) 221.15,212.56 PR100.2 221.07,213.41 PC143.2 ; v1(141.45,124.51) PR360.2 141.26,125.27 PU37.1 ; v1(99.1,165.27) PU55.1 ; RPWRC1.9 v1(165.5,9.75) ; PC127.2 224.49,218.97 225.07,219.56 225.07,220.08 ; PR27.2 191.49,32.4 v1(191.67,32.59) 191.82,32.73 PR29.2 ; v1(109.12,160.15) 108.95,160.31 PC456.2 ; v1(97.71,204.88) 98.06,205.22 C952.2 ; v1(229.11,146.33) 228.71,146.33 228.3,145.91 PR171.2 ; v6(172.69,53.87) 172.99,54.17 173.57,54.17 173.95,53.78 C208.2 ; v1(99.57,26.67) 99.57,26.16 99.5,26.1 PC504.2 ; RPWRC1.4 168.5,3.43 170.26,5.18 ; C355.1 211.3,11.05 v1(210.97,10.72) ; v1(225.07,220.22) 225.07,220.08 ; 225.07,220.08 PR95.2 ; PC254.2 v1(15.75,198.35) ; R56.2 129.98,169.56 v1(129.84,169.42) ; v1(93.98,160.78) 93.4,161.36 R2750.2 ; v1(93.98,160.78) 94.49,161.29 94.49,161.97 PR377.2 ; C639.2 100.84,147.83 v1(101.19,147.47) ; C639.2 101.24,148.85 C2526.2 ; C639.2 C638.2 99.36,148.22 C2515.2 ; UC2.2 96.49,36.94 v1(96.49,36.5) ; v1(127.56,61.01) 127.56,60.68 127.2,60.33 PC486.2 ; R610.2 94.11,205.1 94.78,205.1 R507.1 ; v6(164.8,160.58) 165.4,161.19 PC24.2 ; PC196.2 v1(222.38,143.13) ; R515.1 110.3,162.75 109.32,163.73 v1(109.14,163.73) 108.99,163.73 108.09,164.63 PC457.2 107.43,165.23 107.04,165.63 R534.1 ; PC418.2 134.8,209.52 v1(134.42,209.52) ; v1(126.24,210.31) PR217.2 125.41,209.49 125.73,209.17 PU38.2 ; v1(140.21,157.91) 140.13,157.99 C2527.2 ; C1144.2 180.66,17.27 180.47,17.08 v1(180.47,16.76) ; PR195.2 139.2,108.33 137.77,108.33 v1(137.67,108.43) ; C210.2 v1(169.35,31.81) ; SDRDC1.6 227.83,16.9 v1(227.51,17.22) ; v1(126.57,151.54) 126.53,151.57 PC286.2 124.55,151.57 124.55,151.59 PR413.2 ; R2588.2 184.67,32.32 185.12,32.77 v1(185.12,32.85) U40.S ; PR325.2 119.72,208.14 v1(120.5,208.91) ; R387.2 95.81,60.48 v1(95.83,60.45) 96.09,60.45 96.82,59.72 C1010.2 ; v1(141.38,178.77) 141.38,177.96 C23.2 141.26,177.96 X2.4 ; SDRDC1.10 227.87,20.1 v1(227.48,19.71) 227.89,19.3 SDRDC1.9 ; Q42.E 102.14,220.17 v1(101.47,219.51) 101.68,219.3 R487.1 ; R260.1 v1(19.18,175.9) ; v1(123.19,194.94) 122.96,195.17 122.96,195.92 C971.2 ; v1(108.51,73.77) C2510.2 ; R354.1 100.94,45.38 v1(100.99,45.33) ; R152.1 161.54,60.83 v1(161.32,61.06) ; C345.1 222.25,74.17 v1(222.12,74.04) ; PR28.1 186.3,29.71 C1117.2 186.56,30.1 187.07,30.61 187.59,30.61 187.63,30.57 v1(187.72,30.57) 187.83,30.46 PR25.2 ; R507.1 94.81,205.24 94.03,206.02 v1(94.01,206.02) ; PC430.2 148.96,217.34 PR384.2 146.94,218.22 v1(146.43,218.22) ; SSDC1.76 96.15,99.48 v1(97.31,98.32) ; v1(203.2,211.48) 203.63,211.05 R1223.2 ; v1(158.49,61.08) 158.56,61 158.56,60.46 R147.1 R149.1 ; R2685.2 138.1,166.5 v1(138.05,166.55) ; 105.28,41.15 105.28,40.77 104.29,39.78 C425.2 ; 105.28,41.15 105.71,40.72 106.55,40.72 v1(106.78,40.94) 107.06,40.94 107.39,41.28 C1005.2 107.78,41.26 C280.2 ; 105.28,41.15 PC67.1 ; PR192.2 151.85,15.7 151.6,15.45 151.6,14.93 PC431.2 152.78,14.85 v1(153.16,15.24) ; v1(220.24,27.91) 220.24,28.49 C349.2 ; R562.2 96.39,148.72 v1(96.77,148.34) ; v1(131.04,80.44) 129.59,78.99 R458.1 ; v1(114.83,77.75) 115.16,77.42 C2511.2 ; C372.2 205.33,20.14 v1(205.03,20.45) ; C337.1 194.82,41.66 195.61,40.87 195.61,40.82 v1(195.61,40.82) ; RPWRC1.16 162.5,4.41 v1(163.27,5.18) 163.5,4.95 RPWRC1.14 ; v1(128.02,205.74) 128.21,205.55 C451.2 129.03,206.38 C450.2 ; Q83.S 126.7,130.46 126.85,130.3 127.16,130.3 C2514.2 127.2,129.13 128.04,128.3 v1(128.85,128.3) 129.06,128.3 129.16,128.19 PC262.2 ; v1(140.49,107.29) 139.66,107.29 PC484.2 PR349.2 ; R16.2 209.27,152.08 v1(209.27,152.81) ; HDT1.3 v1(225.02,147.17) ; v1(15.88,210.54) 15.13,210.54 PC384.2 ; v1(187.4,27.33) 187.43,27.36 187.91,27.36 187.91,27.35 PR26.1 ; RPWRC1.31 169.5,2.28 RPWRC1.2 ; v1(133.6,206.12) 133.6,206.1 133.65,206.04 133.65,205.88 PC426.2 ; C727.2 122.19,217.82 v1(122.56,218.19) ; BT1.2 156.09,17.69 v1(155.3,16.89) ; v1(218.02,137) 218.22,136.8 C463.2 ; PR58.2 PR62.2 95.68,33.25 95.66,33.27 v1(95.63,33.27) ; PC177.2 221.18,200.38 221.74,199.82 v1(221.87,199.82) ; R2743.2 197.35,179.86 196.77,180.44 v1(196.77,180.47) ; v1(142.16,175.16) 142.09,175.08 C22.2 ; RPWRC1.5 167.5,9.72 v1(167.49,9.73) ; R531.1 102.87,212.6 103.65,213.38 v1(103.65,214.06) 103.75,214.16 Q43.E ; PC458.2 107.49,155.28 v1(107.49,155.09) ; C414.2 195.17,33.02 195.76,33.02 C413.2 196.06,33.02 v1(196.9,33.02) 196.98,32.94 196.98,32.17 PR31.2 ; v1(137.54,214.3) 137.54,214.38 137.79,214.63 137.79,215.33 PC365.2 ; GPU1.AW27 GPU1.AW29 ; v6(172.97,55.88) 173.04,55.82 R132.1 ; SUSBC1.16 229.43,31.5 230.43,30.5 ; R490.2 104.19,218.86 v1(104.19,219.68) ; C418.2 199.97,31.2 201.13,31.2 v1(201.8,31.88) 201.46,31.88 200.87,32.47 C350.2 ; RPWRC1.15 162.5,8.7 v1(163.19,9.4) 163.5,9.09 RPWRC1.13 ; C462.2 216.73,136.27 217.32,136.27 v1(217.35,136.31) ; v1(228.47,152.36) 228.47,152.57 R723.1 ; v1(224.79,156.06) HDT1.17 ; C493.2 184.06,10.78 v1(183.74,11.1) 183.57,10.92 178.14,10.92 177.58,10.36 C427.2 ; v1(211,13.69) 211.07,13.77 R312.1 ; D9.1 96.13,67.43 v1(95.5,66.8) 96.03,66.27 Q22.E ; v1(114.59,120.26) 113.79,121.06 R2577.2 ; HDT1.5 224.64,148.44 224.66,148.46 v1(224.92,148.46) ; v1(191.08,37.69) 191.34,37.44 C1116.2 ; C494.2 187.11,8.34 187.47,7.98 187.47,7.08 v1(187.43,7.04) 187,6.61 TOUCH1.2 ; R324.1 202.29,25.78 v1(202.2,25.7) ; PR12.1 205.11,27.68 v1(204.83,27.97) 204.83,28.07 205.48,28.72 PR14.1 ; R142.1 v1(152.53,63.37) ; v1(110.97,88.48) 110.55,88.06 C507.2 ; R724.1 v1(229.08,153.19) ; PR348.2 151.88,17.04 PR190.2 151.88,18.61 v1(152.3,19.02) ; R125.1 v1(176.99,57.15) ; R536.1 v1(100.97,212.72) 100.7,212.99 C631.2 101.07,214.13 Q41.E ; v1(160.4,84.84) 160.4,86.3 R114.1 ; PC511.2 v1(13.39,206.5) ; PC186.2 218.14,138 218.57,137.57 v1(218.57,137.53) 219.06,138.03 PR165.2 ; PC503.2 100.12,36.12 v1(100.12,36.89) ; R722.1 v1(229.59,151.36) ; C410.2 188.05,22.13 C411.2 186.92,22.68 v1(186.82,22.58) ; v1(100.12,36.89) 99.32,36.89 R355.2 ; v1(100.12,36.89) 100.01,37 R356.2 ; C460.2 210.13,149.96 v1(210.67,149.96) ; v1(117.68,70.1) 117.68,69.93 117.2,69.45 C984.2 C985.2 115.9,69.34 C987.2 C986.2 ; v1(129.36,46.09) 129.37,46.07 Q37.S 128.62,45.14 128.36,45.4 R464.2 127.63,45.4 C300.2 ; v1(222.76,10.87) 222.47,10.58 R339.1 ; v1(44.76,207.09) 44.76,207.19 44.31,207.63 C737.2 44.1,207.7 44.1,207.45 43.87,207.23 R618.2 ; U13.2 177.39,3.94 C964.2 ; C2509.2 v1(108.44,77.61) ; PC193.2 228.08,141.92 228.09,141.94 v1(228.09,142.01) ; v1(136.53,227.97) 136.19,228.3 PC371.2 ; PC428.2 129.9,123.67 129.49,124.08 v1(129.06,124.08) ; Q10.G v1(98.54,74.43) ; C508.2 104.33,91.73 v1(104.62,92.02) ; v1(129.26,211.58) 129.26,211.05 PC271.2 ; R243.2 141,97.72 v1(140.41,97.13) ; v1(132.03,85.85) 132.16,85.98 132.16,86.6 C297.2 ; v1(96.11,28.35) 96.65,28.88 PC112.2 ; PR414.2 120.99,149.12 121.45,148.66 122.17,148.66 122.34,148.49 PR415.2 122.4,148.54 124.9,148.54 125.16,148.29 PC285.2 126,148.29 126.2,148.08 126.57,148.08 v1(126.62,148.03) 126.67,148.08 127,148.08 127.5,148.58 R2689.2 ; U45.4 v1(129.85,65.66) ; SDRDC1.2 227.93,13.7 227.51,14.12 v1(227.51,14.48) 227.53,14.5 SDRDC1.3 ; C991.2 133.4,14.78 v1(132.97,14.35) 132.97,13.97 133.92,13.02 C931.2 ; PC138.2 209.49,210.91 v1(209.83,210.57) ; v1(229.44,149.03) C464.2 ; PC92.2 21.46,113.27 v1(20.88,113.84) ; C344.2 208.25,33.78 209.04,32.99 209.04,32.99 v1(209.37,32.66) 209.48,32.56 PR15.2 208.34,31.62 PR11.2 ; PR417.2 123.14,145.01 122.44,145.72 PR416.2 ; C1145.2 186.41,19.3 v1(185.98,19.74) 185.45,19.2 R2660.2 ; v1(197.96,58.8) 198.39,58.38 R412.2 ; HDT1.7 v1(224.82,149.71) ; SUSBC1.14 230.1,30.5 ; X3.2 v1(174.59,31.08) ; C209.2 v1(169.23,28.89) ; PC179.2 v1(218.29,141.1) ; R2692.1 213.55,38.48 213.36,38.29 213.36,37.82 v1(213.51,37.67) ; PR220.2 103.34,87.06 v1(103.48,86.92) ; v1(141.54,171.46) C18.1 ; PC222.2 v1(148.76,23.03)
  TOP w0.635: 15.13,117.5 DCPWR1.1 ; DCPWR1.1 16.31,116.32 ; DCPWR1.1 17.49,117.5 ; DCPWR1.4 16.31,127.68 ; DCPWR1.4 15.13,126.5 ; DCPWR1.4 17.49,126.5 ; PT33.2 85.66,143.97 ; PT33.2 83.55,143.97 ; PT33.2 84.61,145.02 ; 18.13,126.5 DCPWR1.8 ; DCPWR1.8 20.49,126.5 ; DCPWR1.8 19.31,127.68 ; 109.87,18.4 H16.1 106.5,21.77 ; 75.55,143.94 PT38.2 76.61,145 ; 79.93,17.5 SATAP1.4 81,16.43 ; DCPWR1.5 20.49,117.5 ; DCPWR1.5 18.13,117.5 ; DCPWR1.5 19.31,116.32 ; PC268.2 121.67,201.85 v1(120.47,203.05)
  TOP w1.016: C301.2 12.28,179.53 FANC1.1
  L3 w0.635: 10.82,179.81 FANC1.1 ; FANC1.1 13.18,179.81 ; FANC1.1 12,180.99 ; FANC1.1 12,178.63
  L6 w0.635: 82,94.96 HDD1.7 ; HDD1.7 82,96.66 ; HDD1.7 82.85,95.81 ; HS1.1 218.19,51 ; HS1.1 216.25,52.94 ; HS1.1 216.25,49.06 ; HS1.1 214.31,51 ; HDD1.1 82.85,88.19 ; HDD1.1 82,87.34 ; HDD1.1 82,89.04 ; HDD1.4 82,92.85 ; HDD1.4 82,91.15 ; HDD1.4 82.85,92 ; 82,86.99 HDD1.8 83.28,85.71
  BOTTOM w0.089: v6(66,217.7) 66.4,218.1 67.2,218.1 v6(67.6,217.7)
  BOTTOM w0.127: v1(148.01,215.29) 148.16,215.13 PU32.4
  BOTTOM w0.254: PU47.18 v6(115.21,206.2) ; C682.2 77.84,177.05 78.38,177.05 78.73,176.7 78.73,176.68 79.08,176.34 79.56,176.34 79.62,176.4 v6(79.85,176.4)
  BOTTOM w0.305: v6(75.63,217.02) 75.82,217.2 75.9,217.2 ; C1121.2 110.34,52.46 111.39,52.46 v1(111.94,51.92) ; C845.2 32.8,174.1 33.04,174.34 33.04,174.39 v6(33.05,174.4) ; v6(73.2,225.72) 73.2,225.73 C779.2 ; v6(96.5,189.2) 95.2,187.9 C903.2 ; v6(98.9,188.4) 99.2,188.1 C891.2 ; PU32.19 152.01,211.9 v1(151.84,211.73) ; C602.2 75.19,171.45 75.57,171.07 R475.2 ; v6(157.51,172.5) 156.82,171.81 156.82,171.68 C49.2 156.62,171.49 R85.1 ; U2506.4 111.32,76.02 111.66,76.35 v1(112.83,76.35) ; 66.8,225.7 66.8,225.71 v6(66.8,225.73) 66.85,225.68 66.85,225.65 67.66,224.84 C830.2 ; v6(97.3,188.4) 97.2,188.3 C894.2 ; v1(137.52,150.24) 137.31,150.04 137.28,150.04 137.14,149.9 C21.2 ; 64.3,216.8 64.41,216.91 v6(64.41,216.92) ; 75.68,215.22 75.6,215.3 v6(75.6,215.33)
  BOTTOM w0.356: U2.5 111.72,51.68 111.94,51.9 v1(111.94,51.92) ; PU52.4 145.44,215.95 145.01,216.38 v1(144.81,216.38) ; v1(215.58,141.65) 215.55,141.62 Q81.1 ; v1(212.85,139.32) 212.42,139.75 Q81.4
  BOTTOM w0.381: C795.2 47.37,223.43 v6(47.5,223.3) ; C804.2 22.6,192.95 v6(22.92,192.63) ; v6(68.5,186.5) 68.71,186.71 R615.2 ; C810.2 35,204.4 v6(34.7,204.1) ; C853.2 24.25,183.25 v6(24.3,183.2) ; v6(26.7,202.49) 26.69,202.49 25.98,201.78 C823.1 ; C813.2 24.25,201.75 v6(24.3,201.7) ; C608.2 83.49,174.36 v6(83.85,174) ; C764.2 92.5,224.1 v6(92.5,224.1) ; C762.2 87.45,225.45 v6(86.9,224.9) 86.6,224.6 C759.2 ; R680.2 107.19,188.5 107.19,188.36 v6(107.35,188.2) 107.7,188.55 C893.2 ; C781.2 63.85,215.57 v6(64.35,216.07) ; C840.2 24.3,176.8 v6(24.3,176.8) ; C866.2 37,167.68 36.52,167.2 36.4,167.2 v6(36.3,167.1) ; C787.2 54.7,225.7 v6(54.7,225.7) 53.81,224.81 C798.2 ; v6(23.5,200.1) 23.4,200.2 C812.2 ; v6(105.65,188.26) 104.85,187.45 C821.1 R689.2 ; C848.2 22.9,185.67 v6(23.04,185.8) ; C882.2 50.1,151.4 v6(50.4,151.1) ; C735.2 78.79,189.46 v6(78.4,189.85) ; C609.2 82.19,177.22 v6(82.19,177.7) ; v6(33.1,193.7) 33.1,193.7 C807.2 ; v6(28.25,196.93) 28.27,196.95 28.27,197.59 28.7,198.02 R682.2 ; C774.2 73.27,224.97 v6(73.2,224.9) ; v6(26.7,184) 26.7,184 C852.2 25.1,184 v6(25.1,184) ; C750.2 94,223.39 v6(94.24,223.63) 94.41,223.46 C831.2 ; v6(64.5,173.5) 64.63,173.37 C718.2 64.86,172.46 C700.2 ; v6(61.74,144.35) 62.48,145.09 C818.2 R667.2 ; C776.2 v6(74,223.3) ; C724.2 60.63,179.61 60.65,179.61 60.79,179.47 60.97,179.47 61.03,179.41 61.25,179.41 61.29,179.37 62.44,179.37 C738.2 63.06,179.06 v6(63.48,179.47) ; v6(57.21,144.21) 57.11,144.11 C889.2 v6(58.4,143.1) ; v6(83.03,171.55) 83.01,171.57 C617.2 ; v6(75.96,171.85) 75.86,171.75 75.23,171.75 75.2,171.73 C602.2 75.22,171.76 C684.2 ; C879.2 50.31,140.9 v6(50.19,141.02) ; R708.2 24.56,174.28 v6(24.65,174.19) 25.03,173.81 C844.2 ; C797.2 48.26,225.74 v6(48.3,225.7) ; C709.2 75.55,189.1 v6(74.8,189.85) ; C770.2 70.67,225.34 70.01,226 v6(69.75,226) 69.64,226.11 C782.2 ; C842.2 26.73,176.03 v6(26.7,176) ; v6(68.42,221.68) 68.42,221.68 R640.2 ; v6(97.26,199.62) 97.4,199.76 C892.2 ; v1(117.91,151.59) 118.31,151.59 118.34,151.61 120.24,151.61 120.47,151.84 PC293.2 ; C881.2 53.8,145.68 v6(54.42,146.3) ; v6(71.77,160.45) 71.77,160.67 72.11,161.01 72.19,161.09 72.19,161.12 72.39,161.32 R720.2 ; C1115.2 107.1,199.64 v6(107.26,199.8) 107.24,199.82 107.24,200.48 C906.2 ; v6(58.42,141.5) 58.4,141.5 57.97,141.07 C875.2 56.79,140.37 C832.2 ; C751.2 94.15,215.34 v6(94.1,215.29) ; v6(45.7,223.44) 45.44,223.7 C742.2 R648.2 43.92,222.54 R637.2 ; C1112.2 26.6,182.03 27.15,181.48 v6(27.15,181.43) ; C801.2 24.6,192.72 v6(24.66,192.66) ; C695.2 74.87,185.97 v6(74.42,185.52) ; v6(25.1,200.1) 25.37,200.37 25.37,200.48 C809.2 ; C888.2 62.1,154.8 v6(60.8,153.5) ; v6(64.41,219.3) 64.39,219.3 64.38,219.29 R642.2 ; v6(94.26,227.05) 93.91,227.4 C753.2 ; C854.2 23.7,181.8 v6(23.45,181.55) ; v6(65.2,223.3) 65.2,223.3 C778.2 ; C717.2 64.28,187.33 v6(65.2,188.25) 65.85,187.6 C736.2 ; C767.2 75.61,223.52 v6(75.74,223.65) ; R614.2 78.55,187.6 78.77,187.82 79.27,187.82 v6(79.85,188.4) ; v6(53.9,226.5) 53.4,227 C799.2 ; R692.2 28.32,203.32 v6(28.3,203.3) ; v6(26.7,165.5) 26.47,165.74 C859.2 ; v6(105.3,198.8) 105.3,198.8 C905.2 103.7,198.8 v6(103.7,198.8) ; v6(33.08,185.61) 33.2,185.74 C850.2 ; C855.2 23.89,180.11 v6(24,180) ; C790.2 49.7,226.7 v6(49.9,226.5) ; C696.2 61.06,173.57 v6(61.82,172.81) ; v6(36.3,174.4) 36.84,173.86 C847.2 ; C676.2 71.86,172.68 72.17,173 72.73,173 73.35,172.37 C601.2 73.25,172.19 72.94,172.19 72.74,171.99 v6(72.4,171.65) ; v6(26.33,155.74) 26.54,155.96 C869.2 ; C902.2 98.6,199.9 v6(98.9,199.6) ; v6(27.5,200.08) 27.32,200.26 R685.2 ; v6(51.2,144.7) 51.2,144.7 C884.2 51.2,146.3 v6(51.2,146.3) ; C877.2 50.34,142.9 v6(50.22,142.78) ; C611.2 80.61,172.04 v6(79.85,172.8) ; R612.2 62.43,187.36 62.43,186.38 R538.1 61.99,186.29 v6(61.68,185.98) ; v6(59.2,142.3) 59.2,142.3 C876.2 ; v6(33.06,167.13) 33.02,167.17 33.02,167.93 C870.2 ; C849.2 27.5,184.8 v6(28.3,184.8) ; v6(24.3,195.3) 24.3,195.3 C1111.2 ; v6(27.26,197.06) 27.59,196.73 C805.2 ; v6(94.13,216.98) 94.47,216.64 C752.2 ; C898.2 107.31,196.14 107.7,196.52 ; v6(34.71,192.89) 35.04,192.56 C806.2 ; C803.2 25.9,194.5 v6(25.9,194.5) ; C883.2 51.1,152.6 v6(51.2,152.7) ; v6(106.9,198) 106.9,198 C904.2 105.34,198 v6(105.33,197.99) ; v6(75.78,227.05) 76.03,227.3 C769.2 ; C708.2 60.66,171.09 v6(60.15,171.6) ; v6(61.8,174.02) 62.53,174.02 C725.2 62.63,174.4 63.27,175.04 63.29,175.04 R624.2 ; v6(23.5,196.1) 23,196.6 C816.2 ; v6(49.9,224.9) 49.6,224.6 C794.2 ; C880.2 52,144.7 v6(52,144.7) ; v6(57.13,215.26) 57.15,215.24 57.16,215.24 57.34,215.06 57.37,215.06 57.62,214.8 C789.2 ; C885.2 v6(60,144.7) ; R634.2 28.27,160.35 28.27,159.12 v6(28.29,159.1) ; C900.2 103.78,195.59 v6(103.78,195.48) 103.5,195.19 R678.2 ; v6(107.7,190.8) 108.37,190.8 C901.2 ; C616.2 83.31,169.86 v6(83.85,170.4) ; v6(51.7,160.85) 51.25,160.4 R627.2 50.03,159.42 C740.2 ; C773.2 76.14,213.16 v6(75.6,213.7) ; C1110.2 53.1,222.9 v6(52.94,222.74) ; C871.2 35,167.4 v6(34.7,167.1) ; R683.2 101.08,199.82 v6(101.3,199.6) ; R719.1 85.7,164.28 v6(85.73,164.25) ; v6(77.18,171.82) 77.13,171.82 76.49,172.46 C622.2 ; v6(59.35,188.4) 59.78,187.97 R621.2 ; C757.2 90,222.74 v6(89.94,222.74) ; R679.2 90.2,221.59 v6(90.05,221.75) ; v6(90.9,226.5) 90.4,227 89.89,227 C765.2 ; C618.2 80.15,179.67 v6(79.81,180.01) ; C719.2 79.15,173.59 79.56,174 v6(79.85,174) ; v6(27.26,160.06) 27.4,159.92 C862.2 ; C771.2 66.8,225.7 ; R664.2 60.31,142.78 C1114.2 61.65,142.78 61.78,142.65 v6(61.84,142.65) ; C872.2 23.69,161.58 22.6,160.5 22.6,159.1 v6(22.6,159.1) ; C896.2 v6(105.3,190) ; C756.2 82.32,213 82.8,213.48 82.8,213.6 v6(82.9,213.7) ; PC374.2 121.26,204.28 121.25,204.27 120.37,204.27 PC372.2 ; v6(25.1,177.6) 25,177.7 C836.2 26.11,178.89 v6(26.21,178.79) ; v6(33.06,155.86) 33.05,155.84 C865.2 ; v6(106.91,191.59) 106.9,191.6 C839.2 105.98,192.98 v6(105.79,192.79) ; v6(25.9,157.5) 25.9,157.5 C863.2 ; v6(88.3,224) 88.89,224.59 88.89,224.67 88.87,224.68 C1108.2 ; v6(26.36,192.71) 26.54,192.89 C802.2 ; v6(94.37,225.34) 94.32,225.4 C754.2 ; v6(30.7,192.9) 30.77,192.83 R686.2 ; v6(30.7,155.9) 31,155.6 R638.2 ; C755.2 82.78,217 82.8,216.98 82.87,216.98 v6(82.89,216.96) ; C788.2 55.5,224.1 v6(55.5,224.1) ; v6(33.1,204.1) 33,204.2 C811.2 ; v6(78.25,182.4) 78.18,182.4 77.61,182.97 C702.2 77.34,182.82 C687.2 ; v6(86.9,226.5) 86.7,226.7 C763.2 ; C634.2 75.47,169.48 v6(74.8,170.15) ; C786.2 45.81,227.15 v6(45.72,227.05) ; v6(59.3,190.7) 58.47,191.53 C698.2 ; R647.2 C743.2 R636.2 27.4,168.14 v6(26.56,167.3) ; v6(61.57,151.09) 61.61,151.09 61.9,150.8 C886.2 ; v6(45.9,216.9) 45.8,217 C785.2 ; v6(22.95,204.32) 22.7,204.07 C814.2 ; C701.2 63.59,171.58 v6(63.99,171.98) ; v6(82.9,215.3) 82.6,215 C760.2 ; C887.2 61.7,152.8 v6(61.6,152.7) ; C784.2 45.61,215.01 v6(45.9,215.3) ; v6(25.1,176.8) 25.1,176.8 C841.2 ; C1109.2 75.9,217.2 ; C610.2 83.08,179.97 v6(83.05,180) ; v6(24.63,155.67) 24.6,155.7 C868.2 ; v6(26.35,174.24) 27.12,173.47 R711.2 27.4,173.44 C908.1 ; C780.2 64.3,216.8 ; v6(78.25,184.8) 78.24,184.81 C703.2 ; C761.2 85.3,226.48 v6(85.3,225.7) ; v6(24.69,167.28) 24.84,167.44 24.84,167.56 25.08,167.8 C1113.2 ; C796.2 45.87,225.15 v6(45.72,225.3) ; v1(118.41,211.96) 118.41,211.77 PR321.2 ; R641.2 79.76,221.44 R646.2 79.78,222.43 C741.2 79.78,222.86 79.51,223.13 79.51,223.26 77.47,225.3 C777.2 75.86,225.3 v6(75.81,225.35) 75.6,225.56 C768.2 ; C791.2 56.91,227.4 v6(57.26,227.05) ; v6(63.5,180.5) 63.41,180.5 63,180.91 R623.2 ; C772.2 75.68,215.22 ; C846.2 34.78,174.32 v6(34.7,174.4) ; R622.2 67.64,171.79 v6(67.6,171.75) ; C822.1 R690.2 81.98,222.72 v6(82.7,223.44) 83.28,224.02 R681.2 ; v6(23.88,197.43) 24.37,197.93 C808.2 25.23,197.93 v6(26,198.7) ; v6(28.22,181.55) 28.45,181.33 R707.2 ; v6(24.3,164.7) 24.1,164.9 C858.2 ; v6(61.77,140.83) 61.66,140.83 61.61,140.78 C878.2 ; C851.2 34.52,185.78 v6(34.7,185.6) ; v6(82.72,225.3) 82.95,225.07 C758.2 ; C739.2 62.24,178.02 v1(61.8,177.57) ; v6(106.91,190.83) 106.91,190.79 106.98,190.72 C897.2 ; C874.2 52.8,142.3 v6(52.8,142.3) 53.92,143.42 R663.2 ; C792.2 57.26,225.4 v6(57.3,225.36) 57.98,224.68 C833.2 ; v6(68.6,222.74) 68.26,222.4 C775.2
  BOTTOM w0.4: C619.2 83.05,180.97 v6(83.05,180) ; v6(53.05,221.8) 52.95,221.7 52.28,221.7 R635.2 ; v6(76.5,186.5) 76.35,186.65 75.26,186.65 C723.2 ; v6(79.85,175.2) 80.16,175.51 80.16,176.09 v6(79.85,176.4) 80.16,176.71 80.16,177.29 v6(79.85,177.6) 80.16,177.91 80.16,178.49 v6(79.85,178.8) ; C716.2 72.02,187.56 72.02,187.84 72.32,188.14 72.32,188.17 v6(72.4,188.25) ; v6(78.25,184.8) 78.31,184.86 78.31,185.9 v6(78.27,185.94) ; v6(57.24,223.63) 57,223.39 C793.2 ; v6(68.8,189.85) 69.46,189.85 C726.2 ; v6(79.85,184.8) 79.25,184.2 78.66,184.2 C710.2
  BOTTOM w0.457: PR390.2 105.6,162.5 PC501.2
  BOTTOM w0.508: PC29.2 174.88,171.12 v6(175.5,170.5) 175.92,170.92 PC40.2 ; C32.2 169.64,177.36 v6(169.5,177.5) ; C136.2 161.83,165.17 v6(162.5,164.5) 163.36,163.64 C40.2 ; R55.2 142.57,175.56 v1(142.16,175.16) ; v6(150.6,40.2) 150.6,40.2 C252.2 C253.2 ; v6(159.5,171.5) 160.25,170.75 C141.2 ; C74.2 185.69,173.69 v6(186.5,174.5) ; C694.2 74.65,183.28 v6(74.42,183.51) ; C104.2 171.46,153.54 v6(171.5,153.5) ; PC3.2 164.54,170.92 165.08,170.92 v6(165.5,170.5) ; C426.2 R350.2 174.47,10.26 v1(174.32,10.11) ; PR425.2 15.37,210.64 15.47,210.54 v1(15.88,210.54) ; R33.2 200.05,167.27 v1(200.05,166.55) ; C185.2 166.66,90.19 v6(166.59,90.12) ; v6(150.25,113.34) 151.8,114.9 C160.2 ; v6(189.49,167.52) 189.84,167.17 189.84,166.68 C89.2 ; v6(199.36,113.54) 199.24,113.66 C149.2 ; C416.2 201.29,31.42 201.75,31.88 v1(201.8,31.88) 201.63,32.05 C415.2 ; C168.2 147.14,115.9 v1(147.07,115.82) ; C988.2 12.47,138 v1(12.34,138.13) ; v6(160.17,33.88) 160.17,33.13 C207.1 ; PR322.2 120.69,208.72 v1(120.5,208.91) ; PC114.1 212.76,229.7 212.12,230.35 v1(212.12,230.4) ; v1(106.1,56.82) 106.93,55.99 R2780.1 ; v6(164.93,108.39) 165.01,108.3 C152.2 ; C45.2 165.29,183.07 165.68,182.68 v1(166,182.68) 166.24,182.44 C37.2 ; v6(154.97,108.68) 154.93,108.65 C163.2 ; v6(162.5,160.5) 163.29,159.71 C35.2 ; v4(130.05,40.26) 130.43,40.64 R2707.2 ; C239.2 154.23,32.77 v6(154.23,33.71) 154.28,33.76 C240.2 ; v6(167.5,174.5) 167.2,174.8 166.57,174.8 C34.2 ; v6(154.52,177.43) 154.47,177.37 R6.2 ; v6(206.63,97.74) 206.33,97.74 205.73,98.34 C159.2 ; v6(165.5,172.5) 165.47,172.5 165.05,172.92 C43.2 ; v6(167.5,172.5) 167.18,172.18 166.73,172.18 PC4.2 ; v6(158.47,161.57) 158.47,162.33 158.71,162.57 C144.2 158.71,162.97 C135.2 ; v6(186.5,171.51) 186.54,171.48 C93.2 ; C56.2 154.84,182.14 154.28,182.7 v6(153.95,182.7) 155.14,183.9 R1215.1 ; C106.2 v6(192.55,126.76) ; v6(201.46,109.28) 201.74,109.28 202.15,108.87 202.15,107.01 202.08,106.95 ; C60.2 184.43,166.57 v6(184.5,166.5) ; R138.1 171.21,48.39 v6(170.6,49) ; C62.2 175.54,172.5 v6(175.5,172.5) ; Q8.C 112.11,55.81 v1(112.14,55.78) ; C424.2 180.11,11.15 181.36,9.91 v1(181.36,9.02) 181.18,8.84 U11.2 ; v6(197.28,112.84) 196.92,112.84 C154.2 ; v6(167.5,170.5) 167.16,170.84 166.6,170.84 PC18.2 ; C158.2 202.08,106.95 ; 202.08,106.95 C170.2 ; C860.2 25.4,163.4 v6(25.1,163.1) C872.2 ; Q44.E 101.97,219.01 v1(101.47,219.51) ; C47.2 162.61,158.55 v6(162.53,158.47) ; v1(137.79,160.5) 138.07,160.5 PC62.2 C143.2 ; R506.1 104.22,205.33 v1(103.25,206.3) ; PC308.2 58.31,119.9 v1(58.24,119.84) ; v1(210.67,149.96) 210.27,149.56 209.34,149.56 208.98,149.92 R2758.2 208.98,151.57 C2513.2 208.79,152.32 v1(209.27,152.81) ; C720.2 77.31,176.63 C682.2 ; C25.2 164.69,165.57 165.58,165.57 PC26.2 ; C25.2 164.6,164.97 v6(164.72,164.85) ; C25.2 C24.2 ; C175.2 172.82,90.17 v6(171.62,90.17) ; R169.1 159.37,35.23 158.77,35.23 v6(158.6,35.4) ; C148.2 170.71,113.98 170.82,113.87 170.82,113.28 170.4,112.86 v6(170.16,112.86) ; v1(15.7,140.46) 16.26,140.46 16.73,139.99 R2505.1 17.67,140.02 R2761.2 ; C275.2 v1(119.89,57.15) 119.89,57.82 C1017.2 ; R1210.2 79.69,165.44 v6(79.6,165.35) ; PC30.2 176.86,160.14 v6(177.5,159.5) ; C172.2 189.17,90.3 v6(189.09,90.22) ; C69.2 189.38,175.32 C75.2 189.37,174.63 v6(189.5,174.5) ; v6(156.24,39.5) 156.41,39.67 C263.2 ; v6(189.65,177) 189.34,177.3 189.32,177.3 189.29,177.33 R2680.1 189.22,177.75 C94.2 ; v1(103.96,52.1) 103.94,52.11 C278.2 103.03,52.09 R2438.2 ; C95.2 189.39,180.39 v6(189.5,180.5) ; R102.1 146.3,108.95 R103.1 v1(147.15,107.86) ; C127.2 v6(192.55,123.2) ; v1(5.71,197.1) 6.03,196.79 PC505.2 6.61,196.78 PR386.2 ; v6(187.32,94.03) 187.83,93.52 D12.2 ; C186.2 160.89,90.51 v6(161.18,90.21) ; v6(163.5,175.5) 163.45,175.45 C55.2 ; v6(170.16,109.28) 170.99,109.28 C171.2 ; PC327.2 v1(83.71,119.9) ; v6(74.4,177.5) 74.96,176.93 C693.2 75.53,177.03 PC352.2 ; C177.2 214.37,109.37 v6(214.41,109.4) ; C61.2 178.65,167.35 v6(178.5,167.5) ; v6(177.5,161.5) 177.4,161.4 PC31.2 ; v6(178.5,162.5) 178.68,162.68 C90.2 ; PC328.2 47.22,120.64 47.22,119.81 v1(47.22,119.8) ; C279.2 108.52,59.86 108.05,59.39 v1(108.05,59.31) ; C192.2 151.34,101.5 C191.2 152.49,102.07 v6(152.83,102.41) ; R509.1 106.4,203.92 107.29,203.03 107.29,201.25 C906.2 ; 210.13,34.42 C311.2 208.96,37.03 C310.2 ; v1(195.71,51.82) 195.38,51.49 D6.A ; R4.2 174.69,174.31 174.88,174.5 v6(175.5,174.5) ; R175.2 116.52,63.52 116.28,63.75 v1(116.28,63.88) 116.23,63.88 116.2,63.86 115.75,63.86 115.62,63.73 R2419.1 ; PR187.2 v1(146.43,218.22) ; R1213.1 150.69,179.58 v6(150.46,179.35) 150.08,179.73 149.2,179.73 149.14,179.79 R137.1 ; PR321.2 117.84,211.2 116.84,211.2 PC499.2 ; v6(157.12,90.16) 157.37,90.41 C157.2 ; v6(165.5,179.5) 165.74,179.26 C46.2 ; C53.2 158.33,169.74 v6(158.55,169.52) ; C1081.2 143.51,170.04 v1(143.51,171.58) ; C153.2 194.45,108.7 v6(194.43,108.72) ; C38.2 163.95,174.95 v6(163.5,174.5) ; v6(171.4,50.6) 171.58,50.42 172.49,50.42 172.75,50.67 R135.1 ; v6(159.87,108.39) 159.87,108.38 C155.2 ; v6(160.46,182.45) 160.46,182.46 R90.1 ; v1(194.25,90.04) 194.09,90.2 C183.2 ; R2702.2 79.12,172.07 v6(79.85,172.8) ; v6(151.38,93.39) 151.3,93.31 C194.2 ; C77.2 175.43,156.68 C76.2 175.5,156.58 175.5,155.54 v6(175.44,155.47) ; v6(169.5,153.5) 169.94,153.94 C108.2 ; v6(185.5,177.5) 185.5,178.48 C82.2 ; PC24.2 165.4,161.19 v6(164.8,160.58) ; R86.1 162.55,184.72 v1(162.97,185.14) ; C982.2 v1(206.38,30.61) ; C250.2 153.02,40.98 v6(153,41) ; R321.2 193.55,14.78 v1(193.27,14.5) 193.29,14.48 193.29,13.36 C388.2 ; PR391.2 7.9,207.67 v1(7.45,207.23) 7.97,206.71 PC500.2 ; v6(160.49,160.47) 160.45,160.43 PC66.2 159.32,160.34 C145.2 ; v1(148.56,119.63) 148.29,119.35 C162.2 ; C26.2 167.24,178.24 167.46,178.46 v6(167.46,178.46) ; C66.2 177.77,171.77 v6(177.5,171.5) 178.35,170.65 C72.2 ; v6(163.47,178.51) 163.26,178.73 C42.2 C54.2 163.26,181.22 C44.2 163.25,182.43 v1(163,182.68) ; PC307.2 95.21,119.76 95.07,119.62 v1(95.07,119.61) ; v1(149.43,118.82) 149.43,118.72 C161.2 ; v6(177.5,164.5) 177.33,164.67 PC28.2 ; C282.2 119.15,52.59 C281.2 119.42,52.59 119.96,52.04 119.96,51.88 v1(119.99,51.86) ; R127.1 174.31,55.08 173.51,55.88 v6(172.97,55.88) ; v6(151.5,181.5) 151.69,181.31 152.7,181.31 152.92,181.09 152.92,180.91 R57.2 ; v6(162.5,168.5) 162.58,168.58 C39.2 ; C97.2 v6(192.55,125.87) ; C632.2 100.22,213.17 100.66,212.72 v1(100.97,212.72) ; v6(188.01,102.04) 187.95,101.98 C178.2 ; v6(174.47,154.53) 174.52,154.48 174.52,153.68 C116.2 ; C65.2 190.21,171.66 v6(189.75,171.2) 189.81,171.14 189.81,170.53 C68.2 C63.2 ; PC65.2 144.75,158.25 144.78,158.23 v1(144.78,157.86) 144.67,157.75 R52.2 ; C27.2 158.43,174.44 v6(158.49,174.5) ; PR197.2 PC484.2 140.36,107.31 140.39,107.29 v1(140.49,107.29) ; C92.2 180.28,165.72 v6(180.5,165.5) 180.5,166.23 C58.2 ; v6(77.19,165.23) 76.53,165.89 C593.2 ; R1214.1 156.78,177.78 v6(157.5,178.5) ; C857.2 35.65,155.69 C864.2 35.15,155.45 v6(34.7,155.9) ; v6(151.03,96.98) 151.03,97.31 C180.2 ; PQ12.S 13.58,142.56 v1(14.36,143.34) ; R70.2 150.51,162.57 C1073.2 149.94,163.14 v6(149.94,164.08) ; v1(8.51,213.61) 8.15,213.26 PC510.2 ; v6(181.46,174.53) 181.25,174.31 C87.2 ; C1006.2 103.95,58.13 103.98,58.1 v1(104.19,58.1) ; v6(168.5,179.5) 168.53,179.53 C33.2 ; v6(171.5,173.5) 171.44,173.44 C29.2 ; C129.2 v6(192.55,124.98) ; C41.2 162.61,162.61 v6(162.5,162.5) ; C128.2 v6(192.55,124.09) ; C52.2 171.46,171.54 v6(171.5,171.5) ; v6(151.4,40.2) 151.46,40.26 C251.2 ; v6(179.52,170.55) 179.63,170.44 179.63,169.48 C71.2 ; v6(196.42,97.56) 196.62,97.56 197.19,98.12 C184.2 ; v1(95.33,50.98) 95.83,50.47 C1011.2 ; v6(154.49,172.52) 154.62,172.65 C57.2 ; C156.2 v6(209.74,113.54) ; v1(195.61,40.82) 195.27,40.47 C327.2 ; v6(173.5,155.5) 173.27,155.73 C100.2 172.85,157.01 PC57.2 ; C292.2 115.44,45.64 116.09,46.29 116.45,46.29 C291.2 116.77,46.02 v1(117.31,46.02) ; v6(173.5,173.5) 173.81,173.19 C70.2 ; PC417.2 v1(141.28,217.36) ; v1(104.19,57.08) 104.06,56.95 C1020.2 ; PC25.2 165.17,162.39 v6(164.85,162.71) ; v1(112.83,76.35) 112.84,76.34 U2506.9 ; v6(185.5,168.4) 184.98,168.93 C91.2 ; v1(120.47,203.05) 120.29,203.23 PC372.2 ; v6(157.34,98.13) 157.32,98.15 C179.2 ; C86.2 182.49,170.5 v6(182.5,170.51) ; v6(185.5,172.5) 185.64,172.64 C73.2 ; C1074.2 152.59,164.59 v6(152.5,164.5) ; v4(213.16,198.32) 213.44,198.04 PC165.2 ; R3.2 171.34,176.31 v6(171.48,176.45) ; C174.2 193.83,98.7 v6(194.21,98.32) ; C169.2 147.24,114.96 v1(147.17,114.88) ; R504.1 78.68,163.83 v6(78.4,163.55) ; v6(160.5,178.5) 159.83,178.5 159.38,178.94 C50.2 ; C182.2 202.71,93.32 203.28,93.89 v6(203.81,93.89) ; v1(150.32,173) 150.61,173.29 C51.2 ; PC232.2 147.03,17.13 v6(147.02,17.12) ; C28.2 149.54,177.08 149.78,176.83 150.56,176.83 R58.2 150.69,176.52 v1(150.22,176.05) 150.81,175.45 R5.2 R59.2 ; v1(109.14,163.73) 108.84,163.42 106.52,163.42 PR390.2 ; C181.2 158,113.48 v6(158.12,113.37) ; v6(166.58,152.5) 166.56,152.49 166.56,151.59 C101.2
  BOTTOM w0.635: SATAP1.2 82.07,22.5 ; SATAP1.2 81,23.57 ; SATAP1.2 79.93,22.5 ; SATAP1.2 81,21.43 ; 42.53,143.87 PT39.2 ; PT39.2 43.59,144.92 ; PT39.2 43.59,142.81 ; PT39.2 44.64,143.87 ; PT35.2 44.74,152.02 ; PT35.2 42.63,152.02 ; PT35.2 43.69,153.07 ; PT35.2 43.69,150.96 ; SATAP1.4 81,18.57 ; SATAP1.4 82.07,17.5 ; SATAP1.4 81,16.43 ; SATAP1.4 79.93,17.5 ; PMBUS1.1 125.79,120.1 ; PMBUS1.1 123.8,120.1 ; PMBUS1.1 124.79,119.11 ; 222,163.28 PT19.2 ; PT19.2 222,165.39 ; PT19.2 223.05,164.34 ; PT19.2 220.94,164.34 ; 106.5,21.77 H16.1 109.87,18.4 ; 214.12,163.28 PT20.2 ; PT20.2 213.07,164.34 ; PT20.2 214.12,165.39 ; PT20.2 215.18,164.34 ; 219.86,51 HS1.1 216.25,54.61
  vias: v1(1.34,132.54) v1(1.37,234.72) v1(1.4,232.03) v1(1.4,229.49) v1(1.4,226.95) v1(1.4,224.41) v1(1.4,221.87) v1(1.4,219.33) v1(1.4,216.79) v1(1.4,214.25) v1(1.4,211.71) v1(1.4,209.17) v1(1.4,206.63) v1(1.4,204.09) v1(1.4,201.55) v1(1.4,199.01) v1(1.4,196.47) v1(1.4,193.93) v1(1.4,191.39) v1(1.4,188.85) v1(1.4,186.31) v1(1.4,183.77) v1(1.4,181.23) v1(1.4,178.69) v1(1.4,176.15) v1(1.4,173.61) v1(1.4,171.07) v1(1.4,168.53) v1(1.4,163.45) v1(1.4,160.91) v1(1.4,158.37) v1(1.4,155.83) v1(1.4,153.29) v1(1.4,150.75) v1(1.4,148.21) v1(1.4,145.67) v1(1.4,143.13) v1(1.4,140.59) v1(1.4,138.05) v1(1.4,135.51) v1(1.4,130.43) v1(1.4,127.89) v1(1.4,125.35) v1(1.4,122.81) v1(1.4,120.27) v1(1.4,117.73) v1(1.4,115.19) v1(1.4,112.65) v1(3.99,141.4) v1(4.16,234.92) v1(5,169.29) v1(5,144.98) v1(7.24,203.02) v1(8.12,166.05) v1(8.18,157.23) v1(8.15,156.31) v1(9.31,104.4) v1(11.85,104.4) v1(13.31,234.94) v1(14.43,104.06) v1(15.39,149.2) v1(15.5,161.47) v1(15.6,163.59) v1(15.63,159.31) v1(15.6,155.3) v1(15.65,153.75) v1(15.62,151.36) v1(15.65,165.44) v1(15.8,146.56) v1(16.03,234.9) v1(16.97,104.06) v1(18.05,157.12) v1(18.27,154.75) v1(18.42,159.94) v1(18.47,146.02) v1(18.57,234.9) v1(19.51,104.06) v1(19.61,165.74) v1(19.58,164.57) v1(19.56,153.26) v1(19.66,166.67) v1(19.76,159.92) v1(20.75,150.72) v1(21.11,234.9) v1(21.13,145.51) v1(22.05,104.06) v1(23.65,234.9) v1(24.59,104.06) v1(25.5,130.07) v1(25.58,132.99) v1(25.55,132.05) v1(25.55,131.09) v1(25.58,129.16) v1(25.55,128.19) v1(26.19,234.9) v1(26.42,130.07) v1(26.49,133.02) v1(26.47,132.05) v1(26.47,131.09) v1(26.49,129.16) v1(26.47,128.19) v1(27.13,104.06) v1(28.07,133.48) v1(28.3,126.06) v1(28.73,234.9) v1(29.13,133.86) v1(29.24,125.98) v1(29.67,104.06) v1(30.05,125.15) v1(30.96,125.15) v1(31.27,234.9) v1(32.21,104.06) v1(33.5,147.12) v1(33.6,148.31) v1(33.81,234.9) v1(34.75,104.06) v1(37.29,104.06) v1(38.89,234.9) v1(39.83,104.06) v1(41.43,234.9) v1(42.37,104.06) v1(43.97,234.9) v1(44.25,115.54) v1(44.75,104.09) v1(45.21,119.41) v1(45.21,118.49) v1(45.21,117.58) v1(45.21,116.66) v1(45.21,115.75) v1(45.21,114.83) v1(45.49,120.95) v1(45.51,120.11) v1(46.13,119.41) v1(46.13,118.49) v1(46.13,117.58) v1(46.13,116.66) v1(46.13,115.75) v1(46.13,114.83) v1(46.23,120.52) v1(46.51,234.9) v1(47.04,117.58) v1(47.04,116.66) v1(47.04,115.75) v1(47.04,114.83) v1(47.29,104.09) v1(47.93,115.06) v1(49.05,234.9) v1(49.83,104.09) v1(51.59,234.9) v1(52.37,104.09) v1(54.13,234.9) v1(54.91,104.09) v1(56.31,119.41) v1(56.31,118.49) v1(56.31,117.58) v1(56.31,116.66) v1(56.31,115.75) v1(56.31,114.83) v1(56.67,234.9) v1(56.69,121.14) v1(56.95,120.42) v1(57.23,119.41) v1(57.23,118.49) v1(57.23,117.58) v1(57.23,116.66) v1(57.23,115.75) v1(57.23,114.83) v1(57.45,104.09) v1(58.14,118.49) v1(58.14,117.58) v1(58.14,116.66) v1(58.14,115.75) v1(58.14,114.83) v1(59.05,115.01) v1(59.21,234.9) v1(59.99,104.09) v1(61.75,234.9) v1(62.53,104.09) v1(64.29,234.9) v1(65.07,104.09) v1(65.33,141.88) v1(65.99,145.34) v1(66.42,142.49) v1(66.47,115.54) v1(66.57,147.78) v1(66.83,234.9) v1(66.88,140.28) v1(67.44,119.41) v1(67.44,118.49) v1(67.44,117.58) v1(67.44,116.66) v1(67.44,115.75) v1(67.44,114.83) v1(67.59,122.2) v1(67.61,104.09) v1(68.35,119.41) v1(68.35,118.49) v1(68.35,117.58) v1(68.35,116.66) v1(68.35,115.75) v1(68.35,114.83) v1(68.79,151.33) v1(69.09,154.03) v1(69.27,119.41) v1(69.27,118.49) v1(69.27,117.58) v1(69.27,116.66) v1(69.27,115.75) v1(69.27,114.83) v1(69.62,150.11) v1(70.15,104.09) v1(70.48,146.86) v1(71.22,141.68) v1(71.6,151.92) v1(71.91,234.9) v1(72.03,143.71) v1(72.24,149.96) v1(72.31,147.83) v1(72.69,104.09) v1(74.45,234.9) v1(75.42,150.93) v1(75.42,150.02) v1(75.42,149.1) v1(75.42,148.19) v1(75.42,147.28) v1(76.99,234.9) v1(78.84,102.23) v1(78.84,99.69) v1(78.84,97.16) v1(78.84,94.61) v1(78.84,92.08) v1(78.84,89.53) v1(78.84,87) v1(78.84,84.45) v1(78.84,81.92) v1(78.84,79.38) v1(78.84,76.83) v1(78.84,74.3) v1(78.84,72.42) v1(78.84,69.88) v1(78.84,67.34) v1(78.84,64.8) v1(78.84,62.26) v1(78.84,59.72) v1(78.84,57.18) v1(78.84,54.64) v1(78.84,52.1) v1(78.84,49.56) v1(78.84,47.02) v1(78.84,44.48) v1(78.77,41.33) v1(78.77,38.79) v1(78.77,36.25) v1(79.1,32.23) v1(79.1,29.69) v1(79.1,27.15) v1(79.1,24.61) v1(79.1,22.07) v1(79.1,19.53) v1(79.1,16.99) v1(79.1,14.45) v1(79.1,11.91) v1(79.1,9.37) v1(79.53,234.9) v1(80.87,115.52) v1(81.84,119.38) v1(81.84,118.47) v1(81.84,117.55) v1(81.84,116.64) v1(81.84,115.72) v1(81.84,114.81) v1(82.07,234.9) v1(82.3,121.28) v1(82.3,120.27) v1(82.75,119.38) v1(82.75,118.47) v1(82.75,117.55) v1(82.75,116.64) v1(82.75,115.72) v1(82.75,114.81) v1(83.67,118.47) v1(83.67,117.55) v1(83.67,116.64) v1(83.67,115.72) v1(83.67,114.81) v1(84.61,234.9) v1(85.37,151.87) v1(85.37,150.95) v1(85.37,150.04) v1(85.37,149.12) v1(85.37,148.21) v1(85.37,147.29) v1(87.15,234.9) v1(87.12,1.4) v1(88.91,1.4) v1(89.2,49.4) v1(89.69,234.9) v1(89.89,46.84) v1(90.17,11.38) v1(90.47,13.61) v1(90.86,2.84) v1(91.26,170.64) v1(91.44,180.8) v1(91.44,178.77) v1(91.44,176.73) v1(91.44,172.67) v1(91.45,1.4) v1(91.52,182.83) v1(91.49,174.73) v1(91.52,168.58) v1(91.97,115.52) v1(91.97,114.6) v1(92.23,234.9) v1(92.41,77.09) v1(92.43,72.8) v1(92.46,80.01) v1(92.46,75.62) v1(92.74,17.81) v1(92.74,14.96) v1(92.94,119.38) v1(92.94,118.47) v1(92.94,117.55) v1(92.94,116.64) v1(92.94,115.72) v1(92.94,114.81) v1(93.09,122.05) v1(93.7,120.6) v1(93.85,119.38) v1(93.85,118.47) v1(93.85,117.55) v1(93.85,116.64) v1(93.85,115.72) v1(93.85,114.81) v1(93.87,80.51) v1(93.87,71.11) v1(93.98,170.63) v1(93.95,73.89) v1(93.99,1.4) v1(94.11,182.8) v1(94.13,180.79) v1(94.13,178.76) v1(94.13,176.73) v1(94.13,174.7) v1(94.13,172.67) v1(94.13,168.6) v1(94.39,75.53) v1(94.47,83.1) v1(94.54,78.25) v1(94.49,69.8) v1(94.74,151.02) v1(94.74,150.1) v1(94.74,149.19) v1(94.74,148.28) v1(94.74,147.36) v1(94.77,234.9) v1(94.77,118.47) v1(94.77,117.55) v1(94.77,116.64) v1(94.77,115.72) v1(94.77,114.81) v1(94.79,11.58) v1(95.07,12.95) v1(95.89,71.86) v1(95.94,15.11) v1(95.94,11.63) v1(96.01,88.87) v1(96.53,1.4) v1(96.75,170.61) v1(96.9,182.8) v1(96.9,180.77) v1(96.9,178.74) v1(96.9,176.71) v1(96.9,174.68) v1(96.9,172.64) v1(96.9,168.58) v1(96.98,88.93) v1(97.05,14.35) v1(97.31,234.9) v1(97.26,167.39) v1(97.71,16.76) v1(98.63,170.63) v1(98.68,11.7) v1(99.07,1.4) v1(99.85,234.9) v1(99.92,168.61) v1(100,167.39) v1(100.15,172.72) v1(101.35,166.57) v1(101.57,172.58) v1(101.63,170.69) v1(101.61,1.4) v1(102.16,206.3) v1(102.18,173.89) v1(102.39,234.9) v1(102.67,168.61) v1(102.9,210.72) v1(102.97,172.64) v1(103.5,115.52) v1(103.5,114.6) v1(103.8,175.79) v1(104.09,166.57) v1(104.15,1.4) v1(104.38,170.69) v1(104.47,119.38) v1(104.47,118.47) v1(104.47,117.55) v1(104.47,116.64) v1(104.47,115.72) v1(104.47,114.81) v1(104.76,168.58) v1(104.78,122.5) v1(105.21,234.9) v1(105.41,174.12) v1(105.38,119.38) v1(105.38,118.47) v1(105.38,117.55) v1(105.38,116.64) v1(105.38,115.72) v1(105.38,114.81) v1(105.71,172.59) v1(105.84,175.92) v1(106.3,119.38) v1(106.3,118.47) v1(106.3,117.55) v1(106.3,116.64) v1(106.3,115.72) v1(106.3,114.81) v1(106.69,1.4) v1(106.89,172.55) v1(107.12,170.69) v1(107.19,85.85) v1(107.55,168.58) v1(107.75,234.9) v1(107.95,84.97) v1(108.2,32.84) v1(108.48,170.66) v1(108.66,174.55) v1(108.97,82.93) v1(109.23,1.4) v1(109.65,169.93) v1(110.29,234.9) v1(110.31,172.72) v1(110.34,168.62) v1(111.66,1.47) v1(111.92,171.23) v1(112.83,234.9) v1(113.79,88.82) v1(114.07,33.05) v1(114.34,97.95) v1(114.58,209.85) v1(114.78,208.89) v1(114.83,88.82) v1(115.14,1.07) v1(115.37,234.9) v1(115.49,210.11) v1(115.67,209.19) v1(116.41,1.19) v1(116.82,85.81) v1(117.05,98.35) v1(117.91,234.9) v1(118.03,100.97) v1(118.44,87.37) v1(118.58,86.05) v1(118.8,102.31) v1(118.88,101.4) v1(119.81,117.27) v1(120.45,234.9) v1(120.5,125.76) v1(120.5,124.82) v1(120.65,211.96) v1(120.65,210.95) v1(121.03,1.09) v1(122.99,234.9) v1(123.16,194.13) v1(123.57,1.09) v1(123.9,195.53) v1(123.93,43.64) v1(123.89,40.4) v1(123.95,88.85) v1(124.18,86.11) v1(124.38,139.14) v1(124.48,138.39) v1(124.61,83.54) v1(126.14,169.93) v1(126.11,1.09) v1(126.49,144.68) v1(127.3,82.55) v1(127.38,85.34) v1(127.58,88.16) v1(128.07,234.9) v1(128.65,1.09) v1(128.88,121.36) v1(129.44,82.73) v1(130.61,234.9) v1(131.11,195.78) v1(131.19,1.09) v1(131.85,166.9) v1(132.38,175.79) v1(132.57,177.74) v1(132.82,83.26) v1(133.15,234.9) v1(133.5,165.23) v1(133.73,1.09) v1(133.86,195.78) v1(134.34,79.88) v1(134.49,54.36) v1(134.67,177.9) v1(134.7,174.42) v1(135,195.2) v1(135,82.04) v1(135.1,131.88) v1(135.33,52.16) v1(135.69,234.9) v1(135.74,64.72) v1(136.27,1.09) v1(136.37,78.03) v1(136.58,177.93) v1(136.73,132.97) v1(136.96,80.06) v1(137.13,171.2) v1(137.54,169.29) v1(137.74,195.2) v1(138.23,234.9) v1(138.81,1.09) v1(140.21,210.57) v1(140.49,195.2) v1(140.77,234.9) v1(141.35,1.09) v1(141.6,79.15) v1(143.03,223.14) v1(143.08,225.04) v1(143.05,224.08) v1(143.31,234.9) v1(143.74,78.26) v1(143.89,1.09) v1(144.17,211.2) v1(145.85,234.9) v1(145.97,14.33) v1(146.43,1.09) v1(146.58,102.01) v1(146.63,101.09) v1(146.56,86.87) v1(146.69,13.89) v1(146.86,102.97) v1(147.14,42.77) v1(147.24,38.63) v1(147.93,173) v1(147.96,176.02) v1(148.39,234.9) v1(148.97,1.09) v1(150.93,234.9) v1(151.38,89.56) v1(152.53,1.09) v1(153.42,23.85) v1(153.47,234.9) v1(154.31,25.53) v1(155.57,5.21) v1(155.93,85.98) v1(156.01,234.9) v1(156.95,86.03) v1(156.97,84.84) v1(160.99,135.28) v1(160.99,134.37) v1(160.99,133.45) v1(160.99,132.54) v1(160.99,131.62) v1(161.09,234.9) v1(163.63,234.9) v1(165.96,185.09) v1(166.17,234.9) v1(168.71,234.9) v1(169.03,185.24) v1(170.81,84.84) v1(171.25,234.9) v1(171.58,40.77) v1(172.73,1.4) v1(172.97,84.96) v1(173.69,40.79) v1(173.79,234.9) v1(173.99,84.94) v1(174.9,84.89) v1(175.27,1.4) v1(176.33,234.9) v1(177.04,49.78) v1(177.81,1.4) v1(178.84,42.55) v1(178.77,38.27) v1(178.87,234.9) v1(178.87,39.8) v1(178.89,25.91) v1(179.04,28.75) v1(180.14,36.43) v1(180.35,1.4) v1(180.87,39.6) v1(181.08,36.86) v1(181.41,234.9) v1(183.95,234.9) v1(184.07,13.97) v1(185.43,1.4) v1(185.55,13.92) v1(185.75,138.61) v1(185.75,137.82) v1(186.08,183.39) v1(186.16,191.49) v1(186.16,187.83) v1(186.16,185.29) v1(186.49,234.9) v1(186.51,37.74) v1(186.46,36.63) v1(187.58,85.47) v1(187.71,38.07) v1(188.62,133.64) v1(188.62,132.75) v1(188.62,131.86) v1(188.59,85.34) v1(188.9,191.49) v1(188.9,187.83) v1(188.9,185.29) v1(189.03,234.9) v1(191.01,183.44) v1(191.26,69.31) v1(191.57,234.9) v1(191.64,191.49) v1(191.64,187.83) v1(191.64,185.29) v1(193.05,1.4) v1(193.19,178.94) v1(193.17,178.05) v1(193.22,68.5) v1(193.75,183.41) v1(193.83,180.54) v1(194.11,234.9) v1(194.39,191.49) v1(194.39,187.83) v1(194.39,185.29) v1(195.59,1.4) v1(195.76,176.83) v1(195.94,172.97) v1(196.29,190.53) v1(196.29,187.78) v1(196.29,185.04) v1(196.29,182.3) v1(196.65,234.9) v1(198.13,1.4) v1(199.19,234.9) v1(200.57,62.37) v1(200.67,1.4) v1(201.73,234.9) v1(203.21,1.4) v1(204.27,234.9) v1(204.75,22.81) v1(204.7,12.5) v1(204.8,24.36) v1(205.75,1.4) v1(206.22,216.18) v1(206.81,234.9) v1(208.29,1.4) v1(208.38,5.51) v1(209.35,234.9) v1(209.93,6.88) v1(210.83,1.4) v1(210.9,7.01) v1(211.89,234.9) v1(212.65,33.2) v1(213.37,1.4) v1(213.51,33.2) v1(214.27,32.99) v1(214.43,234.9) v1(215.19,32.99) v1(215.91,1.4) v1(216.97,234.9) v1(218.09,83.19) v1(218.45,1.4) v1(219.33,13.44) v1(219.38,14.43) v1(219.51,234.9) v1(219.52,17.23) v1(220.99,1.4) v1(221.74,25.4) v1(221.82,24.49) v1(222.05,234.9) v1(223.53,1.4) v1(224.59,234.9) v1(224.61,28.9) v1(224.92,21.74) v1(225.33,77.51) v1(225.73,2.82) v1(225.91,16.84) v1(225.99,14.86) v1(226.07,1.4) v1(226.49,76.33) v1(227.3,234.95) v1(229.45,69.25) v1(229.79,65.02) v1(229.84,62.26) v1(230.09,29.24) v1(230.33,26.04) v1(230.94,26.81) v1(231.01,24.31) v1(231.17,58.29) v1(231.52,21.84) v1(232.49,76.28) v1(232.67,77.51) v1(233.1,49.2) v1(233.17,71.75) v1(233.25,58.29) v1(233.38,20.62) v1(233.45,21.82) v1(234.6,74.14) v1(234.6,71.6) v1(234.6,69.06) v1(234.6,66.52) v1(234.6,63.98) v1(234.6,61.44) v1(234.6,58.9) v1(234.6,56.36) v1(234.6,53.82) v1(234.6,51.28) v1(234.6,48.74) v1(234.6,46.2) v1(234.6,43.66) v1(234.6,41.12) v1(234.6,23.34) v1(234.6,20.8) v1(234.6,18.26) v1(234.6,15.72) v1(234.6,13.18) v1(234.6,10.64) v1(234.8,234.8) v1(234.9,232.69) v1(234.92,227.46) v1(234.92,224.92) v1(234.92,222.38) v1(234.92,219.84) v1(234.92,217.3) v1(234.92,214.76) v1(234.92,212.22) v1(234.92,209.68) v1(234.92,207.14) v1(234.92,204.6) v1(234.92,202.06) v1(234.92,199.52) v1(234.92,196.98) v1(234.92,194.44) v1(234.92,191.9) v1(234.92,189.36) v1(234.92,186.82) v1(234.92,184.28) v1(234.92,181.74) v1(234.92,179.2) v1(234.92,176.66) v1(234.92,174.12) v1(234.92,171.58) v1(234.92,169.04) v1(234.92,166.5) v1(234.92,161.42) v1(234.92,158.88) v1(234.92,156.34) v1(234.92,153.8) v1(234.92,151.26) v1(234.92,148.72) v1(234.92,146.18) v1(234.92,143.64) v1(234.92,141.1) v1(234.92,138.56) v1(234.92,136.02) v1(234.92,133.48) v1(234.92,128.4) v1(234.92,125.86) v1(234.92,123.32) v1(234.92,120.78) v1(234.92,118.24) v1(234.92,115.7) v1(234.92,113.16) v1(234.92,110.62) v1(234.92,108.2) v1(234.92,105.66) v1(234.92,103.12) v1(234.87,101.37) v1(234.87,98.96) v1(234.87,96.42) v1(234.87,93.88) v1(234.91,38.4) v2(15.52,168.61) v2(19.05,190.96) v2(20.09,205.82) v2(24.87,143.33) v2(32.36,135.03) v2(36.37,144.45) v2(38.63,207.14) v2(44.2,118.82) v2(47.96,197.26) v2(50.93,203.84) v2(55.65,120.83) v2(66.32,118.75) v2(87.2,198.91) v2(94.11,113.56) v2(105.51,113.11) v2(112.42,147.9) v2(146.71,151.56) v2(165.56,7.75) v2(198.17,26.39) v2(199.06,127.15) v2(199.52,160.96) v2(200.3,222.61) v2(202.77,41.27) v2(205.05,15.88) v2(208.81,124.76) v2(209.55,22.99) v2(211.56,34.09) v2(224.94,133.25) v2(227.38,93.65) v2(230.84,165.05) v3(25.65,141.1) v3(82.3,113.67) v3(116.43,132.84) v3(119.61,212.24) v3(127.97,145.16) v3(130.3,137.74) v3(133.25,74.65) v3(133.22,44.2) v3(144.93,121.06) v3(148.92,128.45) v3(166.24,126.49) v3(180.62,128.75) v3(185.14,83.39) v3(202.03,83.49) v3(207.21,129.34) v3(210.62,135.61) v3(213.59,123.16) v3(221.74,133.17) v3(231.44,42.37) v4(6.27,183.18) v4(6.27,182.14) v4(7.29,183.16) v4(7.29,182.12) v4(13.34,216.28) v4(13.34,215.37) v4(13.34,214.45) v4(13.34,213.54) v4(14.22,224.54) v4(14.35,216.28) v4(14.35,215.37) v4(14.35,214.45) v4(14.35,213.54) v4(15.37,216.28) v4(15.37,215.37) v4(15.37,214.45) v4(15.37,213.54) v4(16.38,216.28) v4(16.38,215.37) v4(16.38,214.45) v4(16.38,213.54) v4(16.64,187.71) v4(16.69,186.61) v4(16.74,185.42) v4(16.69,184.15) v4(16.97,225.17) v4(17.02,217.42) v4(17.27,202.31) v4(17.27,200.91) v4(17.4,216.28) v4(18.03,217.42) v4(18.41,216.28) v4(28.96,223.37) v4(28.96,222.25) v4(29.84,211.71) v4(29.84,210.57) v4(29.97,223.37) v4(29.97,222.25) v4(30.99,223.39) v4(30.99,222.28) v4(31.24,210.44) v4(31.37,146.61) v4(32.51,210.44) v4(34.92,115.44) v4(35.38,223.44) v4(36.07,114.94) v4(36.45,210.95) v4(36.45,209.93) v4(36.58,223.27) v4(36.58,222.12) v4(37.59,223.27) v4(89.48,27.15) v4(89.48,26.09) v4(90.42,25.27) v4(90.42,24.21) v4(103.33,21.21) v4(103.81,23.16) v4(103.81,22.1) v4(104.88,22.12) v4(106.01,22.05) v4(106.17,26.7) v4(106.78,25.81) v4(107.31,26.67) v4(109.17,30.43) v4(109.17,29.36) v4(109.73,32.72) v4(110.13,24.61) v4(110.18,16.78) v4(110.26,30.35) v4(110.26,29.29) v4(110.26,28.22) v4(110.92,199.39) v4(110.95,198.27) v4(110.95,196.95) v4(110.87,32.77) v4(111,195.78) v4(110.97,194.56) v4(111.02,23.57) v4(111.23,27.1) v4(111.2,24.64) v4(111.28,30.3) v4(111.28,29.24) v4(111.28,28.17) v4(111.58,22.73) v4(112.01,32.77) v4(112.24,27.1) v4(112.24,23.55) v4(112.27,30.3) v4(112.27,29.24) v4(112.27,28.17) v4(112.27,24.61) v4(112.27,22) v4(113.08,32.79) v4(113.26,19.79) v4(114.25,19.38) v4(118.03,228.37) v4(118.03,227.3) v4(119.18,228.45) v4(119.2,227.38) v4(119.68,214.73) v4(119.71,213.66) v4(125.48,96.29) v4(125.48,95.22) v4(125.88,28.75) v4(126.06,30.38) v4(126.29,26.64) v4(126.54,25.2) v4(126.75,40.26) v4(126.8,29.44) v4(127.61,30.38) v4(127.56,26.34) v4(127.89,40.26) v4(128.02,25.22) v4(128.12,28.7) v4(128.65,27.15) v4(128.91,30.05) v4(129.03,122.25) v4(128.98,40.26) v4(129.11,25.86) v4(129.18,75.29) v4(129.82,28.63) v4(130.18,27.1) v4(130.35,25.63) v4(130.56,29.87) v4(130.78,200.63) v4(131.22,28.7) v4(131.32,198.12) v4(131.39,27.03) v4(131.65,12.85) v4(131.9,54.23) v4(131.9,25.7) v4(131.98,29.77) v4(132.21,103.63) v4(132.66,43.15) v4(133.07,103) v4(133.07,49.1) v4(133.73,48.31) v4(133.73,43.15) v4(134.09,102.54) v4(134.16,103.61) v4(135,29.82) v4(135.13,28.68) v4(135.05,25.7) v4(135.15,27.13) v4(135.52,17.84) v4(135.71,57.15) v4(135.71,56.08) v4(136.37,29.87) v4(136.45,28.65) v4(136.4,27.05) v4(136.42,25.81) v4(136.55,63.45) v4(136.6,17.83) v4(136.75,64.54) v4(137.62,226.75) v4(138.68,226.75) v4(139.09,227.74) v4(139.06,198.25) v4(139.75,226.75) v4(140.16,227.74) v4(140.46,121.46) v4(140.46,120.32) v4(140.46,119.18) v4(140.46,118.03) v4(140.46,116.54) v4(140.82,226.75) v4(141.3,202.31) v4(141.4,227.84) v4(141.55,17.02) v4(141.88,226.75) v4(142.01,225.65) v4(141.99,201.29) v4(142.11,32.77) v4(142.11,29.97) v4(142.11,28.83) v4(142.16,200.2) v4(142.19,43.1) v4(142.54,202.29) v4(142.57,36.91) v4(142.9,227.38) v4(142.93,226.24) v4(143,37.92) v4(143.13,211.71) v4(143.36,210.57) v4(143.41,201.45) v4(143.41,200.18) v4(143.99,227.51) v4(144.7,226.64) v4(147.37,66.22) v4(148.46,66.19) v4(149.68,66.12) v4(150.5,30.73) v4(153.57,217.68) v4(153.9,198.27) v4(154.13,219.29) v4(154.48,217.07) v4(154.53,214.93) v4(154.61,218.34) v4(154.56,216) v4(154.99,198.22) v4(155.14,227.86) v4(155.32,225.04) v4(155.32,223.98) v4(155.32,222.91) v4(155.32,221.84) v4(155.32,220.78) v4(155.32,219.71) v4(156.01,228.55) v4(156.03,201.37) v4(155.98,200.28) v4(156.39,225.04) v4(156.39,223.98) v4(156.39,222.91) v4(156.39,221.84) v4(156.39,220.78) v4(156.46,219.71) v4(162.94,219.58) v4(163.04,227.51) v4(163.02,226.39) v4(163.12,228.57) v4(163.73,220.17) v4(164.24,228.52) v4(164.24,227.46) v4(164.24,226.39) v4(164.82,222.3) v4(164.95,221.11) v4(165.3,228.52) v4(165.3,227.46) v4(165.3,226.39) v4(165.89,222.3) v4(166.01,221.11) v4(166.37,228.52) v4(166.37,227.46) v4(166.37,226.39) v4(167.28,222.45) v4(167.44,228.52) v4(167.44,227.46) v4(167.44,226.39) v4(168.35,222.45) v4(168.5,228.52) v4(168.5,227.46) v4(168.5,226.39) v4(169.62,228.6) v4(169.62,227.53) v4(169.62,226.47) v4(169.6,222.48) v4(170.69,228.6) v4(170.69,227.53) v4(170.69,226.47) v4(170.66,222.48) v4(180.34,225.7) v4(180.34,224.64) v4(180.59,222) v4(180.59,220.93) v4(180.95,226.67) v4(181.41,225.7) v4(181.41,224.64) v4(181.66,222) v4(181.66,220.93) v4(181.89,223.55) v4(182.17,226.59) v4(182.47,225.17) v4(182.73,222) v4(182.73,220.93) v4(183.06,224.1) v4(183.06,223.04) v4(183.29,226.59) v4(183.54,225.17) v4(183.79,222) v4(183.79,220.93) v4(184.12,224.1) v4(184.12,223.04) v4(184.35,226.59) v4(184.61,225.17) v4(184.86,222) v4(184.86,220.93) v4(185.19,224.1) v4(185.19,223.04) v4(185.37,225.93) v4(185.88,224.97) v4(186.41,226.44) v4(186.41,223.85) v4(186.36,222.78) v4(189.53,14.53) v4(189.51,13.46) v4(195.43,225.96) v4(195.48,224.89) v4(195.71,63.5) v4(195.71,62.23) v4(196.22,52.58) v4(196.34,219.07) v4(196.55,226.03) v4(196.55,224.94) v4(196.47,53.72) v4(196.72,220.22) v4(196.7,79.81) v4(197.64,226.01) v4(197.64,224.94) v4(198.53,79.78) v4(198.7,225.98) v4(198.7,224.92) v4(199.8,225.96) v4(199.8,224.89) v4(199.8,60.43) v4(199.77,59.31) v4(200.96,226.03) v4(200.96,224.97) v4(202.03,226.03) v4(202.03,224.97) v4(203.1,226.03) v4(203.1,224.97) v4(204.14,62.23) v4(204.17,226.03) v4(204.22,14.61) v4(204.39,63.12) v4(204.85,13.72) v4(216.41,189.87) v4(216.79,188.85) v4(216.98,93.04) v4(217.17,88.9) v4(217.5,189.92) v4(217.86,188.85) v4(217.91,187.38) v4(217.93,186.31) v4(217.93,185.17) v4(217.96,184) v4(217.96,182.93) v4(218.31,131.17) v4(218.36,130.1) v4(218.36,129.03) v4(218.57,190.12) v4(218.8,132.13) v4(218.9,188.82) v4(218.95,187.35) v4(218.95,186.28) v4(218.9,185.17) v4(218.92,184) v4(218.92,182.91) v4(219.43,131.17) v4(219.43,130.1) v4(219.43,129.03) v4(219.63,132.89) v4(220.09,96.52) v4(220.47,133.6) v4(220.55,132.26) v4(220.5,131.17) v4(220.5,130.1) v4(220.5,129.03) v4(220.78,91.49) v4(220.85,64.26) v4(220.85,62.99) v4(221.44,182.93) v4(221.54,189.99) v4(221.49,188.16) v4(221.51,186.08) v4(221.51,185.01) v4(221.51,183.95) v4(221.56,187.15) v4(222.07,196.24) v4(222.07,195.17) v4(222.07,194.11) v4(222.07,193.04) v4(222.33,189.28) v4(222.43,188.29) v4(222.48,184.43) v4(222.73,127.28) v4(222.73,126.21) v4(222.76,62.48) v4(222.88,133.43) v4(222.88,132.36) v4(222.88,131.29) v4(222.88,130.23) v4(222.86,129.08) v4(223.39,49.48) v4(223.52,94.28) v4(223.65,96.52) v4(223.72,127.79) v4(223.75,126.75) v4(223.77,92.96) v4(224.54,95.12) v4(224.54,93.6) v4(224.46,49.5) v4(225.43,94.36) v4(225.63,49.53) v4(225.81,93.34) v4(227.38,92.2) v4(227.41,84.66) v4(227.53,83.52) v4(227.53,82.12) v4(227.58,80.77) v4(228.6,96.55) v4(228.6,94.61) v4(228.73,92.2) v4(229.36,93.47) v4(229.49,95.5) v4(230.38,92.58) v4(230.76,93.73) v4(230.89,96.47) v4(230.89,95.4) v4(230.96,199.49) v4(231.01,196.75) v4(231.01,103.5) v4(231.01,102.44) v4(231.01,101.37) v4(231.01,100.3) v4(231.01,99.24) v4(231.01,98.17) v5(97.89,90.73) v5(103.84,100.23) v5(110.21,99.39) v5(112.14,199.21) v5(113.61,81.84) v5(117.58,216.1) v5(119.63,119.76) v5(120.07,123.75) v5(122.89,195.73) v5(138.89,116.99) v5(139.57,225.63) v5(147.5,128.02) v5(147.75,139.75) v5(151.56,122.83) v5(154.15,222.1) v5(154.15,134.57) v5(157.12,139.65) v5(161.8,28.96) v5(166.75,32.87) v5(167.54,81.89) v5(168.66,224.41) v5(180.87,76.1) v5(181,223.27) v5(182.47,81.71) v5(188.8,136.93) v5(190.75,80.64) v5(192.63,71.55) v5(197.64,142.21) v5(200.2,76.17) v5(202.79,149.28) v5(208.2,165) v5(218.62,62.43) v5(219.76,153.11) v5(220.22,189.08) v5(221.21,73.69) v5(223.95,202.31) v5(223.98,158.24) v5(225.63,53.62) v5(225.7,67.34) v5(226.01,82.4) v5(227.58,211.28) v5(230.56,146.91) v6(9.25,197.36) v6(9.3,211.76) v6(9.27,198.37) v6(10.39,210.64) v6(10.67,197.87) v6(12.04,198.4) v6(12.06,197.38) v6(66.54,184.5) v6(66.52,182.54) v6(66.55,181.55) v6(66.5,180.5) v6(66.5,178.5) v6(66.54,176.54) v6(66.5,174.5) v6(66.56,185.46) v6(66.56,183.51) v6(66.56,179.49) v6(66.57,177.5) v6(66.58,175.53) v6(89.92,60.83) v6(89.96,66.31) v6(90.18,69.14) v6(90.3,63.65) v6(90.27,58.01) v6(94.61,46.35) v6(94.61,43.56) v6(101.26,42.64) v6(102.03,31.32) v6(102.03,30.15) v6(103.02,41.02) v6(103.15,31.34) v6(103.17,30.18) v6(108,194.3) v6(113.78,148.74) v6(114.8,149.65) v6(114.8,148.74) v6(114.8,147.72) v6(115.82,148.74) v6(123.95,205.87) v6(125.09,207.01) v6(125.09,205.87) v6(125.09,204.72) v6(126.49,205.87) v6(130.63,203.58) v6(131.57,203.58) v6(132.51,203.58) v6(135.94,53.9) v6(137.41,221.15) v6(137.54,55.65) v6(138.13,14.45) v6(138.15,221.16) v6(138.46,52.22) v6(138.46,50.95) v6(144.78,57.4) v6(145.97,57.45) v6(147.77,149.47) v6(147.9,146.25) v6(148.03,153.62) v6(148.78,148.26) v6(148.89,183.97) v6(149.12,151.12) v6(149.52,152.81) v6(149.56,96.65) v6(149.68,157) v6(149.65,156.06) v6(149.7,147.11) v6(150.14,31.65) v6(150.23,141.48) v6(150.24,111.21) v6(150.22,109.07) v6(150.34,168.5) v6(152.61,141.28) v6(152.81,112.27) v6(152.84,110.65) v6(152.83,103.2) v6(154.15,141.99) v6(154.45,185.24) v6(154.94,103.31) v6(154.97,110.82) v6(157.22,93.87) v6(157.39,96) v6(157.8,46.6) v6(157.8,45.8) v6(157.8,44.2) v6(157.8,42.6) v6(157.9,142.67) v6(158.09,111.18) v6(158.07,108.34) v6(158.12,104.22) v6(158.09,102.34) v6(158.39,94.54) v6(158.9,129.65) v6(158.9,128.93) v6(158.9,128.22) v6(158.9,127.51) v6(158.9,126.8) v6(158.9,126.09) v6(158.9,125.38) v6(158.9,124.67) v6(159.4,46.6) v6(159.4,45.8) v6(159.4,44.2) v6(159.4,42.6) v6(159.82,110.57) v6(159.84,104.55) v6(159.84,102.67) v6(159.8,96.11) v6(159.87,112.73) v6(160.2,46.6) v6(160.2,45.8) v6(160.2,44.2) v6(160.2,42.6) v6(160.29,141.91) v6(161.57,93.98) v6(161.82,56.08) v6(161.8,51.41) v6(161.8,46.6) v6(161.8,45.8) v6(161.8,44.2) v6(161.8,42.6) v6(162.11,103.92) v6(162.11,102.93) v6(162.18,112.91) v6(162.21,111.38) v6(162.26,109.15) v6(162.59,52.98) v6(162.6,45.8) v6(162.6,44.2) v6(162.6,42.6) v6(162.6,37) v6(162.74,32.16) v6(163.4,56.26) v6(164.21,52.17) v6(164.21,32.49) v6(164.33,96.03) v6(164.35,93.88) v6(164.72,34.04) v6(164.93,110.6) v6(164.9,103.91) v6(164.9,102.97) v6(166.48,97.04) v6(167.41,45.8) v6(167.4,41.8) v6(168.2,42.6) v6(168.2,41.8) v6(168.2,41) v6(168.3,160.32) v6(168.34,94.62) v6(168.38,168.1) v6(169.04,42.6) v6(169,41.8) v6(169,41) v6(169.24,164.06) v6(169.24,163.25) v6(169.21,160.99) v6(169.21,160.07) v6(169.21,159.16) v6(169.64,94.47) v6(169.82,42.6) v6(169.77,41.81) v6(169.8,41) v6(169.88,161.5) v6(170.6,43.4) v6(170.59,42.6) v6(171.93,166.47) v6(171.93,165.76) v6(171.96,162.15) v6(172.21,46.63) v6(172.34,169.14) v6(172.37,168.34) v6(172.47,160.45) v6(173.1,51.82) v6(173.33,160.45) v6(174.85,46.61) v6(175.56,169.37) v6(177.49,102.48) v6(181.02,90.24) v6(182.67,90.24) v6(185.08,90.22) v6(186.66,90.22) v6(188.04,142.79) v6(188.01,141.52) v6(188.31,90.22) v6(189.84,142.6) v6(189.87,144.59) v6(190.14,157.51) v6(190.14,148.49) v6(190.42,163.22) v6(190.78,154.46) v6(190.76,103.99) v6(191.41,157.51) v6(191.54,158.97) v6(191.71,163.22) v6(192.23,153.05) v6(192.84,158.98) v6(194.14,103.15) v6(194.16,103.89) v6(194.23,27.15) v6(194.23,26.14) v6(194.23,25.12) v6(194.39,94.61) v6(194.56,111.17) v6(195.25,27.15) v6(195.25,26.14) v6(195.25,25.12) v6(195.25,24.1) v6(196.27,27.15) v6(196.27,26.14) v6(196.27,25.12) v6(196.99,108.6) v6(197.07,110.73) v6(197.28,27.15) v6(197.28,26.14) v6(197.28,25.12) v6(198.65,97.72) v6(199.33,111.41) v6(199.33,109.28) v6(200.38,42.37) v6(200.71,94.14) v6(201.47,112.93) v6(201.49,110.7) v6(201.6,44.09) v6(201.63,42.34) v6(201.6,40.39) v6(202.62,42.37) v6(203.8,97.73) v6(204.03,104.48) v6(204.11,112.84) v6(204.06,111.42) v6(204.09,103.31) v6(204.93,93.96) v6(206.18,109.28) v6(206.26,111.51) v6(209.27,97.65) v6(209.69,111.3) v6(209.73,104.35) v6(211.07,26.19) v6(211.07,25.17) v6(211.07,24.16) v6(211.89,97.55) v6(212.03,113.67) v6(212.12,111.48) v6(212.08,109.33) v6(212.07,104.6) v6(212.07,103.43) v6(212.09,26.19) v6(212.09,25.17) v6(212.09,24.16) v6(212.09,23.14) v6(212.67,219.61) v6(213.11,25.17) v6(213.11,24.16) v6(213.59,219.61) v6(214.12,25.17) v6(214.12,24.16) v6(214.28,113.18) v6(214.38,111.05) v6(214.5,221.44) v6(214.5,220.52) v6(214.5,219.61) v6(214.5,218.69) v6(214.5,217.78) v6(214.83,202.64) v6(215.42,219.61) v6(215.82,107.96) v6(216.33,219.61) v6(216.45,109.58) v6(216.92,113.57) v6(221.13,204.88) v6(222.38,15.75) v6(223.82,139.14) v6(223.88,140.23) v6(224.99,140.26) v6(224.97,139.14)
