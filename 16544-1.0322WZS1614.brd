# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
2D5V_EN: length 159.3
  TOP w0.114: v1(145.92,66.29) 146.8,65.42 PR209.1 ; v1(208.09,149.55) 208.47,149.17 208.82,149.17 R389.2 208.92,149.27 C460.1 ; v1(212.12,79.63) 211.33,78.84 211.33,74.68 209.42,72.77 v3(190.3,72.77) 185.8,72.77 181.64,68.61 180.56,68.61 178.28,66.33 v1(178.28,66.19)
  L3 w0.114: v1(212.12,79.63) 212.12,81.56 218.24,87.68 218.24,104.75 219.76,106.27 219.76,116.28 216.2,119.84 216.2,127.76 215.47,128.5 215.47,139.88 215.01,140.34 215.01,142.75 214.31,143.45 211.72,143.45 208.99,146.18 208.99,148.65 v1(208.09,149.55)
  L6 w0.102: v1(178.28,66.19) 178.16,66.19 176.33,68.02 168.96,68.02 168.3,67.36 164.04,67.36 151.71,67.36 149.78,65.43 146.79,65.43 v1(145.92,66.29)
2D5V_MEMVPP_S5: length 4.4
  TOP w0.279: DIMM1.257 149.38,113.76 149.33,113.72 149.33,113.67 v6(149.22,113.56) 148.87,113.91 DIMM1.259
  BOTTOM w0.254: 149.02,100.63 PG210.2 PG209.2
  vias: v2(148.44,112.85) v2(148.84,103.28) v2(148.89,109.19) v4(149.35,101.63)
2D5V_PCH_S0: length 12.1
  TOP w0.254: PG226.2 140.84,61.65 ; PG236.2 140.82,60.88 ; PG227.2 140.94,62.41
  TOP w0.305: PCH1.K16 v6(162.6,48.2) PCH1.K15 ; PCH1.N8 v6(156.2,45.8) PCH1.M8 ; PCH1.K11 v6(159.4,48.2) PCH1.K12
  TOP w0.356: PCH1.V17 v6(164.2,41) ; PCH1.V13 v6(160.2,41) PCH1.V12
  BOTTOM w0.508: v6(164.2,41) 164.53,40.67 C223.1 C224.1 R161.1 ; v6(162.6,48.2) 162.35,48.45 C245.1 ; C244.1 160.38,40.82 v6(160.2,41) ; C241.1 155.64,45.53 155.91,45.8 v6(156.2,45.8) ; C246.1 158.79,48.18 159.38,48.18 v6(159.4,48.2)
  vias: v3(147.96,59.99) v4(141.86,62.43) v4(142.93,62.43) v4(143.94,62.41) v4(148.23,55.65) v4(148.21,54.48) v4(149.53,53.92) v4(149.56,55.17) v5(144.25,64.59) v5(146.48,60.93) v5(147.19,53.52) v5(148.89,64.62) v5(149.3,59.16) v6(150.6,53.8) v6(150.6,53) v6(150.6,52.2) v6(151.4,53.8) v6(151.4,53) v6(151.4,52.2) v6(152.2,53.8) v6(152.2,53) v6(153,53) v6(153,52.2) v6(153.8,53) v6(153.8,52.2) v6(154.6,53) v6(154.6,52.2) v6(154.6,51.4) v6(165.8,45.8) v6(165.8,44.2)
2D5V_PCH_S0_PG: length 3.4
  TOP w0.114: v3(179.13,52.22) 178.72,52.64 PR400.1 177.79,52.64 177.34,52.2 R164.1
2D5V_S5: length 1.4
  TOP w0.356: PG148.2 139.7,77.09 ; PG149.2 139.57,76.33
  BOTTOM w0.254: 148.26,99.24 PG209.1 PG210.1
  vias: v2(148.95,98.65) v4(147.96,98.58) v4(149.17,88.75)
2D5V_S5_PG: length 3.1
  TOP w0.114: PR399.1 214.59,130.4 v3(215.67,130.4) 215.65,130.43 215.65,130.65 215.54,130.76 215.54,131.5 215.65,131.61 U21.2
3D3V_AUX_KBC: length 113.5
  TOP w0.508: v4(112.94,67.35) 113.7,66.59 R1222.1 114.24,66.81 114.46,66.81 114.69,67.03 115.98,67.03 116.4,66.61 R183.2 118.31,66.61 R372.1 ; R2772.1 104.44,64.92 102.29,67.08 v4(102.29,73.15)
  L4 w0.508: v1(95.4,54.23) 95.91,54.23 96.24,54.56 96.24,55.6 ; 96.24,55.6 97.33,56.69 97.33,60.51 98.17,61.34 98.5,61.34 99.39,62.23 99.39,64.97 97.54,66.83 97.54,67.86 97,68.4 97,72.11 97.41,72.52 97.41,78.36 v4(97.54,78.49) ; 96.24,55.6 96.24,56.03 95.81,56.46 95.5,56.46 v1(95.48,56.49)
  L4 w0.635: v1(120.32,54.33) 120.32,54.49 116.87,57.94 115.65,57.94 111.86,61.73 111.86,62.97 112.94,64.06 v4(112.94,67.35)
  L4 w1.016: v4(112.94,67.35) 111.12,69.17 111.12,70.23 109.09,72.26 103.5,72.26 102.62,73.15 v4(102.29,73.15)
  L6 w1.016: v4(102.29,73.15) 100.84,73.15 99.45,74.54 99.45,74.81 99.19,75.08 99.19,76.83 v4(97.54,78.49)
  BOTTOM w0.305: RN12.2 116.46,54.66 116.46,55.14 116.2,55.4 116.03,55.4 115.8,55.17 RN12.1
  BOTTOM w0.356: R2631.1 118.08,55.84 118.08,55.79 116.95,54.65 RN12.2 ; 95.4,53.59 v1(95.4,54.23) ; 95.4,53.59 95.94,53.06 96.55,53.06 RN44.3 ; 95.4,53.59 95.68,53.59 95.8,53.72 RN44.4
  BOTTOM w0.508: R2746.1 114.73,42.62 114.88,42.47 120.6,42.47 121.11,42.97 121.11,44.05 121.79,44.74 121.79,47.56 122.1,47.86 122.1,49.02 ; 121.59,50.33 121.82,50.56 121.82,52.27 120.32,53.77 v1(120.32,54.33) 120.19,54.46 120.19,54.53 119.81,54.91 119.15,54.91 118.38,55.69 R2631.1
  vias: v2(122.35,49.53)
3D3V_AUX_S5: length 539.5
  TOP w0.508: R239.2 123.72,48.64 v1(123.95,48.87) 123.95,48.74 125.04,47.65 125.26,47.65 125.29,47.62 125.35,47.62 125.7,47.27 R2751.1 ; v1(97.54,23.88) 97.84,23.57 PR63.1 ; v1(10.01,137.62) 10.36,137.62 11.46,136.52 11.46,136.36 R451.1 ; v1(83.36,29.26) 83.41,29.21 90.07,29.21 91.49,27.79 91.49,25.12 92.48,24.13 92.48,23.09 93.73,21.84 98.27,21.84 v1(98.32,21.79) ; R455.2 110.68,80.25 v1(110.97,80.54) ; D4.1 184.02,21.35 184.53,21.86 184.53,21.92 186.08,23.47 v1(186.82,23.47) ; PG36.1 v1(96.01,29.36)
  TOP w0.864: R2414.1 97.97,80.7 v4(97.54,80.26)
  L3 w0.508: v1(186.82,23.47) 186.26,23.47 186.23,23.44 185.85,23.44 185.37,23.93 185.37,28.5 186.31,29.44 186.31,35.66 v1(186.33,35.69) ; v1(10.01,137.62) 9.09,136.7 7.12,136.7 3.62,133.2 3.62,116.74 12.7,107.67 23.42,107.67 25.35,105.74 78.28,105.74 83.34,100.69 83.34,100.43 84.65,99.12 84.65,86.05 80.77,82.17 80.77,38.94 83.71,36 83.71,29.61 v1(83.36,29.26)
  L6 w0.508: v1(96.01,29.36) 96.01,29.18 95.45,28.62 95.45,25.58 96.47,24.56 96.72,24.56 97.41,23.88 v1(97.54,23.88) ; v1(123.95,48.87) 117.35,48.87 116.05,47.57 113.74,47.57 112.47,48.84 110.81,48.84 110.08,48.12 110.08,47.26 108.93,46.1 104.07,46.1 102.84,47.33 102.84,52.55 101.9,53.49 101.9,59.66 101.27,60.3 101.27,60.91 101.17,61.02 v1(101.17,61.44) ; 97.54,64.77 98.65,64.77 v1(98.7,64.72) ; v1(186.33,35.69) 185.8,36.22 185.8,41.76 187.12,43.08 187.12,57.53 189.59,59.99 189.59,63.6 192.02,66.04 192.02,67.41 186.91,72.52 186.17,72.52 185.66,72.52 185.02,73.16 181.58,76.61 169.37,76.61 169.09,76.89 168.38,76.89 167.81,76.31 161.38,76.31 160.81,75.74 132.94,75.74 132.94,75.74 132.03,75.74 125.55,82.22 125.55,89.32 124.32,90.55 119.71,90.55 114.35,85.19 111.89,85.19 110.1,86.98 104.76,86.98 100.33,82.55 99.82,82.55 v4(97.54,80.26) ; v1(204.83,33.17) 204.88,33.22 204.88,33.5 203.94,34.44 197.23,34.44 194.92,32.13 193.29,32.13 188.09,26.93 188.09,24.31 187.22,23.44 186.84,23.44 v1(186.82,23.47)
  L6 w0.635: v1(110.97,80.54) 110.92,80.49 99.82,80.49 99.29,79.96 97.84,79.96 v4(97.54,80.26)
  L6 w1.016: v1(96.01,29.36) 96.01,30.38 94.69,31.7 94.69,38.43 96.56,40.3 96.56,45.67 94.21,48.02 94.21,49.23 94.85,49.87 95.51,49.87 96.39,50.75 96.39,57.75 96.98,58.34 96.98,62.18 97.54,62.74 97.54,75.72 96.27,76.99 96.27,79.01 97.52,80.26 v4(97.54,80.26)
  BOTTOM w0.508: v1(98.32,21.79) 98.32,22.38 98.33,22.38 98.33,22.83 v5(98.32,22.83) 98.32,23.09 v1(97.54,23.88) ; R2719.1 204.19,34.21 204.88,33.53 204.88,33.22 v1(204.83,33.17) ; v1(101.17,61.44) 101.17,62 100.36,62.81 100.36,64.07 99.68,64.74 98.73,64.74 v1(98.7,64.72) ; v1(10.01,137.62) 10.16,137.77 10.21,137.77 10.64,138.2 10.64,139.88 R2667.1
3D3V_DVDD_MIC: length 11.1
  TOP w0.508: DMIC1.5 229.5,74.09 229.02,73.61 226.24,73.61 225.52,72.9 224.84,72.9 v3(224.74,73) 224.79,73.05 224.79,73.71 224.33,74.17 C345.2 223.86,73.25 R2662.2 223.76,72.35 F23.2
3D3V_DVDD_S0: length 138.2
  TOP w0.203: v1(199.06,30.15) 198.42,30.15 197.96,29.68 U8.16 ; v1(201.85,37.29) 201.48,37.66 U6.7 ; U7.16 214.8,28.69 215.04,28.93 215.04,29.87 214.76,30.15
  TOP w0.508: 214.76,30.15 PR16.1 215.55,31.17 C382.1 216.25,30.48 C381.1 v1(217.85,30.48) ; v1(217.4,36.02) 217.12,36.3 217.12,37.35 PR1.1 ; R2585.1 194.44,34.42 195.47,34.42 196.08,33.8 197.94,33.8 PR30.1 198.29,33.69 198.86,33.12 v1(198.86,32.99) ; v1(217.6,69.09) 219.58,71.07 222.35,71.07 F23.1 222.87,71.59 R2662.1 ; v1(202.87,32.66) 202.87,32.74 203.08,32.94 R282.2 203.57,34.09 R291.1
  L3 w0.508: v1(206.98,37.87) 208.29,36.56 208.29,36.54 210.01,34.82 214.48,34.82 215.68,36.02 v1(217.4,36.02)
  L6 w0.508: v1(206.98,37.87) 206.5,37.39 205.51,37.39 205.43,37.47 202.82,37.47 202.31,37.97 201.57,37.97 200.66,37.06 197.61,37.06 195.66,35.1 191.59,35.1 189.79,36.91 189.79,41.82 188.34,43.27 188.34,57.02 190.8,59.49 190.8,62.28 196.85,68.33 196.85,70.1 199.77,73.03 203.33,73.03 205.49,70.87 215.82,70.87 v1(217.6,69.09)
  BOTTOM w0.508: 202.23,33.88 202.51,33.6 202.51,33.02 v1(202.87,32.66) 203.17,32.36 205.31,32.36 207.78,34.84 R283.2 207.8,35.72 R284.2 207.8,37.06 v1(206.98,37.87) ; v1(217.85,30.48) 216.79,31.54 216.79,35.41 v1(217.4,36.02)
  vias: v2(199.48,36.86)
3D3V_M2VAUX: length 1
  TOP w0.508: R440.1 111.21,102.93 v1(110.95,102.67)
  vias: v1(116.41,93.04) v3(100.66,90.07) v3(112.88,90.91) v4(102.21,89.31) v4(102.82,90.07) v4(113.49,92.43) v4(114.5,92.46) v5(103.53,93.5) v5(112.45,101.6) v5(112.42,94.11)
3D3V_MUX_S0: length 28.4
  TOP w0.305: U26.6 121.16,98.71 121.25,98.79 121.25,99.23 121.16,99.31 v1(121.16,99.37)
  TOP w0.508: v1(110.26,85.78) 111.11,85.78 R2599.1
  BOTTOM w0.508: v1(110.26,85.78) 109.65,86.39 109.65,89.84 110.21,90.4 116.87,90.4 119.09,92.62 R2558.2 119.38,93.38 v5(119.38,95.96) 119.38,97.28 120.02,97.92 C512.1 122.14,97.96 C510.1 122.11,98.98 C511.1 121.67,99.87 v1(121.16,99.37)
3D3V_PCH_S0: length 25.3
  TOP w0.305: PCH1.G9 157.56,50.04 158.22,50.04 v1(158.24,50.01) ; PCH1.L18 v6(165,47.4)
  TOP w0.356: PCH1.Y20 v6(166.6,40.2)
  L4 w0.508: v6(166.6,40.2) 166.2,40.2 165.18,41.22 165.18,47.22 v6(165,47.4) 165,48.54 164.47,49.07 161.34,49.07 160.38,50.04 158.27,50.04 v1(158.24,50.01)
  BOTTOM w0.508: L2.1 160.02,54.86 v2(159.38,54.23) 159.38,53.55 158.8,52.97 C211.1 158.56,52.29 C212.1 158.56,50.33 v1(158.24,50.01)
3D3V_PCH_S5:
  vias: v5(157,36.75) v6(156.2,38.6) v6(156.2,37.8) v6(156.2,37) v6(156.2,36.2) v6(156.2,35.4) v6(156.2,34.6)
3D3V_S0: length 1144.9
  TOP w0.254: DIMM1.255 149.87,116.55 v6(150.29,116.97)
  TOP w0.305: RN3.4 92.78,69.95 92.48,69.65 v1(92.43,69.65) 92.43,69.7 92.13,70 RN3.3 ; v6(150.23,103.09) 150.23,101.29 149.87,100.93 DIMM2.255 ; 119.43,79.32 121.16,79.32 LPC1.4
  TOP w0.356: RN2412.2 175.77,35.52 176.57,35.52 v1(176.89,35.2) 176.52,34.84 RN2412.1
  TOP w0.406: R1230.1 205.58,152.15 U38.5
  TOP w0.508: R122.1 v1(168.28,59.94) ; R2604.2 222.61,9.53 v1(222.96,9.88) ; R113.2 171.87,85.7 171.87,85.09 171.83,85.05 v1(171.83,84.96) ; v1(201.47,182.65) 201.78,182.65 202.39,182.04 R2742.2 ; v1(126.24,193.01) 126.21,193.04 123.32,193.04 122.17,194.18 R1217.1 ; v1(207.16,7.52) 206.84,7.84 R2598.2 ; PR341.1 5.87,199.11 v1(5.59,199.39) ; v1(207.7,213.66) 208.05,213.31 208.84,213.31 208.91,213.37 209.47,213.37 209.99,213.89 210.54,213.89 210.57,213.87 PR101.1 ; v4(163.32,85.6) 162.24,84.52 R111.2 160.9,83.87 159.84,83.87 159.26,84.45 R112.2 ; RPWRC1.12 164.5,4.51 v4(165.13,5.13) 165.5,4.76 RPWRC1.10 ; v1(82.17,28.47) 82.27,28.47 82.3,28.45 v1(89.79,28.45) ; v1(177.04,53.21) R163.1 R133.1 R126.1 ; R375.1 PR78.1 216.4,226.35 215.75,225.7 215.35,225.7 215.21,225.57 214.79,225.57 214.71,225.65 214.54,225.81 214.11,225.81 v1(214.05,225.88) 213.98,225.81 213.24,225.81 211.88,224.46 210.01,224.46 209.65,224.82 R2752.1 ; v1(110.31,84.91) 110.39,84.84 113.54,84.84 114.22,84.15 115.76,84.15 R453.1 116.2,83.71 116.2,83.48 116.63,83.06 117.82,83.06 118.24,82.64 118.24,80.52 119.43,79.32 ; v4(137.62,155.91) 137.73,156.02 R121.2 ; v1(176.89,35.2) 176.89,33.05 176.26,32.42 R159.1 ; R367.1 104,41.29 103.68,41.61 103.47,41.61 v1(103.46,41.61) ; D5.K 9.84,168.21 R251.1 9.84,166.56 v1(9.65,166.37) ; v1(208.56,141.91) 208.53,141.88 R388.1 ; v1(131.84,51.05) 131.79,51.1 131.79,53.23 131.43,53.59 131.2,53.59 R456.2 130.99,53.92 130.89,54.02 130.89,56.26 130.56,56.59 129.63,56.59 128.16,58.07 128.16,58.35 127.9,58.61 PR395.1 ; R2627.1 208.91,65.99 v1(208.89,66.01) ; R36.2 151.38,62.86 151.76,63.24 151.76,64.26 ; R1227.1 208.93,158.12 208.61,158.44 v1(208.61,159.18) 210.39,159.18 211.52,158.05 R17.2 ; R2589.2 222.2,76.75 222.2,84.33 v1(222.07,84.45) ; v1(205.82,151.26) 205.87,151.31 205.87,151.87 R1230.1
  TOP w0.635: U1.G 163.47,58.99 163.47,58.06 v4(163.19,57.78)
  TOP w1.016: 160.58,65.28 164.47,69.16 164.47,81.15 163.55,82.07 163.55,85.37 v4(163.32,85.6)
  L3 w0.305: v1(90.02,41.02) 97.92,41.02 98.55,40.39 103.14,40.39 103.57,40.82 103.57,41.5 v1(103.46,41.61)
  L3 w0.508: v1(201.47,182.65) 202.77,181.36 202.77,176.61 201.9,175.74 201.9,170.68 207.39,165.19 207.39,160.4 v1(208.61,159.18) ; v1(148.97,161.16) 148.21,161.16 148.08,161.29 146.69,161.29 145.24,159.84 141.38,159.84 v1(141.25,159.72) ; v1(5.59,199.39) 4.95,199.39 3.56,197.99 3.56,186.41 5.77,184.2 10.36,184.2 15.37,179.2 15.37,170.56 11.18,166.37 v1(9.65,166.37) 9.46,166.18 9.46,164.66 8.92,164.11 8.92,153.95 9.19,153.68 9.19,143.4 2.86,137.07 2.86,116.23 4.34,114.75 14.11,104.98 77.87,104.98 80.01,102.84 80.01,30.1 81.64,28.47 v1(82.17,28.47) ; v6(171.87,104.53) 171.67,104.53 169.98,106.22 153.36,106.22 v6(150.23,103.09) ; v1(221.36,113.79) 221.36,105.71 220.45,104.8 220.45,100.63 219.35,99.54 219.35,88.9 222.07,86.18 v1(222.07,84.45)
  L4 w0.508: v1(131.84,51.05) 131.83,51.05 130.41,49.63 130.28,49.63 128.47,47.83 123.44,47.83 v1(123.39,47.88) ; v1(190.02,6.91) 189.01,6.91 188.47,6.38 186.28,6.38 183.9,8.76 182.96,8.76 177.67,14.05 v1(177.67,14.48) ; v1(176.89,35.2) 176.91,35.2 177.02,35.31 180.46,35.31 181.33,34.44 188.8,34.44 v1(189.97,33.27)
  L6 w0.508: v1(5.59,199.39) 7.24,199.39 14.22,206.38 14.22,207.01 15.24,208.03 35.94,208.03 37.47,209.55 37.47,220.8 44.71,228.05 94.35,228.05 98.93,223.47 101.73,223.47 101.8,223.55 103.94,223.55 104.42,223.06 115.7,223.06 116.64,224 116.64,224.94 116.97,225.27 116.97,228.73 117.53,229.29 136.8,229.29 137.26,228.83 144.5,228.83 145.75,227.58 145.75,224.38 142.7,221.34 142.7,220.57 141.33,219.2 138.3,219.2 137.69,218.59 137.69,216.99 136.54,215.84 134.84,215.84 132.12,213.12 129.6,213.12 128.6,212.12 128.6,211.31 128.99,210.92 129.2,210.92 130.3,209.82 130.3,204.15 130,203.84 130,203 130.68,202.31 131.95,202.31 132.84,201.42 132.84,198.12 131.83,197.1 131.32,197.1 130,195.78 130,194.77 128.24,193.01 v1(126.24,193.01) ; v1(214.05,225.88) 213.82,226.11 213.82,227.03 214.12,227.33 215.7,227.33 217.36,225.67 220.15,225.67 221.44,224.38 221.44,217.27 220.95,216.79 220.94,216.79 217.28,213.13 212.17,213.13 209.96,215.34 208.81,215.34 207.7,214.22 v1(207.7,213.66) 204.97,213.66 203.96,212.65 203.96,210.77 203.76,210.57 203.76,206.9 203.78,206.87 203.78,197.04 202.9,196.15 202.9,194.39 199.57,191.06 199.57,187.98 199.57,184.56 v1(201.47,182.65)
  BOTTOM w0.305: RN2405.1 151.14,156.83 152.12,155.85 152.65,155.85 153.63,156.83 154.48,156.83 R37.2 ; R79.2 155.69,159.66 R39.2 155,159.85 154.3,159.16 153.8,159.16 153.72,159.24 153.18,159.24 152.73,158.79 151.5,158.79 151.14,158.43 RN2405.2
  BOTTOM w0.508: v4(163.32,85.6) 163.78,86.06 170.74,86.06 v1(171.83,84.96) 172.57,84.23 208.76,84.23 ; v1(177.67,14.48) 176.96,13.77 175.85,13.77 175.78,13.84 169.28,13.84 v4(168.02,12.57) ; v1(110.31,84.91) 110.03,84.91 108.86,86.08 108.86,87.38 ; F22.2 224.89,17.47 225.17,17.75 R2774.2 226.75,17.41 226.75,13.89 223.42,10.57 223.42,10.26 223.04,9.88 v1(222.96,9.88) 222.86,9.88 222.76,9.78 222.05,9.78 220.19,7.92 207.57,7.92 v1(207.16,7.52) 206.55,6.91 v1(190.02,6.91) ; R2714.2 141.27,159.25 141.27,159.69 v1(141.25,159.72) 142.24,160.71 142.24,162.69 140.74,164.19 139.28,164.19 138.92,163.83 138.84,163.83 137.97,162.97 136.04,162.97 ; R2706.2 128.33,46.27 129.23,47.17 129.23,48.49 131.8,51.05 v1(131.84,51.05) ; R100.2 172.16,104.24 v6(171.87,104.53) ; v1(221.36,113.79) 221.34,113.82 221.34,114.1 215.75,119.68 215.75,136.3 214.63,137.41 212.22,137.41 208.56,141.07 v1(208.56,141.91) 207.52,142.95 207.52,148.08 205.82,149.78 v1(205.82,151.26) 204.93,152.15 204.93,155.5 v1(208.61,159.18) ; 108.86,87.38 108.86,90.27 109.75,91.16 116.54,91.16 117.56,92.19 R2558.1 ; 108.86,87.38 108.43,87.81 101.19,87.81 v4(99.85,86.46) ; C192.1 150.38,101.02 C191.1 150.23,102.22 v6(150.23,103.09) ; v1(123.39,47.88) 123.39,47.85 122.56,47.02 122.56,44.42 121.87,43.74 121.87,42.41 121.17,41.71 110.01,41.71 109.88,41.58 108.2,41.58 107.34,42.44 104.55,42.44 103.72,41.61 v1(103.46,41.61) ; v1(208.89,66.01) 208.76,66.14 208.76,84.23 ; 208.76,84.23 212.22,84.23 212.45,84.45 v1(222.07,84.45)
  BOTTOM w0.635: L7.2 197.78,35.33 196.1,33.66 190.37,33.66 189.99,33.27 v1(189.97,33.27) 189,33.27 188.21,32.49 188.21,32.13 186.99,30.91 186.99,29.51 185.19,27.71 185.19,23.09 182.77,20.66 182.77,18.72 181.7,17.65 179.95,17.65 178.89,16.59 178.89,15.7 v1(177.67,14.48)
  vias: v1(153.92,63.37) v1(154.81,63.37) v2(99.59,80.59) v2(133.86,162.51) v2(142.65,108.13) v2(170.56,57.91) v2(173.43,23.32) v3(130.73,149.3) v3(154.28,65.07) v4(90.25,17.78) v4(90.27,18.8) v4(95.02,65.46) v4(95,64.54) v4(98.93,86.41) v4(131.09,15.09) v4(131.72,163.98) v4(131.98,15.62) v4(135.51,16.38) v4(135.92,151.51) v4(136.42,16.38) v4(138.25,142.14) v4(140.51,106.15) v4(168.07,19.3) v5(90.7,20.32) v5(104.9,5.97) v5(142.49,139.32) v5(154.43,61.8)
3D3V_S0_CT2: length 3.4
  TOP w0.203: U33.10 136.46,14.85 136.32,14.99 135.14,14.99 C991.1
  TOP w0.508: v3(134.37,13.79) 134.94,14.36 C991.1
3D3V_S5: length 1208.6
  TOP w0.203: 138.51,17.73 PG32.2 PG17.1 PG18.2 PG24.1 PG27.2 PG211.2 PG234.2 138.51,23.14 139.04,23.67 ; 133.65,65.3 133.22,64.87 PG224.2 PG225.2 PG235.2
  TOP w0.254: PU34.15 136.49,109.05 136.78,109.35 v1(136.78,109.86) ; v4(148.79,18.8) 148.44,18.44 PU33.15 ; PG221.2 108.98,157.16 ; PG220.2 109.03,158.17
  TOP w0.305: R2495.2 9.44,139.59 8.28,138.43 8.28,138.28 7.75,137.75 OSDC1.3
  TOP w0.356: v1(102.38,45.42) 102.13,45.42 100.56,46.99 R351.2 ; PG147.2 133.76,68.81 ; PG212.2 133.71,68.05 ; RN17.2 212.64,145.15 v1(212.37,144.88) 211.99,145.26 RN17.1
  TOP w0.381: CPU1.AK19 v6(160.46,164.49) CPU1.AJ19
  TOP w0.406: C462.1 215,135.43 U21.5
  TOP w0.508: v1(136.78,109.86) 138.53,109.86 139.14,110.46 PC243.1 ; PR216.1 133.05,214.01 v1(133.05,215.26) ; R430.1 99.36,61.59 98.48,60.71 v1(98.48,60.68) ; v1(112.09,79.88) 112.66,80.45 Q36.E ; v1(13.21,139.62) 9.71,139.62 9.68,139.59 R2495.2 ; v1(137.41,104.14) 137.38,104.1 PR338.1 ; v1(87.38,54.36) 87.38,55.28 R2481.2 87.66,55.07 93.2,55.07 93.21,55.09 93.52,55.09 94.12,55.68 94.12,56.05 v1(94.28,56.21) ; 174.02,21.03 174.02,18.97 172.06,17.02 172.06,11.42 172.09,11.4 172.09,10.85 171.55,10.32 v1(171.55,10.07) ; PR212.1 129.11,127.05 v4(129.08,127.08) ; v1(142.62,66.17) 142.62,66.14 142.29,65.81 142.29,65.57 142.05,65.33 PR207.1 ; R379.1 127.95,201.99 v1(127.76,202.18) ; v1(129.39,132.69) 129.23,132.85 Q85.D ; R359.1 181.14,6.31 181.56,5.89 v1(181.56,5.36) ; v1(137.34,159.89) 136.86,159.89 136.32,159.36 135.17,159.36 133.67,157.86 130.23,157.86 129.55,157.18 R2715.1 129.45,157.05 R2688.1 128.47,157.04 128.47,156.54 127.94,156.01 R2717.1 ; v1(100.58,66.91) 99.82,67.67 R383.1 99.62,67.96 D9.2 ; v1(225.3,22.73) 224.61,23.42 R2492.2 ; v1(137.24,144.78) 137.19,144.73 137.19,143.84 137.69,143.33 140.54,143.33 141.68,144.48 R128.2 ; v4(108.89,139.27) 108.89,139.01 110.24,137.67 114.09,137.67 PR225.1 PR224.1 115.62,137.73 116.06,138.16 116.21,138.16 PR223.1 ; R2661.1 184.21,18.94 183.74,18.46 180.34,18.46 v1(180.29,18.52) ; R2747.1 v1(139.37,214) 141.35,214 143.17,215.81 PR361.1 144.37,215.1 PR333.1 ; v1(163.32,10.34) 163.5,10.16 163.51,10.16 164.5,9.17 RPWRC1.11 ; 197.69,66.17 197.64,66.12 197.64,63.97 R414.1 ; PR64.1 101.87,22.62 101.8,22.68 v1(101.7,22.68) 101.63,22.61 94.84,22.61 94.04,22.61 93.24,23.4 93.24,24.45 92.46,25.24 92.46,28.07 90.55,29.97 84.25,29.97 83.78,30.44 R2484.2 83.11,30.68 v1(82.88,30.45) ; R2580.1 13.93,143.89 13.57,143.53 12.69,143.53 12.27,143.95 12.27,144.16 v1(12.25,144.16) ; R154.1 165.24,63.31 v1(165.3,63.25) ; v1(124.36,51.46) 124.36,51.21 123.93,50.77 123.37,50.77 123.3,50.7 R2733.1 ; v1(147.69,8.12) 147.69,8.11 147.69,7.48 147.75,7.41 147.75,5.45 R2483.2 ; v1(212.37,144.88) 213.28,144.88 213.89,144.27 216.28,144.27 216.59,143.97 217.89,143.97 218.38,143.48 R399.1 218.41,143.22 219.17,143.22 219.46,142.94 PR166.1 ; v1(148.69,15.32) 148.79,15.21 148.79,13.73 PR335.1 148.81,13.63 149.67,12.76 PR363.1 ; C462.1 215.21,135.76 v1(214.55,136.42) ; L30.2 202.54,61.85 v1(203.35,62.66)
  TOP w0.559: v1(220.24,9.65) 220.24,9.73 220.88,10.36 R336.2
  TOP w0.635: v1(215.32,67.67) 215.32,64.87 217.07,63.12 L31.2
  TOP w0.762: 189.61,66.17 198.93,66.17 199.01,66.09 v1(200.51,66.09)
  L3 w0.381: v1(137.34,159.89) 138.68,159.89 140.99,162.21 143.54,162.21 145.41,164.08 147.32,164.08 149.05,165.81 v6(149.22,165.81) 149.4,165.81 149.59,165.63 151.15,165.63 151.43,165.91 159.11,165.91 160.46,164.56 v6(160.46,164.49)
  L3 w0.508: v1(203.35,62.66) 200.51,65.51 v1(200.51,66.09) ; v1(225.3,22.73) 223.71,22.73 220.58,19.61 220.57,19.61 219.94,18.97 219.94,17.93 220.45,17.42 220.45,14.78 220.9,14.33 220.9,12.54 220.45,12.08 220.45,9.86 v1(220.24,9.65) 220.24,8.81 219.02,7.58 218.26,7.58 218.26,7.58 213.24,7.58 212.7,8.12 212.7,8.12 212.64,8.18 205.9,8.18 205.85,8.23 204.67,8.23 204.64,8.19 192.69,8.19 190.82,10.06 190.82,10.07 189.99,10.9 189.99,11.77 186.31,15.44 186.31,16.43 184.23,18.52 v1(180.29,18.52) ; v1(12.25,144.16) 12.27,144.14 12.27,143.95 13.31,142.91 13.31,140.56 13.21,140.47 v1(13.21,139.62) 13.32,139.73 13.59,139.73 14.22,139.09 14.22,136.4 12.7,134.87 12.7,134.87 12.34,134.52 12.34,133.25 7.56,128.46 7.56,118.53 12.52,113.56 20.22,113.56 20.6,113.18 23.72,113.18 26.37,110.54 26.44,110.54 26.49,110.49 79.27,110.49 85.59,104.17 v1(86,104.17) ; v1(137.34,159.89) 137.34,156.77 136.63,156.06 136.63,153.66 134.9,151.93 134.9,148.11 137.24,145.78 v1(137.24,144.78) ; v1(112.22,10.59) 112.9,11.28 116.08,11.28 116.46,10.9 121.34,10.9 123.88,13.44 129.21,13.44 130.12,14.35 130.12,15.72 130.76,16.36 134.06,16.36 134.85,15.57 136.86,15.57 v4(139.98,18.69)
  L4 w0.356: v1(102.38,45.42) 102.38,45.72 101.8,46.3 101.24,46.3 98.43,49.12 98.43,49.7 98.2,49.94 98.2,54.75 98.07,54.88 98.07,55.36 98.2,55.49 98.2,60.4 v1(98.48,60.68)
  L4 w0.508: v1(167.39,11.05) 169.04,11.05 170.01,10.07 v1(171.55,10.07) 172.82,8.8 176.62,8.8 180.06,5.36 v1(181.56,5.36) ; v1(146.1,181.1) 131.24,181.1 128.78,178.64 v1(128.78,176.28) ; v1(121.03,206.02) 120.12,206.02 119.63,206.5 119.63,212.34 121.32,214.03 125.76,214.03 126.82,215.09 127.79,215.09 127.82,215.11 128.78,215.11 129.06,215.39 132.72,215.39 132.84,215.26 v1(133.05,215.26) 133.25,215.26 133.39,215.41 138.28,215.41 139.37,214.32 v1(139.37,214) ; v1(129.13,62.05) 126.36,62.05 124.23,59.92 124.23,57.38 125.58,56.03 127.3,56.03 JMP1.2 127.48,53.62 127.48,51.36 127.05,50.93 124.89,50.93 v1(124.36,51.46) ; v1(163.32,10.34) 163.22,10.44 157.41,10.44 154.84,7.87 147.93,7.87 v1(147.69,8.12) ; v1(87.38,54.36) 87.38,51.94 84.48,49.05 84.48,32.05 v1(82.88,30.45) ; v1(137,163.86) 137,163.85 136.68,163.53 136.68,160.55 v1(137.34,159.89) ; v1(212.37,144.88) 213,144.88 214.3,143.59 214.3,136.68 v1(214.55,136.42) 213.31,135.18 211.02,135.18 207.72,131.88 207.72,114.05 208.64,113.13 208.64,108.51 207.87,107.75 207.87,84.33 202.41,78.87 191.16,78.87 v4(189.76,77.47) ; v1(139.6,200.58) 139.55,200.53 133.22,200.53 131.95,199.26 130.3,199.26 128.37,201.19 128.37,201.57 v1(127.76,202.18) 127.76,202.06 126.92,201.22 126.9,201.22 126.31,200.64 126.31,200.01 126.87,199.45 126.87,199.36 126.95,199.29 126.95,190.83 130.18,187.6 130.4,187.6 v1(130.43,187.58)
  L4 w0.762: v4(222.12,69.98) 219.81,67.67 v1(215.32,67.67) 213.31,67.67 211.96,69.01 203,69.01 200.51,66.52 v1(200.51,66.09)
  L6 w0.508: v1(225.3,22.73) 223.42,24.61 223.42,26.64 213.87,36.2 v1(213.36,36.2) ; v1(139.37,214) 138.2,214 136.55,212.34 136.55,203.63 v1(139.6,200.58) ; v1(98.48,60.68) 98.48,61.34 100.58,63.45 v1(100.58,66.91) 100.58,68.81 104.78,73 106.99,73 107.48,73.5 107.48,74.92 109.74,77.18 109.74,78.06 110.69,79.02 111.76,79.02 112.09,79.35 v1(112.09,79.88) ; v1(101.7,22.68) 101.65,22.63 101.65,21.36 100.86,20.58 100.86,18.63 108.19,11.3 111.51,11.3 v1(112.22,10.59) ; v1(146.1,181.1) 146.1,180.11 149.43,176.78 150.6,176.78 151,176.38 151,175.51 151.74,174.78 151.74,167.23 150.32,165.81 v6(149.22,165.81) ; v4(110.16,122.25) 109.73,121.82 109.73,107.9 107.77,105.94 89.9,105.94 88.12,104.17 v1(86,104.17) ; v1(130.43,187.58) 130.43,187.23 130.57,187.09 130.57,185.31 128.2,182.94 128.2,177.16 128.78,176.59 v1(128.78,176.28)
  L6 w1.016: v4(189.76,77.47) 183.34,83.9 169.6,83.9 168.53,84.96 164.69,84.96 160.43,80.7 156.91,80.7 156.05,79.83 146.81,79.83 144.58,82.07 139.6,82.07 137.87,80.34 137.87,79.68 137.34,79.15 136.42,79.15 133.22,82.35 132.44,82.35 130.89,83.9 130.89,94.39 134.24,97.74 134.24,99.74 135.21,100.71 135.74,100.71 137.54,102.51 137.54,104.01 v1(137.41,104.14) 135.03,104.14 134.57,104.6 134.14,104.6 133.99,104.75 128.44,104.75 126.26,106.93 126.26,113.93 126.26,115.71 128.7,118.14 128.7,118.63 128.7,119.58 130.18,121.06 130.18,122.71 130.18,125.98 v4(129.08,127.08) ; v4(110.16,122.25) 110.5,122.25 113.13,124.88 113.13,126.79 113.16,126.81 113.16,127.23 114.43,128.5 114.43,132.23 108.86,137.79 108.86,139.14 108.89,139.17 v4(108.89,139.27) 108.89,141.04 110.82,142.97 110.82,152.1 110.67,152.25 110.67,152.82 110.44,153.05 110.44,155.04 v4(109.4,156.08)
  BOTTOM w0.203: 138.51,17.73 PG32.2 PG17.1 PG18.2 PG24.1 PG27.2 PG211.2 PG234.2 138.94,23.55
  BOTTOM w0.254: 117.97,205.3 PU47.15
  BOTTOM w0.508: R43.2 138.21,158.99 137.34,159.87 v1(137.34,159.89) ; R2632.2 147.88,180.81 147.88,179.84 R131.2 ; R2632.2 147.88,180.82 R44.2 ; R2632.2 146.87,180.82 146.58,181.1 v1(146.1,181.1) ; v1(98.48,60.68) 97.03,59.23 97.03,58.75 95.43,57.15 95.2,57.15 94.28,56.24 v1(94.28,56.21) ; 185.47,69.67 185.72,69.67 ; v1(12.25,144.16) 12.06,144.16 11.76,144.46 R2668.1 ; R347.1 172.49,10.91 171.66,10.08 171.63,10.07 v1(171.55,10.07) ; R1226.2 11.51,138.61 12.1,139.2 12.78,139.2 13.04,139.46 13.05,139.46 v1(13.21,139.62) ; v1(167.39,11.05) 167.08,11.05 166.62,10.59 165.15,10.59 164.68,10.12 R2485.2 163.54,10.12 v1(163.32,10.34) ; v1(213.36,36.2) 212.98,36.2 212.57,36.6 R269.2 ; v1(148.69,15.32) 147.92,16.09 PC232.1 148.03,18.03 v4(148.79,18.8) ; v1(158.47,28.19) 160.02,29.74 R153.1 ; v1(121.03,206.02) 121.03,205.99 121.28,205.74 PC374.1 120.99,205.17 120.9,205.08 119.58,205.08 119.3,205.36 118.03,205.36 117.97,205.3 ; v6(160.46,164.49) 160.94,164.98 C136.1 ; v1(112.22,10.59) 112.22,10.52 112.34,10.39 112.34,9.88 112.41,9.82 R2482.2 ; v1(137.24,144.78) 136.91,144.45 136.91,142.33 140.67,138.57 140.67,122.63 141.6,121.69 141.6,114.17 137.29,109.86 v1(136.78,109.86) 136.63,109.7 136.63,105.88 PR340.1 136.72,104.89 137.41,104.19 v1(137.41,104.14) ; R2684.1 R2686.1 138.53,164.6 138.53,164.6 137.79,163.86 v1(137,163.86) 137,163.86 133.88,166.98 133.85,166.98 133.27,167.56 131.11,167.56 129.41,165.86 R2782.2 ; R2491.2 220.79,10.2 v1(220.24,9.65) ; v1(139.37,214) 139.55,213.82 140.35,213.82 140.5,213.97 PR394.1 ; v4(129.08,127.08) 130.43,128.42 130.43,131.57 129.39,132.61 v1(129.39,132.69)
  BOTTOM w1.016: v4(110.16,122.25) 110.36,122.45 113.13,122.45 118.62,127.94 127.66,127.94 128.52,127.08 v4(129.08,127.08) ; v4(189.76,77.47) 189.76,76.78 188.01,75.03 188.01,71.96 185.72,69.67
  vias: v1(154.18,27.56) v2(134.09,68.02) v2(176.53,19.94) v3(110.79,157.76) v3(132.84,69.19) v3(139.98,17.55) v4(131.93,68.48) v4(131.93,67.34) v4(131.93,66.19) v4(139.98,22.5) v4(139.98,21.51) v4(139.98,20.6) v4(139.98,19.68) v4(140.06,23.67) v4(141.05,22.94) v4(141.05,21.89) v4(141.05,20.98) v4(141.05,20.07) v4(141.17,18.57) v4(150.83,25.96) v4(151.84,25.96) v4(175.77,23.01) v4(175.77,22.1) v4(187.27,64.31) v4(187.35,65.35) v5(140,17.53) v5(154.79,28.55) v5(182.75,70.23) v5(184.28,40.23)
3D3V_SD: length 2.7
  TOP w0.508: SDRDC1.7 228.02,17.7 227.41,18.31 v1(227.41,18.5) SDRDC1.8
  vias: v2(222.88,19.43)
3D3V_VDD_S0: length 44
  TOP w0.381: CPU1.AK21 160.46,161.54 v6(160.56,161.54) 160.56,161.56 CPU1.AJ21
  TOP w1.016: L1.1 134.04,147.7 v3(134.75,147.7) 135.08,147.7 v1(135.66,148.29)
  L3 w0.305: v1(135.66,148.29) 136.58,149.2 136.58,150.29 137.46,151.18 137.46,154.59 139.06,156.19 139.06,158.24 140.08,159.26 140.69,159.26 140.92,159.03 144.57,159.03 144.71,159.17 145.76,159.17 147.07,160.48 149.05,160.48 151.58,163.01 156.22,163.01 156.26,162.96 157.99,162.96 159.41,161.54 v6(160.56,161.54)
  BOTTOM w0.203: C145.1 160.99,160.19 160.99,161.11 v6(160.56,161.54)
  BOTTOM w0.508: v6(160.56,161.54) 160.14,161.95 PC66.1
3D3V_VGA: length 388.9
  TOP w0.381: GPU1.AM24 72.33,170.07 v6(72.43,170.07) ; v6(71.19,171.63) 71.42,171.4 GPU1.AL24 72.03,171.17 72.04,171.17 72.35,170.85 v6(72.4,170.85)
  TOP w0.457: R533.2 110.48,165.9 110.52,165.86 v1(110.69,165.86)
  TOP w0.508: PR392.1 9.88,205.23 11.61,205.23 12.14,205.77 v1(12.14,206.15) PR346.1 ; R527.2 114.23,188.62 113.97,188.88 113.97,189.42 R520.2 113.98,189.48 R525.2 113.98,190.75 113.55,191.19 113.23,191.19 112.95,191.47 v1(112.95,191.54) 112.95,191.95 112.98,191.97 112.98,193.85 111.89,194.94 111.89,203.15 110.3,204.74 107.43,204.74 106.92,205.25 106.92,206 v4(106.68,206.25) 106.51,206.08 R1197.1 ; R2643.1 13.88,155.9 R2642.1 14.7,155.9 15.19,156.39 v1(15.21,156.39) ; R483.2 100.55,224.92 103.49,224.92 R480.1 103.88,224.74 104.74,223.77 R491.2 104.78,223.5 104.94,223.5 105.66,222.78 105.66,220.14 v1(104.93,219.41) ; R495.1 95.44,165.8 R494.1 96.03,165.86 v1(96.53,165.35) ; v1(110.69,165.86) 110.77,165.79 R552.1 ; PR406.1 111.92,138.59 PR231.1 111.75,138.43 110.57,138.43 110.11,138.89 110.11,139.45 v1(110.03,139.52) 110.08,139.52 110.54,139.98 110.77,139.98 R2634.1
  L3 w0.508: v1(88.87,103.94) 88.87,105.54 89.79,106.45 89.79,107.19 89.38,107.59 89.33,107.59 84.2,112.73 81.15,112.73 81.01,112.87 34.4,112.87 31.17,116.1 15.47,116.1 14.3,117.27 14.3,131.7 16.74,134.14 16.74,148.44 17.14,148.84 17.14,151.08 16.51,151.71 16.51,155.75 15.88,156.39 v1(15.21,156.39) 15.21,157.33 17.27,159.38 17.27,167.61 18.49,168.83 18.49,197.61 16.19,199.91 16.19,202.63 12.98,205.84 12.45,205.84 v1(12.14,206.15)
  L4 w0.508: v1(112.95,191.54) 112.95,190.69 115.11,188.53 115.11,169.16 111.68,165.74 110.82,165.74 v1(110.69,165.86) ; v4(106.68,206.25) 107.04,205.89 109.86,205.89 111.79,207.82 116.05,207.82 117.02,208.79 117.02,211.81 v1(116.08,212.75)
  L6 w0.508: v4(106.68,206.25) 106.55,206.38 106.55,207.34 104.93,208.97 v1(104.93,219.41) ; v1(109.26,161.39) 107.8,161.39 106.05,159.64 106.05,158.5 107.44,157.1 110.01,157.1 111.61,155.5 111.61,153.22 111.89,152.94 111.89,141.33 110.08,139.52 v1(110.03,139.52) 110.03,138.25 116,132.28 116,128.22 114.15,126.36 114.15,124.46 111.7,122.01 111.7,108.72 108.15,105.18 91.06,105.18 89.81,103.94 v1(88.87,103.94)
  BOTTOM w0.406: PR324.1 115.6,212.27 v1(116.08,212.75)
  BOTTOM w0.508: 102.72,207.34 104.34,207.34 105.28,206.4 R505.1 106.35,205.15 R510.2 106.4,205.97 v4(106.68,206.25) ; v1(97.54,162.94) 97.39,162.94 R2635.1
  vias: v2(70.64,159.49) v2(71.25,170.69) v2(83.44,155.8) v2(88.27,155.7) v4(90.88,156.44) v4(91.14,155.35)
+TSVDD: length 2.7
  TOP w0.508: GPU1.AR26 74.23,168.2 74.42,168 74.48,168 74.55,167.94 74.61,167.94 74.78,167.77 v6(74.83,167.77)
  BOTTOM w0.508: C634.1 75.58,167.57 L27.2 75.53,167.51 75.08,167.51 v6(74.83,167.77)
AC_OK#: length 6.1
  TOP w0.114: Q78.G 122.34,46.08 122.78,46.08 123.7,46.99 R2751.2 124.81,45.92 C1160.1 124.86,45.1 124.82,45.06 v3(124.82,44.88)
AD+_2: length 23.8
  TOP w0.254: v1(26.8,115.06) 26.05,115.81 R382.1 26.77,116.89 U18.4
  L6 w0.254: v1(23.34,126.19) 23.88,126.19 26.8,123.27 v1(26.8,115.06)
  BOTTOM w0.254: v1(23.34,126.19) 23.98,126.82 v2(24.59,126.82) 25.11,126.3 R380.2 25.11,125.49 25.45,125.15 25.45,125.13 C459.2 26.57,124.01 U19.4
AD_JK: length 54.4
  TOP w0.635: DCPWR1.7 20.49,123.5 ; DCPWR1.7 18.13,123.5 ; DCPWR1.7 19.31,122.32 ; DCPWR1.7 19.31,124.68 ; 15.13,120.5 DCPWR1.2 ; DCPWR1.2 17.49,120.5 ; DCPWR1.2 16.31,119.32 ; DCPWR1.2 16.31,121.68 ; DCPWR1.3 17.49,123.5 ; DCPWR1.3 16.31,122.32 ; DCPWR1.3 15.13,123.5 ; DCPWR1.3 16.31,124.68 ; DCPWR1.6 20.49,120.5 ; DCPWR1.6 18.13,120.5 ; DCPWR1.6 19.31,121.68 ; DCPWR1.6 19.31,119.32
  L3 w0.635: DCPWR1.3 17.49,123.5 ; DCPWR1.3 16.31,122.32 ; DCPWR1.3 16.31,124.68 ; DCPWR1.6 20.49,120.5 ; DCPWR1.6 18.13,120.5 ; DCPWR1.6 19.31,119.32 ; DCPWR1.6 19.31,121.68 ; DCPWR1.7 20.49,123.5 ; DCPWR1.7 19.31,124.68 ; DCPWR1.7 19.31,122.32 ; DCPWR1.7 18.13,123.5 ; DCPWR1.2 16.31,121.68 ; DCPWR1.2 16.31,119.32 ; DCPWR1.2 17.49,120.5
  BOTTOM w0.635: 15.13,120.5 DCPWR1.2 ; DCPWR1.2 16.31,121.68 ; DCPWR1.2 17.49,120.5 ; DCPWR1.2 16.31,119.32 ; 18.13,120.5 DCPWR1.6 ; DCPWR1.6 20.49,120.5 ; DCPWR1.6 19.31,121.68 ; DCPWR1.6 19.31,119.32 ; DCPWR1.3 17.49,123.5 ; DCPWR1.3 16.31,124.68 ; DCPWR1.3 16.31,122.32 ; DCPWR1.3 15.13,123.5 ; 18.13,123.5 DCPWR1.7 ; DCPWR1.7 20.49,123.5 ; DCPWR1.7 19.31,122.32 ; DCPWR1.7 19.31,124.68
  vias: v2(22.73,118.11) v2(22.86,123.7) v4(23.88,122.81) v4(23.88,121.56) v4(23.88,120.4) v4(23.88,119.25) v4(23.93,118.11) v4(25.02,122.81) v4(25.02,121.56) v4(25.02,120.4) v4(25.02,119.25) v4(25.07,118.14)
ADAPTOR_PSID: length 28.6
  TOP w0.114: v1(116.1,59.6) 116.1,59.69 115.65,60.15 KBC1.99 ; v1(101.27,63.88) 101.7,64.31 101.7,66.83 99.89,68.64 R383.2 R384.2 99.62,69.86 D9.3
  L3 w0.114: v1(101.27,63.88) 101.54,63.88 102.95,62.47 111.34,62.47 112.98,60.83 114.87,60.83 v1(116.1,59.6)
  BOTTOM w0.114: v1(101.27,63.88) v5(101.27,62.97)
ADAPTOR_PSID_R: length 9.5
  TOP w0.114: Q21.S 93.76,67.73 v3(93.98,67.94) 96.9,70.87 98.3,70.87 98.62,70.55 R384.1
ADBIA0: length 31
  TOP w0.13: GPU1.P36 82.6,187.95 v6(83.05,188.4) ; v6(102.1,197.2) VRAMA1.J4
  BOTTOM w0.089: 86.35,189.11 86.04,188.8 83.45,188.8 v6(83.05,188.4)
  BOTTOM w0.13: 86.35,189.11 87.8,190.56 87.8,192.88 93.47,198.55 93.52,198.55 93.98,199.01 94.47,199.01 95.6,200.14 95.6,200.35 96.26,201.01 100.14,201.01 100.38,200.78 100.38,199.62 100.95,199.05 101.5,199.05 101.63,198.92 101.63,198.54 101.5,198.4 101.19,198.4 101.06,198.27 101.06,197.86 101.2,197.73 101.58,197.73 v6(102.1,197.2)
ADBIA1: length 37
  TOP w0.13: GPU1.J36 83.05,191.85 v6(83.05,192) ; v6(91.7,220.1) 91.7,220.1 VRAMA2.J4
  BOTTOM w0.13: v6(91.7,220.1) 91.7,220.1 93.59,218.21 94.51,218.21 94.54,218.24 95.17,218.24 95.32,218.08 95.32,212.41 94.21,211.3 94.21,211.21 90.03,207.04 90.03,205 83.68,198.65 83.68,192.84 83.05,192.22 v6(83.05,192)
ADBIB0: length 36.4
  TOP w0.13: GPU1.L21 68.95,190.65 v6(68.8,190.65) ; VRAMB1.J4 66.81,220.14 v6(66.79,220.14)
  BOTTOM w0.089: v6(68.8,190.65) 68.64,190.65 68.21,191.08 68.21,195.98 68.12,196.06 68.12,196.23
  BOTTOM w0.122: v6(66.79,220.14) 66.78,220.12 66.78,219.87 66.38,219.47 66.38,219.16 66.14,218.92 65.03,218.92 64.93,218.82 64.82,218.82 64.48,218.48
  BOTTOM w0.13: 68.12,196.23 68.17,196.28 68.17,203.67 64.88,206.96 64.88,212.18 63.96,213.1 63.96,213.11 63.95,213.11 62.96,214.1 62.96,218.12 63.32,218.48 64.48,218.48
ADBIB1: length 39.5
  TOP w0.13: VRAMB2.J4 54.65,220.15 54.67,220.15 54.68,220.14 v6(54.7,220.14) ; v6(66.4,190.65) 66.55,190.65 GPU1.L19
  BOTTOM w0.089: 66.07,198 66.07,195.78 66,195.72 66,195.38 66.07,195.32 66.07,194.88 66,194.82 66,194.48 66.07,194.42 66.07,194.08 66,194.02 66,193.68 66.07,193.62 66.07,193.28 66,193.22 66,192.88 66.07,192.82 66.07,192.48 66,192.42 66,191 66.35,190.65 v6(66.4,190.65)
  BOTTOM w0.13: 66.07,198 66,198.07 66,201.58 60.95,206.63 60.95,210.03 59.92,211.06 59.92,211.1 58.8,212.22 58.8,212.98 58.65,213.13 57.63,213.13 57.51,213.26 57.51,213.69 57.63,213.82 58.52,213.82 58.8,214.1 58.8,218.22 58.5,218.52 56.28,218.52 54.7,220.1 v6(54.7,220.14)
ADBIC0: length 40.3
  TOP w0.13: v6(29.9,195.3) VRAMC1.J4 ; GPU1.W11 59.35,183.45 v6(59.35,183.6)
  BOTTOM w0.089: v6(59.35,183.6) 58.95,184 52,184
  BOTTOM w0.13: v6(29.9,195.3) 30.89,194.31 30.89,193.65 31.48,193.06 31.48,191.5 31.78,191.2 35.92,191.2 36.04,191.33 36.04,192.3 36.17,192.43 36.58,192.43 36.7,192.3 36.7,191.33 36.83,191.2 37.24,191.2 37.36,191.33 37.36,191.82 37.49,191.95 37.92,191.95 38.05,191.82 38.05,191.3 38.15,191.2 38.16,191.2 39.07,190.3 40.31,189.05 43.37,189.05 48.42,184 52,184
ADBIC1: length 36.3
  TOP w0.13: v6(59.35,181.2) 59.35,181.05 GPU1.AA11 ; v6(29.9,183.2) VRAMC2.J4
  BOTTOM w0.089: 54.46,181.94 54.97,181.94 55.12,181.8 58.75,181.8 v6(59.35,181.2)
  BOTTOM w0.13: 54.46,181.94 46.22,181.94 43.04,185.12 37.82,185.12 35.74,187.2 31.8,187.2 31.5,186.9 31.5,186.2 31.6,186.09 31.6,184.9 v6(29.9,183.2)
ADBID0: length 37.1
  TOP w0.13: v6(57.98,167.15) 58.35,167.15 GPU1.AT9 ; v6(29.9,158.3) VRAMD1.J4
  BOTTOM w0.13: v6(57.98,167.15) 57.7,167.15 56.9,166.34 51.52,166.34 50.7,165.52 50.12,165.52 44.57,159.97 42.96,159.97 38.2,155.21 37.84,155.21 37.23,154.61 31.79,154.61 31.58,154.82 31.58,155.92 30.35,157.15 30.35,157.85 v6(29.9,158.3)
ADBID1: length 29.8
  TOP w0.13: GPU1.AT14 61.75,166.95 v6(61.6,166.95) ; VRAMD2.J4 v6(52.8,147.9)
  BOTTOM w0.089: v6(61.6,166.95) 61.2,166.55 61.2,165.1
  BOTTOM w0.13: v6(52.8,147.9) 51.08,149.62 49.33,149.62 49.05,149.9 49.05,153.85 49.33,154.13 50.5,154.13 50.73,154.35 50.73,155.63 51.33,156.23 51.33,156.31 53.6,158.58 53.6,158.59 57.21,162.2 58.18,162.2 59.09,163.12 59.72,163.12 61.09,164.49 61.09,164.49 61.2,164.6 61.2,165.1
AGPIO5_DEVSLP0: length 2.3
  TOP w0.114: CPU1.AP22 v6(155.5,161.5)
  BOTTOM w0.114: v2(155.5,162.31) 155.5,161.5 v6(155.5,161.5) 155.5,161.5 R39.1
AGPIO89: length 10.6
  TOP w0.114: v1(145.54,157.86) 146.56,158.88 147.7,158.88 150.21,161.39 151.61,161.39 CPU1.AV22
  BOTTOM w0.114: v1(145.54,157.86) v2(145.54,156.59) 145.55,156.58 R52.1
ALERT#: length 4.2
  BOTTOM w0.114: v2(110.79,53.61) 110.8,53.61 111.07,53.34 111.45,53.34 R231.2 112.19,53.06 112.47,52.78 112.47,51.56 112.34,51.43 U2.6
ALERT#_CPU: length 29.5
  TOP w0.114: R1231.2 200.43,153.34 200.36,153.34 199.57,154.13 v3(199.57,154.43) 199.58,154.44 199.58,163.49 199.14,163.93 198.42,163.93 v1(198.35,164.01) ; CPU1.D16 v6(186.5,167.5)
  L6 w0.102: v1(198.35,164.01) 197.97,164.39 197.97,165.94 195.57,168.33 191.92,168.33 191.36,168.88 187.99,168.88 186.6,167.5 v6(186.5,167.5)
ALL_PWRGD_2: length 9.5
  TOP w0.114: R1195.1 131.25,160.66 R1129.1 131.25,162.14 132.72,163.6 v3(132.72,164.21) 131.41,165.52 131.41,166.21 130.23,167.39 Q53.D
ALL_SYS_PWRGD: length 221.5
  TOP w0.114: CPU1.AM3 v6(157.5,180.5) ; KBC1.10 103.27,55.74 104.07,56.55 104.78,56.55 v1(105.11,56.87) ; v1(135.76,149.48) 135.57,149.67 R38.2
  L3 w0.114: v1(139.22,98.4) 139.22,97.12 139.78,96.55 139.78,95.31 140.3,94.79 140.3,89.27 141.06,88.51 141.06,86.93 143.92,84.07 149.96,84.07 151.94,82.1 155.54,82.1 155.73,81.92 156.57,81.92 156.87,82.22 157.56,82.22 158.47,81.3 163.43,81.3 167.44,77.29 v1(167.44,72.95)
  L4 w0.114: v1(139.22,98.4) 139.44,98.4 140.05,99.01 140.05,101.08 139.14,101.98 139.14,129.9 139.62,130.38 139.62,139.4 136.12,142.89 136.12,149.12 v1(135.76,149.48) 135.76,150.19 136.58,151 136.58,156.51 138.3,158.24 138.3,160.68 143,165.38 143,170.05 144.75,171.81 144.75,173.56 148.03,176.83 148.03,176.89 148.31,177.16 148.31,177.19 148.79,177.67 150.01,177.67 153.1,180.76 153.8,180.76 154.02,180.97 154.6,180.97 155.04,180.54 155.04,180.37 155.28,180.13 156.99,180.13 157.36,180.5 v6(157.5,180.5)
  L6 w0.102: v1(167.44,72.95) 162.76,72.95 162.2,72.39 131.55,72.39 129.53,72.39 123.75,66.61 123.12,66.61 122.41,65.9 121.27,65.9 115.87,60.5 115.08,60.5 113.86,59.28 112.31,59.28 111.9,58.87 111.36,58.33 110.61,58.33 109.4,57.12 108.28,57.12 107.49,56.34 105.64,56.34 v1(105.11,56.87)
  BOTTOM w0.114: R2780.2 106.04,55.38 v2(105.41,56.01) 105.11,56.31 v1(105.11,56.87)
ALL_SYS_PWRGD_C: length 5.5
  TOP w0.114: R2752.2 208.33,224.84 v3(208.33,225.98) 208.33,227.16 R2602.1 209.5,227.27 R374.1 209.61,227.33 D7.3
ALL_SYS_PWRGD_EC: length 318.3
  TOP w0.114: KBC1.84 119.24,54.54 v1(119.53,54.25) ; v1(212.17,73.28) 209.21,70.33 v3(202.98,70.33) 197.64,70.33 197.23,70.74 185.95,70.74 182.38,67.17 181.19,67.17 180.38,66.36 179.67,66.36 v1(178.87,65.56) ; v1(212.29,228.62) 212.22,228.55 212.22,228.52 211.76,228.07 208.52,228.07 R2602.2
  L4 w0.114: v1(212.17,73.28) 214.68,73.28 222.5,81.1 222.5,82.19 223.94,83.62 223.94,87.63 223.23,88.34 223.23,93.69 220.85,96.07 220.85,104.49 220.9,104.54 220.9,115.69 216.01,120.57 216.01,127.98 216.43,128.4 v1(216.43,128.5)
  L6 w0.102: v1(119.53,54.25) 120.29,55.02 121.28,55.02 122.63,56.36 123.92,56.36 125.42,57.86 126.85,57.86 129.39,60.4 132.03,60.4 133.93,62.31 136.27,62.31 139.09,65.13 146.09,65.13 146.49,64.72 150.24,64.72 152.17,66.65 156.72,66.65 156.72,66.65 164.34,66.65 168.59,66.65 169.25,67.31 176.03,67.31 177.86,65.48 178.58,65.48 178.65,65.56 v1(178.87,65.56) ; v1(216.43,128.5) 215.95,128.98 215.95,131.32 216.53,131.9 216.53,137.41 217.73,138.61 217.73,138.91 219.74,140.92 219.74,144.8 221.62,146.69 225.93,146.69 227.84,148.59 227.84,150.76 217.94,160.66 212.77,160.66 208.45,164.97 208.43,164.97 205.38,168.02 205.38,177.99 203.05,180.32 203.05,184.2 201.29,185.95 201.29,190.22 204.57,193.5 204.57,195.46 205.46,196.35 205.46,198.42 206.63,199.59 206.63,200.63 210.46,204.47 211.84,204.47 213.54,206.17 216.58,206.17 217.57,207.16 218.49,207.16 224.03,212.7 224.03,222.38 224.05,222.4 224.05,225.55 222.53,227.08 221.79,227.08 220.68,228.19 217.27,228.19 216.38,229.08 212.7,229.08 212.29,228.68 v1(212.29,228.62)
AM4R1: length 47
  TOP w0.114: CPU1.AL8 159.53,175.53 v6(159.54,175.53) ; R23.2 139.76,146.37 v1(140.72,147.32)
  L4 w0.114: v6(159.54,175.53) 159.54,175.54 159.92,175.92 159.92,176.7 159.68,176.94 155.35,176.94 155.07,176.65 155.07,176.48 154.9,176.31 154.9,176.27 154.64,176.02 154.43,176.02 153.92,175.51 153.92,175.38 153.55,175.01 152.42,175.01 151.89,174.48 151.89,173.34 149.74,171.2 149.1,171.2 147.9,170 147.9,165.79 147.02,164.9 147.02,162 143.32,158.31 143.32,154.14 143.15,153.97 143.15,149.84 140.72,147.4 v1(140.72,147.32)
  BOTTOM w0.114: TP9.1 159.02,175.01 v6(159.54,175.53)
AMDTSI_CLK_CPU: length 14.1
  TOP w0.114: v1(196.61,168.87) 196.56,168.87 196.32,168.63 196.32,167.67 196.1,167.45 RN1.4 195.36,167.45 195.17,167.64 192.33,167.64 190.08,165.39 188.39,165.39 CPU1.B18
  BOTTOM w0.114: Q75.1 195.74,171.26 196.54,170.47 v2(196.54,169.83) 196.61,169.76 v1(196.61,168.87)
AMDTSI_DATA_CPU: length 14.5
  TOP w0.114: v1(194.78,168.86) 195.07,168.86 195.45,168.48 195.5,168.48 195.72,168.26 RN1.3 195.62,168 192.18,168 189.79,165.61 187.61,165.61 CPU1.C18
  BOTTOM w0.114: v2(193.99,168.25) 194.17,168.25 v1(194.78,168.86) 194.78,169.38 194.2,169.96 Q75.4
AMP_ASEL: length 4.2
  TOP w0.114: U7.18 214,29.92 213.87,30.05 v3(213.87,30.16) 213.87,30.79 213.87,30.8 PR16.2 213.87,31.17 PR17.1
AMP_AVDD2: length 1.7
  TOP w0.203: v1(212.8,29.79) U7.21
  vias: v2(212.72,30.61)
AMP_BST_A: length 7.8
  TOP w0.114: U7.2 216.68,22.44 217.13,21.99 219.14,21.99 v1(219.43,22.28)
  BOTTOM w0.114: v1(219.43,22.28) 219.43,22.15 219.07,21.79 v2(219.07,21.34) C361.1
AMP_BST_B: length 6.2
  TOP w0.114: v1(212.6,18.8) 212.88,19.08 212.88,20.62 212.8,20.7 U7.50
  BOTTOM w0.114: C362.2 209.96,17.42 v2(210.64,18.11) 210.82,18.29 212.09,18.29 v1(212.6,18.8)
AMP_BST_B_C:
  vias: v2(208.61,15.8)
AMP_BST_C: length 5.2
  TOP w0.114: U7.49 212.4,20.55 212.62,20.32 212.62,19.53 211.99,18.9 C363.1 212.52,17.7 v3(213.06,17.17)
AMP_BST_C_C: length 2.9
  TOP w0.114: R312.2 212.77,15.29 v3(213.11,15.63) 213.11,15.88 212.47,16.51 C360.1
AMP_BST_D: length 8.6
  TOP w0.114: U7.41 208.53,22.44 208.11,22.02 208.11,21.78 207.76,21.43 207.52,21.43 207.11,21.02 204.66,21.02 204.42,20.78 204.42,19.66 v3(204.6,19.48) 205.15,18.93 C364.2
AMP_GVDD_AB: length 4.6
  TOP w0.114: U7.3 216.81,22.84 217.07,22.58 v3(218.11,22.58) 218.46,22.58 R315.2 220.12,23.19 C374.2
AMP_GVDD_CD: length 3.4
  TOP w0.114: C376.1 207.29,21.8 v3(207.52,22.02) 208.33,22.84 U7.40
AMP_I2C_SCL: length 8
  TOP w0.114: U7.8 217.01,24.84 218,25.82 218,26.86 218.46,27.32 R2512.2 217.65,27.63 v1(217.58,27.56)
  BOTTOM w0.114: R2514.2 218.46,27.43 218.59,27.57 v2(218.59,28.21) 218.23,28.21 v1(217.58,27.56)
AMP_I2C_SDA: length 6.9
  TOP w0.114: R2511.2 218.46,25.57 v1(217.55,24.66) 217.33,24.44 U7.7
  BOTTOM w0.114: v2(218.81,24.45) 217.76,24.45 v1(217.55,24.66) 217.55,25.32 217.93,25.71 R2513.2
AMP_ISENSEP_L: length 4.9
  TOP w0.114: U7.25 211.2,28.77 210.79,29.18 210.79,29.39 210.44,29.74 v3(210.44,30.1) 210.54,30.2 210.54,31.25 PR9.2 210.03,31.28 PR15.1
AMP_ISENSEP_R: length 5.7
  TOP w0.114: PR6.2 206.55,29.19 PR14.2 207.5,28.72 v3(207.57,28.65) 208.2,28.65 208.53,28.98 209.78,28.98 210,28.76 U7.28
AMP_IVSENSE_L: length 5.8
  TOP w0.114: v1(209.42,29.79) 209.45,29.82 209.88,29.82 210.57,29.13 210.57,29.09 210.8,28.86 U7.26
  BOTTOM w0.114: v1(209.42,29.79) 209.37,29.85 PR13.1 209.36,30.74 PR8.2 207.64,30.74 v2(207.26,31.11)
AMP_IVSENSE_R: length 3.8
  TOP w0.114: U7.29 208.55,27.24 208.46,27.33 v3(207.57,27.33) 207.57,27.34 207.22,27.68 PR12.2 PR5.2
AMP_LDO_1D5: length 4.4
  TOP w0.203: 212.29,29.13 212.4,29.03 U7.22
  TOP w0.254: 212.29,29.13 212.12,29.31 212.12,29.92 212.78,30.58 C379.1 212.34,31.19 v3(211.66,31.19)
AMP_OC_ADJ: length 6.2
  TOP w0.114: U7.5 217.62,23.64 217.65,23.67 v1(218.24,23.67)
  BOTTOM w0.114: v1(218.24,23.67) 218.24,23.04 217.55,22.35 v2(216.66,22.35) 216.15,22.86 R313.2
AMP_OUT_A: length 1.7
  TOP w0.203: U7.55 214.8,20.36 v4(215.42,19.74)
  vias: v2(216.41,18.41) v4(215.42,18.82)
AMP_OUT_A_C:
  vias: v2(218.44,16.64)
AMP_OUT_A_L: length 27.9
  TOP w0.508: v1(210.19,33.07) 210.57,32.69 PR9.1
  L3 w0.254: v4(218.31,11.94) 215.39,11.94 209.73,17.6 209.73,28.57 210.46,29.31 210.46,32.87 210.26,33.07 v1(210.19,33.07)
  vias: v2(215.9,12.7) v4(218.26,12.85)
AMP_OUT_B: length 1.7
  TOP w0.203: U7.52 213.6,20.36 v4(214.2,19.76)
  vias: v2(213.23,19.56) v4(214.2,18.85)
AMP_OUT_C: length 2
  TOP w0.203: 211.25,19.35 211.25,19.96 211.6,20.31 U7.47
  vias: v3(210.57,18.87)
AMP_OUT_C_L: length 21.9
  TOP w0.508: v1(205.44,30.23) 205.92,29.74 PR6.1
  L3 w0.254: v1(205.44,30.23) 205.44,27.36 207.21,25.58 207.21,17.55 208.84,15.93 208.84,11.4 v4(209.32,10.92)
  vias: v3(213.16,12.57)
AMP_OUT_D: length 1.3
  TOP w0.203: 209.96,20.09 210.4,20.53 U7.44
  vias: v3(207.67,16.51)
AMP_OUT_D_C: length 2.7
  TOP w0.508: C357.2 204.98,17.71 v3(204.7,17.42)
  TOP w0.635: C357.2 206.05,16.54 R309.1
AMP_PGVDD: length 5.8
  TOP w0.114: R314.2 220,24.08 R315.1 219.07,25.07 v3(218.97,25.17) 218.54,25.17 218.04,24.67 218.04,24.46 217.62,24.04 U7.6
AMP_SPKR_L+_C: length 29.5
  TOP w0.508: PR7.1 206.26,31.64 v1(206.25,31.62)
  L3 w0.254: v1(206.25,31.62) 207.14,31.62 207.77,30.99 207.77,29.36 208.71,28.42 208.71,17.6 208.69,17.58 208.69,17.17 215.62,10.24 216.92,10.24 217.86,9.3 v1(217.91,9.3)
  vias: v2(215.9,9.53) v4(218.74,9.37)
AMP_SPKR_L-_C: length 29.4
  L3 w0.254: v4(218.16,10.74) 215.85,10.74 209.22,17.37 209.22,28.75 208.33,29.64 v1(208.33,32.69)
  BOTTOM w0.508: v2(217.29,10.95) 217.42,10.95 217.42,10.95 217.96,10.95 v4(218.16,10.74) ; v1(208.33,32.69) PR8.1
AMP_SPKR_R+_C: length 18.6
  TOP w0.559: v1(205.03,25.48) 205.18,25.48 205.33,25.63 PR4.1
  L3 w0.254: v1(205.03,25.48) 205.01,25.48 204.19,24.65 204.19,19.1 207.82,15.47 v4(207.82,10.69)
  BOTTOM w0.508: v4(207.82,10.69) v2(207.82,11.63)
AMP_SPKR_R-_C: length 25.3
  TOP w0.508: v1(204.75,26.87) 204.96,26.67 PR5.1
  L3 w0.254: v4(213.59,10.77) 212.76,9.94 209.44,9.94 208.33,11.05 208.33,15.7 205.69,18.34 205.69,25.93 v1(204.75,26.87)
  BOTTOM w0.508: v2(212.7,10.77) v4(213.59,10.77)
AMP_VREF1: length 6.5
  TOP w0.114: C380.1 210.96,33.13 v3(211.58,32.51) 211.18,32.11 211.18,31.93 211.03,31.78 211.03,30.63 211.81,29.84 211.81,28.98 212,28.79 U7.23
AMP_VSENSEN_L: length 5.3
  TOP w0.114: U7.27 210.4,28.96 210.07,29.29 208.85,29.29 v3(208.41,29.72) 208.33,29.8 PR11.1 208.31,30.75 PR7.2
AMP_VSENSEN_R: length 5.1
  TOP w0.114: U7.30 209.14,26.87 208.08,26.87 PR4.2 206.58,25.37 PR10.2 206.8,24.38 v3(207.59,24.38)
APU_DBRDY: length 47.6
  TOP w0.114: HDT1.14 216.89,153.52 v1(216.28,152.91) ; CPU1.E13 v6(185.51,170.52)
  L3 w0.114: v1(216.28,152.91) 215.33,153.86 215.33,154.26 213.43,156.16 210.17,156.16 206.25,160.08 206.25,164.82 198.41,172.66 197.32,172.66 196.53,171.87 191.12,171.87 189.35,170.09 186.19,170.09 185.76,170.52 v6(185.51,170.52)
  BOTTOM w0.114: v5(215.62,152.38) 215.75,152.38 v1(216.28,152.91)
APU_DBREQ#: length 38.8
  TOP w0.114: CPU1.D14 v6(186.49,168.4) ; v1(213.21,154) 213.21,153.57 213.54,153.23 R20.2 214.16,153.29 R725.2
  L3 w0.114: v1(213.21,154) 213.06,153.85 209.26,153.85 208.5,154.61 202.15,160.96 202.15,161.71 198.88,164.97 196.6,164.97 195.29,166.28 195.29,166.95 193.91,168.32 193.54,168.32 193.53,168.33 186.75,168.33 186.67,168.4 v6(186.49,168.4)
  BOTTOM w0.114: v1(213.21,154) 213.21,154.03 213.74,154.56 v2(213.77,154.59)
APU_TCK: length 44.2
  TOP w0.114: RN2.5 216.37,146.11 v1(216.41,146.15) 216.66,145.9 HDT1.2 ; CPU1.C15 v6(187.5,167.5)
  L6 w0.102: v1(216.41,146.15) 216.24,146.15 214.86,147.53 214.86,147.73 209.85,152.73 209.85,152.99 209.13,153.72 208.38,153.72 205.43,156.67 204.92,156.67 204.92,156.67 204.46,156.67 197.13,164 197.13,164.95 194.47,167.61 191.62,167.61 191.08,168.15 188.15,168.15 v6(187.5,167.5)
  BOTTOM w0.114: v2(217.22,146.1) 217.17,146.15 v1(216.41,146.15)
APU_TDI: length 47.3
  TOP w0.114: HDT1.6 218.03,148.44 217.04,147.45 216.48,147.45 v1(216.22,147.7) 215.78,147.26 RN2.7 ; CPU1.A14 190.14,169 192.23,171.09 198.04,171.09 v1(199.9,169.24)
  L6 w0.102: v1(199.9,169.24) 200.96,168.17 200.96,163.35 205.41,158.9 206.36,158.9 209.05,156.22 210.12,156.22 215.94,150.39 215.94,147.98 v1(216.22,147.7)
  BOTTOM w0.114: v1(216.22,147.7) 216.48,147.45 v2(217.3,147.45)
APU_TDO: length 52.1
  TOP w0.114: HDT1.8 217.02,149.71 v1(216.41,149.1) ; CPU1.C14 187.32,169 187.71,168.61 188.16,168.61 188.42,168.88 188.42,168.97 189.03,169.57 189.89,169.57 191.77,171.45 196.34,171.45 196.8,171.91 v1(196.8,173.02)
  L3 w0.114: v1(216.41,149.1) 216.74,149.43 216.74,154.34 214.5,156.59 210.33,156.59 206.78,160.15 206.78,164.88 198.58,173.08 196.85,173.08 v1(196.8,173.02)
  BOTTOM w0.114: v1(216.41,149.1) 216.79,149.48 v5(216.79,149.99)
APU_TMS: length 48.7
  TOP w0.114: v1(199.14,169.24) 199.14,169.34 197.73,170.75 192.51,170.75 190.17,168.41 188.41,168.41 CPU1.B15 ; HDT1.4 217.27,147.17 217.09,146.99 216.46,146.99 v1(216.44,146.97) 216.41,146.97 216.2,146.76 RN2.6
  L6 w0.102: v1(199.14,169.24) 200.56,167.82 200.56,163.18 205.24,158.5 206.19,158.5 208.88,155.81 209.95,155.81 215.26,150.5 215.26,147.7 215.98,146.99 216.42,146.99 v1(216.44,146.97)
  BOTTOM w0.114: v2(215.52,146.3) 215.77,146.56 216,146.56 216.41,146.97 v1(216.44,146.97)
APU_TRST#: length 61.6
  TOP w0.114: R721.1 226.16,149.71 v1(227.2,150.75) ; v1(216.79,148.21) 216.53,148.46 215.94,148.46 215.39,147.91 RN2.8 ; CPU1.B13 188.39,170 188.83,170.44 189.92,170.44 191.54,172.06 195.01,172.06 C925.1 195.02,172.08 v1(195.02,172.92)
  L6 w0.102: v1(216.79,148.21) 216.87,148.29 216.87,151.36 212.1,156.12 211.6,156.62 209.21,156.62 205.67,160.16 205.67,161.92 205.3,162.3 204.71,162.89 202.49,162.89 202.11,163.27 202.11,168.58 199.09,171.6 197.89,171.6 197.26,172.22 195.72,172.22 v1(195.02,172.92)
  BOTTOM w0.114: v1(216.79,148.21) v5(218.69,150.11) 219.33,150.75 v1(227.2,150.75)
