# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VDDNBA_BOOT: length 4.3
  TOP w0.305: PR146.1 217.23,202.41 216.84,202.41 216.82,202.39 PU21.2
  TOP w0.508: PR146.1 218.95,204.32 v3(218.95,204.75)
PWR_VDDNBA_BOOT_A: length 4.7
  TOP w0.508: PR146.2 217.17,201.5 216.05,200.38 PC170.1 216.05,199.24 v3(215.29,198.48)
PWR_VDDNBA_HG: length 5.2
  TOP w0.305: PU21.1 215.81,201.89 214.93,201.02 v4(214.53,201.02)
  BOTTOM w0.635: PR147.1 213.26,199.75 v5(213.41,199.9) v4(214.53,201.02)
PWR_VDDNBA_HG_A: length 5.1
  TOP w0.762: PU20.4 209.21,191.8 v4(209.17,191.84)
  L4 w1.016: v4(209.17,191.84) 209.32,191.99 209.32,195.28 v4(209.17,195.43)
  vias: v2(208.28,195.53)
PWR_VDDNBA_LG: length 27
  TOP w0.305: PU21.5 213.73,203.77 214.01,204.05 214.01,204.05 v4(214.17,204.22)
  TOP w0.762: v4(216.36,187.71) 216.48,187.58 PU23.4
  L4 w1.016: v4(216.38,181.81) 216.36,181.84 v4(216.36,187.71) 214.25,189.81 214.25,196.47 215.82,198.04 215.82,202.94 214.55,204.22 v4(214.17,204.22)
  vias: v5(218.06,181.74)
PWR_VDDNBA_PH: length 17.3
  TOP w0.305: PU21.8 213.12,201.89 212.78,201.55 v4(212.78,200.99)
  TOP w0.508: v4(212.78,200.99) 213.94,199.82 PC170.2
  L4 w1.016: v4(208.91,189.76) 209.96,189.76 211.71,191.52 211.71,199.92 v4(212.78,200.99)
  vias: v2(210.46,188.82) v3(208.71,194.13) v4(206.76,193.29) v4(206.76,192.38) v4(206.88,180.97) v4(207.01,185.67) v4(207.31,183.67) v4(207.39,182.12) v4(207.52,194.23) v4(207.72,180.21) v4(207.9,185.17) v4(208.03,186.56) v4(208.13,193.22) v4(208.13,192.3) v4(208.15,188.09) v4(208.28,179.27) v4(208.79,183.77) v4(208.79,180.21) v4(208.86,182.22) v4(209.17,187.32) v4(209.17,185.8) v4(209.55,177.8) v4(209.68,179.2) v4(210.29,180.29) v4(210.44,176.66) v4(210.85,179.35) v4(210.95,178.05) v4(211.35,180.29) v4(211.71,176.78) v4(215.9,176.02) v4(217.04,180.34) v4(217.04,178.82) v4(217.17,177.16) v5(212.8,180.26) v5(213.13,176.2) v5(214.45,178.44) v5(215.72,179.93)
PWR_VDDNBA_PWM: length 23.4
  TOP w0.305: PU21.3 216.61,202.89 v1(216.79,203.07)
  L3 w0.381: v1(216.79,203.07) 216.89,203.17 216.89,206.48 216.51,206.87 216.51,208.33 215.32,209.52 214.61,209.52 214.3,209.83 214.3,210.85 211.18,213.97 211.18,218.01 210.67,218.52 209.65,218.52 v1(209.58,218.44)
  BOTTOM w0.203: PU6.28 209.74,218.61 v1(209.58,218.44)
  BOTTOM w0.381: v5(216.31,202.36) 216.79,202.84 v1(216.79,203.07)
PWR_VDDNBA_VCC: length 4.9
  TOP w0.305: v3(212.37,203.84) 213.31,202.89 PU21.6
  TOP w0.508: 214,205.77 213.6,205.37 PC169.1 212.37,205.07 v3(212.37,203.84)
PWR_VDDNBA_VSUMN_A: length 70.4
  TOP w0.254: v1(219.68,223.06) 219.96,222.78 220.57,222.78 220.79,222.57 PR150.2 222.17,222.57 PR151.2 ; v1(212.33,173.69) 212.65,174.02 213.77,174.02 214.22,173.56 PG57.2
  L3 w0.254: v1(212.33,173.69) 212.65,174.02 218.21,174.02 220.47,176.28 220.47,196.56 225.45,201.54 225.45,213.06 224.16,214.36 224.16,217.27 224.46,217.58 224.46,221.39 222.66,223.19 219.83,223.19 219.81,223.16 v1(219.68,223.06)
  BOTTOM w0.254: v5(213.33,173.69) v1(212.33,173.69)
PWR_VDDNBA_VSUMP_A: length 68.6
  TOP w0.254: PG56.2 214.07,175.01 213.59,174.52 212.65,174.52 v1(212.33,174.84)
  L3 w0.254: v1(212.33,174.84) 212.65,174.52 218,174.52 219.96,176.49 219.96,196.77 224.94,201.75 224.94,212.85 223.65,214.15 223.65,217.49 223.95,217.79 223.95,221.18 222.45,222.68 220.67,222.68 220.53,222.56 220.32,222.39 v1(220.32,222.22)
  BOTTOM w0.254: v5(211.34,174.8) 211.35,174.8 211.35,174.8 212.29,174.8 v1(212.33,174.84) ; v1(220.32,222.22) 220.27,222.28 220.27,223.2 PR153.2 221.4,223.43 PR152.2
PWR_VDDNBB_BOOT: length 4.5
  TOP w0.305: 221.38,206.9 PU26.2
  TOP w0.508: 221.38,206.9 220.52,207.76 PR155.1 219.91,208.33 219.18,207.59 v3(218.99,207.59)
PWR_VDDNBB_BOOT_A: length 2.8
  TOP w0.508: PR155.2 223.75,208.33 v3(223.88,208.46) 224.05,208.28 PC176.1
PWR_VDDNBB_HG: length 19.1
  TOP w0.305: PU26.1 221.88,206.26 222.48,206.86 v4(222.58,206.86)
  L6 w1.016: v4(222.58,206.86) 222.22,206.5 222.22,203.12 223.55,201.8 223.55,197.08 225.37,195.25 225.37,190.58 v4(225.3,190.5)
  vias: v5(223.39,188.72)
PWR_VDDNBB_HG_A: length 7.5
  TOP w0.635: PU25.4 229.49,196.67 229.29,196.88 v4(229.29,196.95)
  L3 w1.016: v4(229.11,190.75) 229.29,190.93 v4(229.29,196.95)
  vias: v5(227.97,190.12)
PWR_VDDNBB_LG: length 27.9
  TOP w0.305: v4(220.4,202.31) 220.38,202.32 PU26.5
  TOP w0.635: v4(222.5,182.98) 222.55,182.93 PU28.4
  L6 w1.016: 222.66,186.74 223.7,185.7 223.7,183.85 222.83,182.98 v4(222.5,182.98) ; 222.66,186.74 v4(222.5,186.74) ; 222.66,186.74 223.57,187.66 223.57,189.53 220.68,192.43 220.68,201.9 220.4,202.18 v4(220.4,202.31)
  BOTTOM w0.508: v5(222.25,181.86) 222.66,182.27 222.66,182.83 v4(222.5,182.98)
  BOTTOM w0.635: PU27.4 v4(222.5,186.74)
PWR_VDDNBB_PH: length 17.5
  TOP w0.305: PU26.8 222.65,203.77 222.68,203.73
  TOP w0.508: 222.68,203.73 223.75,203.73 v4(224,203.99) 224.05,204.04 PC176.2
  L6 w1.016: v4(224,203.99) 227.69,200.3 227.69,195.88 229.49,194.08 230.86,194.08 v4(230.89,194.11)
  vias: v4(223.42,178.82) v4(223.55,180.04) v4(223.55,177.83) v4(223.49,176.68) v4(224.56,176.68) v4(227.94,175.87) v4(228.24,176.75) v4(228.96,180.82) v4(228.96,179.91) v4(228.96,178.99) v4(229.01,175.87) v4(229.21,176.94) v4(229.9,178.69) v4(229.9,177.77) v4(229.97,179.78) v4(230.07,180.85) v4(230.12,176.45) v4(230.71,190.93) v4(230.84,189.15) v4(230.89,193.04) v4(230.89,192) v4(230.96,187.22) v4(230.96,186.31) v4(230.96,185.39) v4(230.96,184.48) v4(230.96,183.57) v4(230.96,182.65) v4(230.96,181.74) v5(225.04,178.59) v5(226.14,175.9) v5(226.95,180.57) v5(227.61,178.26) v5(231.32,179.1) v5(231.65,188.21)
PWR_VDDNBB_PWM: length 30.6
  TOP w0.305: PU26.3 220.88,206.31 220.51,206.68 218.82,206.68 v3(218.08,205.94) 218.02,205.87 v1(218.02,204.95)
  L3 w0.381: v1(218.02,204.95) 218.02,205.01 218.08,205.08 218.08,208.69 216.66,210.11 216.66,212.14 218.44,213.92 218.44,215.98 217.02,217.4 217.02,220.85 214.55,223.32 214.55,223.75 v1(213.36,224.94)
  BOTTOM w0.203: PU6.40 213.5,223.74 213.61,223.85 213.61,224.69 v1(213.36,224.94)
PWR_VDDNBB_SNB: length 2.5
  TOP w0.508: PC178.1 v3(225.24,189.31) PR158.2
PWR_VDDNBB_VCC: length 4.6
  TOP w0.508: v3(222.86,200.43) 222.86,201.55 PR154.2 222.45,201.83 222.08,201.46 PC177.1 221.26,201.54 221.26,202.79
PWR_VDDNBB_VSUMN_A: length 66.1
  TOP w0.254: v1(224.33,174.27) 224.43,174.37 225.58,174.37 226.42,173.53 PG62.2
  L3 w0.254: v1(225.98,221.44) 225.98,220.34 225.45,219.81 225.45,214.14 226.21,213.38 226.21,203.23 228.73,200.71 231.01,200.71 232.03,199.69 232.03,175.59 230.48,174.04 224.56,174.04 v1(224.33,174.27)
  BOTTOM w0.254: PR159.2 224.05,222.47 PR160.2 225.15,221.97 224.99,221.82 v2(224.99,221.41) 225.96,221.41 v1(225.98,221.44)
PWR_VDDNBB_VSUMP_A: length 70.7
  TOP w0.254: PR162.2 224.6,222.52 PR161.2 225.93,222.3 v1(226.11,222.48) ; PG61.2 226.29,175.49 225.68,174.88 224.1,174.88 223.39,174.17 v1(223.39,173.99)
  L3 w0.254: v1(223.39,173.99) 223.85,173.53 230.69,173.53 232.54,175.38 232.54,199.91 231.22,201.22 228.94,201.22 226.72,203.44 226.72,213.59 225.96,214.35 225.96,219.6 226.49,220.13 226.49,221.15 226.57,221.23 226.57,222.02 v1(226.11,222.48)
  BOTTOM w0.254: v2(222.43,173.99) v1(223.39,173.99)
PWR_VDDP: length 12.3
  TOP w0.203: PC210.1 152.27,199.34 PG108.1 PG107.1 PG111.1 PG113.1 PG115.1 147.9,199.34 147.73,199.52
  TOP w0.254: PG110.2 147.24,199.42 PC410.1
  BOTTOM w0.203: 147.36,199.32 PG114.1 PG116.1 ; PC210.1 152.26,199.32 PG118.1 PG119.1 PG117.1 ; PC410.1 147.35,199.31
  vias: v2(148.46,202.46) v2(151.03,202.64) v4(149.1,201.42) v4(149.1,200.41) v4(150.24,201.42) v4(150.24,200.41) v4(151.26,201.42) v4(151.26,200.41)
PWR_VDDP_BT: length 3.8
  TOP w0.508: PC209.2 150.85,212.85 v3(150.39,212.39) 150.39,212.17 v1(150.98,211.58)
  BOTTOM w0.305: PU32.20 151.51,212.21 150.98,211.68 v1(150.98,211.58)
PWR_VDDP_EN: length 33.1
  TOP w0.254: v1(147.88,213.79) 148.77,213.79 149.05,214.07 PC430.1 148.5,216.45 PR384.1 147.8,216.47 PR362.2 146.3,216.47 145.65,217.12 144.08,217.12 PR361.2 143.6,216.64 142.47,216.64 v3(141.92,216.08) 141.45,215.61 138.91,215.61 138.63,215.34 138.63,214.33 137.87,213.56 135.76,213.56 132.99,210.8 132.99,207.72 135.19,205.53 PC426.1 135.57,204.85 PU53.8
  BOTTOM w0.254: PU32.2 148.25,214.13 147.9,213.79 v1(147.88,213.79)
PWR_VDDP_FB: length 7.1
  BOTTOM w0.305: PR350.1 147.84,217.16 148.34,216.66 148.34,215.77 148.47,215.63 PU32.5
  BOTTOM w0.457: v5(146.35,217.09) 145.64,217.09 PR187.1
  BOTTOM w0.508: PR185.2 PC220.2 145.31,217.26 PR187.1 ; PR350.1 147.27,217.09 v5(146.35,217.09)
PWR_VDDP_FB_A: length 29.7
  TOP w0.508: PG110.1 146.15,198.25 146.1,198.3 v1(144.98,198.3)
  L6 w0.508: v1(142.34,218.29) 142.24,218.19 142.24,215.01 141.88,214.66 141.88,214.49 139.96,212.57 139.22,212.57 138.2,211.56 138.2,207.95 144.98,201.17 v1(144.98,198.3)
  BOTTOM w0.508: v2(144.09,198.18) 144.86,198.18 v1(144.98,198.3) ; PC220.1 PR185.1 143.01,218.15 142.8,218.36 142.42,218.36 v1(142.34,218.29)
PWR_VDDP_FB_B: length 3.1
  BOTTOM w0.406: PU52.6 146.09,214.36 146.84,215.11 v5(146.84,215.34) 147.35,215.85 PR350.2
PWR_VDDP_FB_C: length 5.2
  BOTTOM w0.406: PU52.3 142.26,215.66 v5(141.97,215.38) PR394.2 142.09,213.97 142.49,214.38 142.49,214.5 143,215.01 PU52.2
PWR_VDDP_PFM: length 5
  TOP w0.254: PR186.1 145.62,214.3 v3(145.8,214.12) 145.85,214.07 147.32,214.07 v1(147.8,214.55)
  BOTTOM w0.254: PU32.3 147.88,214.63 v1(147.8,214.55)
PWR_VDDP_PG: length 3.3
  TOP w0.254: PR334.1 146.39,212.62 v3(147.59,212.62) 147.78,212.62 v1(148.29,213.13)
  BOTTOM w0.254: v1(148.29,213.13) 148.79,213.63 PU32.1
PWR_VDDP_PH: length 0.1
  BOTTOM w0.305: PU32.16 153.31,214.08
  vias: v1(153.14,211.33) v1(153.16,209.55) v1(154.23,211.33) v1(154.18,209.55) v2(152.2,209.17) v6(152.15,215.26) v6(152.2,216.13) v6(152.17,214.25)
PWR_VDDP_SS: length 5.1
  BOTTOM w0.254: v5(146.96,214.02) 146.96,213.07 PC221.1 147.52,213.06 148.62,211.96 149.53,211.96 150.01,212.44 PU32.22
PWR_VDDP_TON: length 3.9
  BOTTOM w0.254: v5(149.35,219.96) 149.35,219.71 149.29,219.65 PR184.2 149.21,218.61 PU32.6
PWR_VDDQ_BOOT: length 3.7
  TOP w0.203: PU29.18 224.41,137.03 224.84,136.6 v3(224.84,136.27)
  TOP w0.508: v3(224.84,136.27) 224.84,135.94 224.13,135.23 PR167.1
PWR_VDDQ_BOOT_A: length 2.6
  TOP w0.508: v3(220.09,135) 220.27,134.82 PC187.1 221.46,134.95 PR167.2
PWR_VDDQ_CS: length 4.7
  TOP w0.203: 220.73,138.76 221.23,139.27 221.23,139.28 221.66,139.7 PU29.13
  TOP w0.254: 220.73,138.76 220.34,138.38 PR165.1 219.95,137.55 v3(220.22,137.29)
PWR_VDDQ_EN: length 3.5
  TOP w0.203: PC196.1 224.41,143.07 v1(224.41,142.42) PU29.8
  TOP w0.254: PC196.1 PR172.2
  BOTTOM w0.254: v1(224.41,142.42) 224.43,142.39 v2(225.01,142.39)
PWR_VDDQ_EN_R: length 15.5
  TOP w0.254: v1(225.11,145.22) 225.02,145.14 223.85,145.14 223.46,144.74 PR172.1 ; R393.2 C463.1 v1(219.11,136.91)
  BOTTOM w0.254: v1(219.11,136.91) 219.11,139.76 v2(219.28,139.93) 221.27,141.92 221.93,141.92 225.11,145.1 v1(225.11,145.22)
PWR_VDDQ_FB: length 7.1
  TOP w0.203: PU29.6 225.21,141.62 225.7,142.11 225.7,142.74 PR170.2
  TOP w0.508: v3(229.41,145.34) 229.1,145.02 PR171.1 228.23,145.06 227.03,145.06 226.33,144.37 PC192.2 226.33,143.91 225.97,143.55 PR170.2
PWR_VDDQ_HG: length 29.4
  TOP w0.203: PU29.17 224.01,136.38 223.88,136.25 v4(223.88,136.14)
  TOP w0.762: v4(230.23,119.53) 230.25,119.56 PQ3.4
  L6 w1.016: v4(223.88,136.14) 225.53,136.14 227,134.67 227,121.26 226.36,120.62 v4(226.36,119.53) 226.8,119.1 229.79,119.1 v4(230.23,119.53)
  BOTTOM w0.508: v2(224.28,137.16) 224.28,136.55 v4(223.88,136.14)
  BOTTOM w0.762: PQ4.4 226.44,119.61 v4(226.36,119.53)
PWR_VDDQ_LG: length 20.9
  TOP w0.203: v4(221.31,138.35) 221.84,138.35 222.39,138.9 PU29.15
  TOP w0.762: PQ5.4 v4(217.88,128.12)
  L6 w1.016: v4(217.88,128.12) 218.41,127.58 221.16,127.58 v4(221.69,128.12) 221.69,133.88 220.52,135.05 220.52,137.57 v4(221.31,138.35)
  BOTTOM w0.508: v2(221.28,137.24) 221.28,138.33 v4(221.31,138.35)
  BOTTOM w0.762: v4(221.69,128.12) 221.69,127.59 221.68,127.58 221.68,126.75 PQ6.4
PWR_VDDQ_PG: length 183.5
  TOP w0.203: v1(115.32,62.53) 114.83,62.05 114.83,60.91 KBC1.101 ; 222.5,141.48 222.93,141.91 223.39,141.91 223.61,141.69 PU29.10
  TOP w0.254: v1(219.01,142.05) PR166.2 220.42,142.05 220.99,141.48 222.5,141.48
  L4 w0.254: v1(115.32,62.53) 115.72,62.13 120.17,62.13 120.55,62.51 v1(123.67,62.51) ; v1(188.2,77.07) 188.64,77.07 189.08,76.63 190.35,76.63 191.94,78.22 202.78,78.22 210.15,85.59 210.15,102.15 210.46,102.46 210.46,114.4 209.27,115.6 209.27,131.78 212.04,134.54 213.57,134.54 214.82,135.79 214.82,135.79 215.19,136.16 215.19,136.69 215.19,136.69 215.19,140.41 216.83,142.05 v1(219.01,142.05)
  L6 w0.254: v1(188.2,77.07) 182.27,83.01 169.23,83.01 169.18,83.06 164.16,83.06 160.91,79.81 157.73,79.81 v1(155.98,78.05)
  BOTTOM w0.254: v1(155.98,78.05) 154.7,78.05 149.03,72.38 128.77,72.38 125.88,69.49 125.88,65.51 v2(125.15,64.77) 125.15,64.21 123.67,62.74 v1(123.67,62.51)
PWR_VDDQ_PH: length 20.5
  TOP w0.203: 223.47,137.54 223.61,137.68 PU29.16
  L6 w1.016: v4(222.91,137.44) 222.33,136.86 222.33,135.79 225.07,133.05 225.07,122.76 224.03,121.72 v4(224.03,119.38)
  vias: v2(224.99,118.26) v2(225.55,115.57) v2(228.47,115.52) v2(228.57,118.62) v4(219.07,119.61) v4(219.71,118.39) v4(220.6,119.56) v4(220.83,117.7) v4(221.54,116.61) v4(222.12,118.11) v4(222.2,119.61) v4(222.81,116.64) v4(223.04,114.76) v4(223.29,118.16) v4(224.13,116.59) v4(224.31,114.78) v4(225.63,113.89) v4(226.9,113.92) v4(228.22,113.87) v4(229.67,113.89) v4(229.97,117.93) v4(230,116.61) v4(229.97,115.47) v4(230.89,117.93) v4(230.91,116.61) v4(230.89,115.47)
PWR_VDDQ_SNUB: length 2.4
  TOP w0.508: PC191.1 v3(223.9,123.83) 223.9,122.7 PR169.2
PWR_VDDQ_TON: length 5.9
  TOP w0.203: PU29.9 224.01,141.98 223.49,142.49 222,142.49 221.69,142.19 v3(221.36,142.19)
  TOP w0.254: v3(221.36,142.19) 221.11,142.44 221.11,143.83 PR168.2
PWR_VDDQ_VDD: length 7.7
  TOP w0.203: PU29.12 221.48,140.1 220.7,139.32 219.68,139.32 219.62,139.26
  TOP w0.508: v3(215.67,138.94) 215.94,139.2 PR164.1 217.07,139.2 217.12,139.26 PC186.1 219.62,139.26
PWR_VDDQ_VDDQ: length 53.9
  TOP w0.203: PR170.1 226.69,142.84 226.69,140.72 226.48,140.5 PU29.5
  TOP w0.508: v1(217.42,133.26) 217.17,133.01 217.17,130.18 215.77,128.78 215.77,119.46 220.7,114.53 220.7,107.72 222.33,106.1 PG77.1 ; PR170.1 227.23,143.37 227.23,144.02 PC192.1 v1(228.15,144.03)
  BOTTOM w0.508: v1(228.15,144.03) 225.48,141.35 222.51,141.35 220.01,138.85 v2(220.01,135.79) 219.95,135.79 v1(217.42,133.26)
PWR_VDDQ_VID: length 4.1
  TOP w0.203: 222.16,140.72 222.38,140.5 PU29.11
  TOP w0.508: 222.16,140.72 v3(221.15,140.72) 220.85,140.72 220.47,141.1 PC179.1 PR163.1
PWR_VDDQ_VLDOIN: length 2.8
  TOP w0.203: PU29.19 224.81,137.55 225.92,136.44
  TOP w0.254: PG72.2 226.62,135.2 226.57,135.25 ; PG74.2 227.38,135.2 227.33,135.25
  vias: v3(226.82,135.97)
PWR_VDDQ_VTT: length 3.7
  TOP w0.203: 227.71,138.56 227.2,139.06 226.82,139.06 226.59,139.3 PU29.2 ; PU29.20 225.83,138.15 ; 228.4,137.01 PG80.2 PG82.2 229.16,137.03
  vias: v3(228.85,138.18)
PWR_VDDQ_VTTREF: length 5.6
  TOP w0.203: 227.33,140.84 226.59,140.1 PU29.4
  TOP w0.254: 227.33,140.84 227.33,142.11 228.14,142.93 PC195.1 228.26,143.12 v3(229.11,143.97)
PWR_VGA_PG: length 11.1
  TOP w0.203: 111.05,145.81 111.05,146.32 111.26,146.54 PU39.12
  TOP w0.254: 111.05,145.81 110.17,144.93 109.66,144.93 108.72,144 108.6,144 PR344.2 108.35,143.72 PR345.1 108.66,142.36 108.66,141.28 108.13,140.75 v3(108.13,140.74) 107.95,140.74 107.3,140.74 PR419.2 106.6,141.45 106.6,142.09 106.34,142.34 PC507.1
PWR_VR_PG: length 4.5
  BOTTOM w0.203: 218.82,217.73 218.82,217.75 218.36,218.21 PU6.10
  BOTTOM w0.254: PR96.2 220.17,216.81 v2(219.48,217.5) 219.05,217.5 218.82,217.73
PWR_VSSDDC_SENSE_A: length 7.1
  TOP w0.203: v1(116.15,152.83) 116.2,152.79 PU39.39
  TOP w0.254: PR254.1 118.42,153.78 PR256.1 117.25,154.11 PC287.2 117.04,153.72 v1(116.15,152.83)
  BOTTOM w0.254: v1(116.15,152.83) 116.15,152.73 116.11,152.68 v2(116.11,151.89) PC290.1
PWR_VSSDDCI_SENSE_A: length 10.4
  TOP w0.203: PU39.24 117,145.13 117.73,144.4
  TOP w0.254: 117.73,144.4 118.62,143.51 v1(118.85,143.51) 119.25,143.1 119.25,142.24 PC295.2 119.67,141.82 119.74,141.82 120,141.57 PR263.2 120.98,140.88 PR264.1
  BOTTOM w0.254: PC297.1 117.17,144.96 117.84,144.28 v5(117.87,144.28) 117.87,144.26 118.62,143.51 v1(118.85,143.51)
PWR_VSUM_1: length 17.9
  TOP w0.254: PR113.2 203.59,206.84 204.29,207.54 v1(204.57,207.54)
  L6 w0.254: v1(217.3,210.85) 217.02,210.85 216.94,210.77 216.66,210.77 215.57,209.68 207.85,209.68 205.71,207.54 v1(204.57,207.54)
  BOTTOM w0.254: v1(217.3,210.85) 217.07,211.07 v5(216.28,211.07) 215.77,211.58 PR109.2
PWR_VTT_EN: length 7
  TOP w0.203: PU29.7 224.81,141.95 225.13,142.27
  TOP w0.254: 225.13,142.27 225.3,142.44 225.3,144.59 226.73,146.02 v3(227.2,146.02) 227.24,146.06 PR174.2
PWR_VTT_EN_R: length 4
  TOP w0.254: R396.2 C464.1 229.1,148.15 229.49,147.75 v3(229.49,147.45) 229.49,147.35 229.16,147.02 PR174.1
PWRBTN_N: length 215.4
  TOP w0.114: R452.2 11.67,135.33 C518.1 12.96,136.28 v1(13.43,136.75)
  L3 w0.114: v1(13.43,136.75) 10.48,133.8 10.46,133.8 6.52,129.86 6.52,118.1 14.05,110.57 24.84,110.57 25.98,109.43 78.73,109.43 86.85,101.31 86.85,97.13 86.61,96.9 86.61,85.14 84.26,82.78 84.26,55.1 92.26,47.1 93.56,47.1 94.1,47.64 96.54,47.64 97.62,48.72 105.31,48.72 106.79,50.2 112.94,50.2 115.09,48.06 118.59,48.06 119.13,47.52 121.51,47.52 123.34,49.35 124.51,49.35 124.95,49.8 124.95,51.53 124.1,52.37 v1(124.1,53.26)
  BOTTOM w0.114: v1(124.1,53.26) 124.16,53.32 124.16,54.91 123.27,55.8 121.86,55.8 R2432.1 ; v2(13.74,135.94) 13.74,136.44 v1(13.43,136.75)
PWRBTN_N_R: length 6.8
  BOTTOM w0.114: v2(122.81,56.59) 122.68,56.46 121.65,56.46 R2432.2 121.64,57.07 121.7,57.14 R2470.2 121.13,57.86 121.07,57.8 120.69,57.8 120.42,58.08 120.42,58.1 119.56,58.95 C1017.1 119.2,59.04 R237.1
PWRCN_DET_EC: length 209.3
  TOP w0.114: KBC1.72 114.16,49.74 113.56,49.15 113.56,48.84 v1(113.51,48.79) ; v1(11.99,140.36) 11.86,140.49 v3(10.88,140.49) 9.59,140.49 R2495.1 9.33,140.47 7.61,138.75 OSDC1.1
  L3 w0.114: v1(11.99,140.36) 11.99,139.98 11.85,139.84 11.85,137.13 5.26,130.55 5.26,117.46 13.41,109.31 24.14,109.31 25.28,108.17 78.19,108.17 84.86,101.5 84.86,99.83 85.27,99.42 85.27,85.57 82.99,83.3 82.99,80.73 82.8,80.54 82.8,55.5 82.55,55.24 82.55,52.46 89.37,45.64 93.54,45.64 93.83,45.93 93.83,46.19 94.43,46.79 96.98,46.79 97.31,47.12 100.61,47.12 100.95,46.78 102.1,46.78 102.69,47.37 104.11,47.37 104.52,47.78 105.18,47.78 105.38,47.98 105.38,48.18 106.98,49.78 111.8,49.78 112.79,48.79 v1(113.51,48.79)
PWRGD_3V_N: length 2.7
  BOTTOM w0.114: R232.1 106.73,51.03 v2(106.93,50.83) 106.93,50.2 Q14.G
PX_EN: length 39.7
  TOP w0.114: R1200.1 107.09,207.19 v1(107.21,207.31) 107.8,206.73 R476.1 107.8,205.6 C592.1 ; v6(85.55,184.8) 85.55,184.65 GPU1.V40
  L3 w0.114: v6(85.55,184.8) 85.55,185.42 85.96,185.83 85.96,187.31 88.99,190.33 88.99,195.03 95.78,201.82 101.24,201.82 106.73,207.31 v1(107.21,207.31)
  BOTTOM w0.114: v2(107.57,206.5) 107.57,206.96 v1(107.21,207.31)
PX_EN_G: length 6
  TOP w0.114: Q55.G 103.71,203.13 104.04,203.45 v3(104.04,203.48) R1201.2 104.25,204.46 104.9,205.1 104.9,206.69 R1200.2
PX_ENB: length 8.9
  TOP w0.114: v1(104.72,202.92) 105.55,203.75 R1198.1 105.71,204.25 R1197.2 ; v1(101.96,204.11) Q55.D 99.48,204.11 C952.1
  BOTTOM w0.114: v1(104.72,202.92) 103.54,202.92 v2(103.25,203.2) 102.34,204.11 v1(101.96,204.11)
RASA0B: length 34
  TOP w0.13: v6(103.71,197.99) 104.1,197.6 VRAMA1.G3 ; v6(80.65,188.4) 80.2,187.95 GPU1.P33
  BOTTOM w0.089: v6(80.65,188.4) 81.9,189.2 84.82,189.2 85.1,189.47 85.1,189.79
  BOTTOM w0.13: v6(103.71,197.99) 103.7,197.99 103.38,198.52 103.28,198.63 103.28,198.69 103.26,198.73 103.26,200.79 102.45,201.6 101.38,201.92 95.52,201.92 93.92,200.69 86.44,193.21 86,192.17 86,190.62 85.61,190.23 85.55,190.23 85.1,189.79
RASA1B: length 41.5
  TOP w0.13: VRAMA2.L3 v6(92.5,221.7) ; GPU1.M35 v6(82.25,189.6)
  BOTTOM w0.13: v6(92.5,221.7) 93.21,221.25 94.37,221.25 94.77,221.1 95.78,220.08 95.78,211.45 95.17,210.55 93.27,208.65 92.04,206.92 91.18,204.42 85.43,198.67 85.43,198.67 85.18,198.42 85.18,198.42 84.97,198.21 84.97,194.35 85.08,193.43 85.08,191.83 84.27,191.03 84.27,190.63 83.74,190.09 83.21,190.09 82.91,190.02 82.81,189.95 82.46,189.6 v6(82.25,189.6)
RASB0B: length 38
  TOP w0.13: GPU1.K20 67.75,191.45 v6(67.6,191.45) ; VRAMB1.G3 66,221.73 v6(66,221.7)
  BOTTOM w0.089: 67.26,197.2 67.21,197.15 67.21,196.18 67.23,196.16 67.23,195.74 67.2,195.72 67.2,191.99 67.6,191.59 v6(67.6,191.45)
  BOTTOM w0.13: 67.26,197.2 67.48,197.42 67.48,202.73 63.3,206.91 63.3,212.13 61.77,213.67 61.77,220.81 62.23,221.28 65.58,221.28 v6(66,221.7)
RASB1B: length 40
  TOP w0.13: GPU1.M20 67.75,189.85 v6(67.6,189.85) ; VRAMB2.L3 v6(55.5,221.7)
  BOTTOM w0.089: 66.54,197.62 66.54,196.58 67.04,196.08 67.04,195.82 67.01,195.79 67.01,190.37 67.53,189.85 v6(67.6,189.85)
  BOTTOM w0.13: v6(55.5,221.7) 56,221.2 58.82,221.2 60.48,219.54 60.48,213.41 62.1,211.79 62.1,207.12 66.67,202.55 66.67,199.91 66.54,199.78 66.54,197.62
RASC0B: length 40.1
  TOP w0.13: v6(60.15,182.4) 60.15,182.25 GPU1.Y12 ; v6(28.3,194.5) VRAMC1.G3
  BOTTOM w0.089: v6(60.15,182.4) 59.56,182.99 54.87,182.99 54.73,182.85 54.53,182.85
  BOTTOM w0.13: 54.53,182.85 51.71,182.85 51.14,183.42 50.18,183.42 50.09,183.33 47.45,183.33 42.88,187.9 39.88,187.9 38.22,189.55 30.41,189.55 28.8,191.17 28.8,192.7 28.8,192.7 28.8,194 v6(28.3,194.5)
RASC1B: length 37.6
  TOP w0.13: v6(58.55,182.4) 58.55,182.25 GPU1.Y10 ; v6(28.3,184) VRAMC2.L3
  BOTTOM w0.089: v6(58.55,182.4) 58.15,182.8 55.01,182.8 54.73,182.52 54.59,182.52
  BOTTOM w0.13: v6(28.3,184) 28.76,184.46 28.76,185.9 28.58,186.08 28.58,186.8 29.97,188.19 36.38,188.19 37.87,186.7 43.09,186.7 47.27,182.52 54.59,182.52
RASD0B: length 41.6
  TOP w0.13: GPU1.AR12 60.4,167.75 v6(60.35,167.75) ; VRAMD1.G3 v6(28.3,157.5)
  BOTTOM w0.089: 58.19,165.74 59.02,166.57 59.42,166.57 59.64,166.79 59.64,167.26 60.12,167.74 60.34,167.74 v6(60.35,167.75)
  BOTTOM w0.1: 58.19,165.74 57.86,165.74
  BOTTOM w0.13: 57.86,165.74 57.35,165.86 56.62,165.81 56.17,165.57 55.95,165.52 53.61,165.06 51.62,164.82 51.58,164.82 51.33,164.57 51.33,164.57 51.11,164.35 49.29,163.04 45.11,158.86 43.08,157.96 41.17,156.55 39.06,154.44 37.5,153.46 31,153.46 29.57,154.01 28.75,154.83 28.75,156.8 v6(28.3,157.5)
RASD1B: length 33.8
  TOP w0.13: GPU1.AN14 62.16,169.8 62.05,169.69 v6(61.6,169.35) ; VRAMD2.L3 v6(52,146.3)
  BOTTOM w0.089: v6(61.6,169.35) 61,168.45 61,167.5 60.8,166.87 60.8,165.98 60.59,165.76 60.58,165.76 60.57,165.75 60.2,165.75 60.04,165.59
  BOTTOM w0.13: 60.04,165.59 59.35,164.9 59.05,164.9 58.15,164 57.35,164 51.89,158.55 51.78,158.55 47.98,154.74 47.98,148.07 49.21,146.84 51.46,146.84 v6(52,146.3)
RDISPLAY1_DET_EC: length 38.6
  TOP w0.114: v1(113.25,56.96) KBC1.105 ; v1(93.33,55.83) 92.38,55.83 92.2,56.01 87.21,56.01 R2481.1 85.95,55.89 v3(85.95,56.97) 85.95,58.47 85.39,59.03 84.94,59.03 84.91,59.05 84.58,59.05 84.39,59.25 DISPC1.1
  L3 w0.114: v1(113.25,56.96) 113.15,57.05 111.59,57.05 111.56,57.02 108.25,57.02 107.37,56.13 106.91,56.13 106.39,55.62 103.08,55.62 102.78,55.92 99.83,55.92 98.79,56.95 94.06,56.95 93.33,56.22 v1(93.33,55.83)
RDISPLAY2_DET_EC: length 206.8
  TOP w0.114: v1(84.2,54.36) 84.33,54.36 86.06,52.63 88.54,52.63 88.75,52.83 v1(93.42,52.83) ; R2580.2 12.82,144.74 12.04,144.74 11.21,143.92 v3(10.92,143.92) v1(8.1,143.92) 7.9,144.12 7.9,145.85 7.5,146.25 DISPC2.1 ; KBC1.63 116.05,46.77 115.59,47.22 114.4,47.22 113.05,48.58 113.05,49.4 v1(114.38,50.72)
  L3 w0.114: v1(114.38,50.72) 114.83,50.72 115.3,51.19 115.3,51.58 114.07,52.8 111.04,52.8 110.56,52.32 109,52.32 108.29,53.03 106.41,53.03 105.73,53.7 102.3,53.7 102.03,53.98 98.68,53.98 97.99,53.29 94.21,53.29 94.03,53.11 93.7,53.11 v1(93.42,52.83)
  L6 w0.102: v1(84.2,54.36) 83.43,54.36 80.8,56.99 80.8,104.5 79.45,105.84 78.9,105.84 26.31,105.84 23.88,108.28 19.58,108.28 8.1,119.76 v1(8.1,143.92)
RING2_CON: length 31.5
  TOP w0.61: v4(232.11,34.5) SUSBC1.21 ; v4(232.08,35.64) 232.22,35.5 SUSBC1.23
  L6 w1.016: 210.95,51.31 210.95,49.91 213.08,47.78 219.63,47.78 231.64,35.77
  vias: v4(210.19,53.21) v4(210.19,52.07) v5(206.63,52.45)
RLAN_AUDIO_DET_EC: length 124.6
  TOP w0.114: v1(110.19,54.41) 111.24,55.46 111.24,56.63 112.45,57.84 KBC1.107 ; R2483.1 146.94,5.52 v3(146.94,6.6) 145.08,6.6 v1(143.59,8.1) 143.46,8.1 142.75,7.39 LAUOC1.40
  L4 w0.114: v1(110.19,54.41) 110.54,54.05 110.54,52.98 109.65,52.1 109.65,50.37 107.54,48.26 105.82,48.26 103.95,46.4 103.95,45 102.88,43.93 102.27,43.93 102.25,43.95 100.72,43.95 99.13,42.36 99.13,40.33 96.96,38.16 96.96,36.31 96.5,35.85 95.14,35.85 93.3,34.02 93.3,19.43 93.88,18.86 93.88,13.57 93.01,12.71 93.01,10.23 97.91,5.33 109.17,5.33 110.06,4.45 114.41,4.45 114.49,4.52 123.46,4.52 124.2,5.26 142.29,5.26 143.59,6.55 v1(143.59,8.1)
RPWR_CN1_DET_EC: length 92
  TOP w0.114: v1(165.61,11.81) 165.61,12.86 166.36,13.62 166.85,13.62 167.28,13.18 167.28,12.42 168.19,11.51 168.54,11.51 169.5,10.55 RPWRC1.1 ; v1(111.21,47.73) 111.21,47.01 111.65,46.57 KBC1.52
  L6 w0.102: v1(165.61,11.81) 165.74,11.94 165.74,14.55 165,15.29 162.26,15.29 159.33,18.21 159.33,24.78 151.71,32.4 148.6,32.4 148.16,32.84 144.12,32.84 141.94,35.03 141.94,37.54 140.39,39.09 139.93,39.09 133.88,45.14 113.8,45.14 v1(111.21,47.73)
  BOTTOM w0.114: v1(165.61,11.81) 165.35,12.07 165.35,12.07 165.22,12.19 v2(164.59,12.19) 164.34,11.94 R2485.1
RSMRST#_CPU: length 44.2
  TOP w0.114: CPU1.AP5 v6(155.5,178.5) ; Q72.6 131.59,153.91 131.97,154.29 R368.2 135.29,153.17 137.39,153.17 v3(137.67,153.44) 138.58,153.44 v1(139.06,153.92)
  L4 w0.114: v6(155.5,178.5) 155.01,178.99 153.37,178.99 152.35,177.97 152.35,177.62 151.51,176.78 151.51,176.15 150.24,174.88 147.73,174.88 146.18,173.33 146.18,171.45 144.27,169.54 144.27,164.95 139.55,160.22 139.55,156.52 139.51,156.49 139.51,154.37 v1(139.06,153.92)
RSMRST_H: length 4.4
  TOP w0.114: v3(128.98,155.52) Q72.3 130.29,156.79 R2715.2 130.94,156.45 Q72.2
RSMRST_SIO_N: length 184.9
  TOP w0.114: v1(132.99,153.77) 132.21,152.98 132.21,152.27 130.63,150.7 129.62,150.7 129.35,150.96 R369.1 129.34,151.32 R2716.1 127.83,151.78 127.83,152.67 127.94,152.78 R2717.2 ; v1(104.88,52.1) 104.39,51.61 103.56,51.61 103.42,51.75 KBC1.20
  L3 w0.114: v1(137.39,98.35) 137.39,97.92 139.06,96.25 139.06,95.01 139.57,94.49 139.57,87.38 147.09,79.86 155.84,79.86 157.35,81.38 v1(157.35,81.64)
  L4 w0.114: v1(132.99,153.77) 133.15,153.77 133.84,153.08 133.84,152.63 132.8,151.6 132.8,133.33 132.38,132.91 130.28,130.81 130.28,121.09 129.79,120.61 129.79,111.12 129.89,111.03 129.89,109.91 130.21,109.59 130.21,106.44 132.28,104.37 134.72,104.37 136.14,102.95 136.14,101.52 137.39,100.28 v1(137.39,98.35)
  L6 w0.102: v1(104.88,52.1) 104.42,52.55 103.76,52.55 102.51,53.8 102.51,59.5 106.79,63.78 110.11,63.78 110.41,64.08 110.41,65.56 109.93,66.04 109.93,66.92 110.17,67.16 111.87,68.86 118.34,68.86 118.77,69.29 122.61,69.29 v1(123.75,70.43)
  BOTTOM w0.114: v1(157.35,81.64) 157.35,80.77 v5(156.74,80.16) 156.03,79.45 154.26,79.45 148.47,73.66 127.94,73.66 125.02,70.74 124.05,70.74 v1(123.75,70.43)
RSMRST_SIO_R: length 3.5
  TOP w0.114: Q72.5 130.94,153.29 131.24,152.98 v3(131.24,152.27) 130.26,152.27 C440.1 R369.2
RST#_CPU: length 42
  TOP w0.114: v6(188.47,167.46) 188.46,167.46 CPU1.B16 ; v1(211.21,149.42) 211.18,149.45 211.18,150.19 v3(212.15,151.16) 212.73,151.75 214.37,151.75 215.2,150.91 R18.2 216.55,152.25 HDT1.12
  L6 w0.102: v6(188.47,167.46) 188.95,167.94 190.69,167.94 191.44,167.19 193.26,167.19 193.8,166.65 193.8,166.46 194.07,166.19 194.36,166.19 205.66,154.89 205.66,154.88 205.93,154.61 206.81,154.61 209.45,151.97 209.45,151.43 210.21,150.67 210.62,150.67 211.13,150.16 211.13,149.5 v1(211.21,149.42)
RTC_DET#: length 109.2
  TOP w0.114: Q16.D 180.97,27.1 179.3,25.43 178.61,25.43 178.16,24.97 177.75,24.97 177.24,25.48 170.71,25.48 167.84,28.35 159.99,28.35 159.08,27.43 v1(158.5,27.43) ; KBC1.17 101.59,52.95 101.45,53.09 v1(101.21,53.09)
  L6 w0.102: v1(158.5,27.43) 158.27,27.43 153.24,32.46 152.53,32.46 151.64,33.35 144.36,33.35 143.15,34.55 143.15,37.26 143.54,37.64 143.54,38.14 142.18,39.5 140.13,39.5 134.06,45.57 114.89,45.57 112.22,48.23 111.06,48.23 110.69,47.87 110.69,46.48 109.6,45.39 103.46,45.39 101.63,47.22 101.63,52.67 v1(101.21,53.09)
  BOTTOM w0.114: v1(101.21,53.09) 100.9,53.39 v2(99.68,53.39) 99.36,53.39 99.04,53.07 RN44.2
RTYPEC_DET_EC: length 73
  TOP w0.114: KBC1.106 112.85,57.65 111.58,56.39 111.58,55.02 v1(110.97,54.41) ; v1(112.88,8.15) 112.85,8.13 112.85,7.57 112.75,7.47 TYPEC1.1
  L4 w0.114: v1(100.71,39.34) 100.71,42.76 101.06,43.1 101.76,43.1 101.79,43.08 102.97,43.08 102.98,43.09 103.37,43.09 104.89,44.61 104.89,45 110.08,50.19 110.08,51.92 110.96,52.79 110.96,54.39 v1(110.97,54.41)
  L6 w0.102: v1(100.71,39.34) 100.66,39.29 100.66,38.1 99.52,36.96 99.52,36.28 97.89,34.65 97.89,26.26 98.76,25.4 98.76,23.39 97.59,22.23 97.59,20.21 100.23,17.57 100.23,17.06 108.65,8.64 112.39,8.64 v1(112.88,8.15)
  BOTTOM w0.114: v5(99.87,39.32) 99.9,39.34 v1(100.71,39.34) ; R2482.1 113.3,8.57 v1(112.88,8.15)
RUSB3_DET_EC: length 46.1
  TOP w0.114: v1(86.64,30.86) 86.46,30.68 R2484.1 84.67,32.45 83.95,33.17 RUSBC1.1 ; KBC1.59 114.45,46.12 112.28,48.29 109.88,48.29 109.61,48.55 v1(109.61,48.58)
  L3 w0.114: v1(97.8,35.85) 97,35.05 92.05,35.05 87.99,30.99 86.77,30.99 v1(86.64,30.86)
  L4 w0.114: v1(97.8,35.85) 98.53,35.85 99.07,36.38 99.07,36.76 99.77,37.47 100.3,37.47 104.23,41.39 104.23,42.2 105.23,43.21 105.23,44.36 105.31,44.43 105.31,44.82 108.85,48.36 109.32,48.36 109.54,48.58 v1(109.61,48.58)
  BOTTOM w0.114: v1(97.8,35.85) 97.41,36.24 v5(97.41,36.83)
S5_ENABLE: length 44.1
  TOP w0.114: v1(107.72,55.8) 107.59,55.67 106.57,55.67 105.33,54.43 103.61,54.43 103.32,54.14 KBC1.14 ; v1(100.03,71.5) 99.64,71.88 97.97,71.88 96.63,73.22 Q10.D 96.63,75.88 96.49,76.02 96.49,76.8 R199.2
  L4 w0.114: v1(100.03,71.5) 99.61,71.08 99.61,68.59 101.18,67.02 101.18,65.52 107.26,59.44 107.26,58.75 107.59,58.43 107.59,57 107.72,56.87 v1(107.72,55.8)
  BOTTOM w0.114: R179.2 113.51,58.6 111.63,58.6 110.6,57.57 110.6,56.63 v2(110.44,56.46) 109.83,55.85 109.25,55.85 108.97,55.58 107.95,55.58 v1(107.72,55.8)
S5_MUX_APU: length 56.8
  TOP w0.114: CPU1.AP4 v6(155.5,179.53) ; U17.6 131.25,201.76 130.86,201.37 130.16,201.37 129.98,201.55 129.76,201.77 129.76,202.47 129.35,202.88 R379.2 127.95,202.88 v1(127.89,202.95)
  L4 w0.114: v1(140.61,189.97) 143.02,192.37 143.02,195.91 140.35,198.59 140.35,199.87 140.92,200.44 140.92,201.17 140.67,201.42 139.96,201.42 139.85,201.31 130.05,201.31 129.99,201.38 129.78,201.38 128.22,202.95 v1(127.89,202.95)
  L6 w0.102: v6(155.5,179.53) 155.85,179.89 155.85,180.92 154.88,181.9 154.88,185.68 152.78,187.78 142.76,187.78 141.94,188.6 141.44,189.09 141.43,189.09 140.61,189.91 v1(140.61,189.97)
  BOTTOM w0.114: v2(128.8,203.23) 128.17,203.23 v1(127.89,202.95)
SA0_DIMM1: length 7.6
  TOP w0.114: v1(147.42,109.63) 149.09,107.96 149.38,107.96 149.62,107.71 DIMM1.256
  BOTTOM w0.114: v1(147.42,109.63) 147.32,109.63 147.08,109.87 R102.2 146.33,110.49 146,110.82 v2(145.82,110.82) 145.62,110.82 145.26,110.46 R98.1
SA0_DIMM2: length 16.2
  TOP w0.114: R111.1 161.61,85.47 R114.2 161.61,87.01 161.49,87.12 v3(159.64,87.12) 159.51,87.12 157.61,89.02 156.27,89.02 156.26,89.03 151.18,89.03 149.61,90.6 149.61,91.68 DIMM2.256
SA1_DIMM1: length 5
  TOP w0.114: v1(147.42,107.04) 147.56,106.9 DIMM1.260
  BOTTOM w0.114: v1(147.42,107.04) 147.19,107.04 147.13,106.97 R103.2 146.3,106.35 146.02,106.07 v2(145.85,106.07) 145.41,106.07 145.21,106.27 R99.1
SA1_DIMM2: length 14.6
  TOP w0.114: DIMM2.260 148.62,90.39 149.34,89.67 150.03,89.67 151.03,88.67 156.69,88.67 v3(158.12,87.25) R115.2 R112.1
SA2_DIMM1: length 5.7
  TOP w0.114: DIMM1.166 172.12,105.7 v6(171.87,105.45)
  BOTTOM w0.114: v6(171.87,105.45) 172.18,105.13 R100.1 172.7,106.07 173,106.38 v2(173.33,106.38) 173.5,106.38 173.76,106.12 R104.2
SA2_DIMM2: length 7.3
  TOP w0.114: DIMM2.166 172.12,86.84 R113.1 v3(170.84,86.68) R116.2
SATA__RXN0_C: length 16.7
  TOP w0.102: 91.71,91.61 93.06,90.25 93.06,90.11 93.27,89.9 93.41,89.9 94.16,89.15 94.16,88.3 95.41,87.05 95.62,87.05 C473.2 ; 91.71,91.61 v3(91.44,91.34) ; 91.71,91.61 89.52,93.79 84.24,93.79 HDD1.5
SATA__RXP0_C: length 16.6
  TOP w0.102: HDD1.6 84.24,94.02 89.62,94.02 94.18,89.46 ; 94.18,89.46 94.39,89.25 94.39,88.4 95.51,87.27 95.77,87.27 C474.2 ; 94.18,89.46 v3(94.46,89.74)
SATA__TXN0_C: length 20
  TOP w0.102: C472.2 99.3,82.93 98.77,82.93 96.4,85.3 94.66,87.05 92.66,87.05 ; 92.66,87.05 v3(92.66,87.43) ; 92.66,87.05 92.15,87.05 88.99,90.21 84.24,90.21 HDD1.3
SATA__TXP0_C: length 20
  TOP w0.102: HDD1.2 84.24,89.98 88.89,89.98 89.79,89.08 ; 89.79,89.08 v3(89.51,88.8) ; 89.79,89.08 92.06,86.82 94.56,86.82 97.57,83.81 98.68,82.7 99.3,82.7 C471.2
SATA_RXN0_C_N: length 8.6
  TOP w0.102: L26.1 103.24,85.49 103.02,85.71 102.49,85.71 101.49,84.71 99.28,84.71 98.84,85.15 ; v3(98.58,84.89) 98.84,85.15 ; 98.84,85.15 98.49,85.5 98.35,85.5 98.13,85.71 98.13,85.85 97.92,86.07 97.78,86.07 97.56,86.28 97.56,86.42 97.34,86.64 C473.1
SATA_RXP0_C_N: length 8.8
  TOP w0.102: 101.93,85.47 101.4,84.94 99.37,84.94 97.43,86.87 97.43,87.01 C474.1 ; 101.93,85.47 v3(101.65,85.75) ; 101.93,85.47 102.4,85.94 103,85.94 103.22,86.17 L26.4
SATA_TXN0_C_N: length 5.8
  TOP w0.102: 103.89,83.76 104.66,83.76 104.89,83.98 L25.4 ; 103.89,83.76 v3(103.89,84.12) ; 103.89,83.76 101.95,83.76 101.12,82.93 100.85,82.93 C472.1
SATA_TXP0_C_N: length 5.9
  TOP w0.102: 101.55,83.03 102.04,83.53 104.66,83.53 104.89,83.3 L25.1 ; 101.55,83.03 101.22,82.7 100.85,82.7 C471.1 ; 101.55,83.03 v3(101.83,82.75)
SATA_ZVDDP: length 8.2
  TOP w0.114: CPU1.AV7 151.42,176.58 148.59,176.58 v6(148.46,176.71)
  BOTTOM w0.114: v6(148.46,176.71) 147.85,176.71 147.52,176.37 147.52,175.8 148.23,175.08 v2(148.23,175.01) 148.23,174.8 147.88,174.45 R2.2
SATA_ZVSS: length 1.7
  TOP w0.114: CPU1.AV6 v6(152.53,176.46)
  BOTTOM w0.114: v6(152.53,176.46) 152.59,176.51 R6.1
SATAHDR_RX_DN0: length 80.2
  TOP w0.102: L26.2 105.45,85.49 105.69,85.72 105.96,85.72 v1(106.3,85.38) ; PCH1.D15 v6(161.8,53)
  L4 w0.102: v6(161.8,53) 161.51,52.71 161.22,52.71 160.2,53.74 160.2,54.72 160.32,54.84 160.32,55.15 160.2,55.27 160.2,55.58 157.71,58.06 151.51,58.06 149.28,60.3 132.53,60.3 129.41,63.42 126.37,63.42 126.27,63.52 125.97,63.52 125.87,63.42 125.57,63.42 125.47,63.52 125.16,63.52 125.06,63.42 124.76,63.42 124.66,63.52 124.35,63.52 124.26,63.42 120.33,63.42 114.63,69.12 114.63,75.87 111.04,79.46 111.04,79.61 110.82,79.82 110.68,79.82 110.46,80.04 110.46,80.18 110.25,80.39 110.11,80.39 109.89,80.61 109.89,80.75 109.68,80.96 109.54,80.96 109.09,81.41 107.31,81.41 105.59,83.13 105.59,84.16 105.69,84.26 105.69,84.56 105.59,84.66 105.59,85.64 105.68,85.73 105.95,85.73 v1(106.3,85.38)
SATAHDR_RX_DP0: length 80.3
  TOP w0.102: PCH1.E15 v6(161.8,52.2) ; L26.3 105.45,86.17 105.66,85.95 105.96,85.95 v1(106.3,86.3)
  L4 w0.102: v6(161.8,52.2) 161.51,52.49 161.13,52.49 159.97,53.64 159.97,55.48 157.61,57.84 151.42,57.84 149.18,60.07 132.44,60.07 129.31,63.2 120.24,63.2 114.4,69.03 114.4,75.78 109,81.18 107.22,81.18 105.36,83.04 105.36,85.73 105.59,85.96 105.96,85.96 v1(106.3,86.3)
SATAHDR_TX_DN0: length 76.1
  TOP w0.102: v1(108.08,84.06) 107.77,83.76 107.43,83.76 107.2,83.98 L25.3 ; PCH1.B15 v6(161.8,54.6)
  L4 w0.102: v6(161.8,54.6) 161.8,54.66 162.05,54.91 162.38,54.91 162.79,55.32 162.79,56.44 162.38,56.85 160.85,56.85 158.41,59.28 151.71,59.28 149.68,61.32 133.83,61.32 130.27,64.87 120.07,64.87 115.75,69.2 115.75,78.26 110.24,83.77 108.37,83.77 v1(108.08,84.06)
SATAHDR_TX_DP0: length 76
  TOP w0.102: L25.2 107.2,83.3 107.43,83.53 107.7,83.53 v1(108.08,83.15) ; PCH1.A15 v6(161.8,55.4)
  L4 w0.102: v1(108.08,83.15) 108.47,83.54 110.14,83.54 110.36,83.32 110.36,83.19 110.57,82.97 110.71,82.97 110.93,82.75 110.93,82.61 111.14,82.4 111.28,82.4 111.5,82.18 111.5,82.04 111.71,81.83 111.85,81.83 115.52,78.16 115.52,69.1 119.98,64.64 130.18,64.64 133.73,61.09 149.59,61.09 151.62,59.05 152.13,59.05 152.26,58.93 152.56,58.93 152.69,59.05 158.32,59.05 159.04,58.33 159.04,58.19 159.26,57.97 159.4,57.97 159.61,57.76 159.61,57.62 159.83,57.4 159.97,57.4 160.18,57.19 160.18,57.05 160.4,56.83 160.54,56.83 160.76,56.62 162.29,56.62 162.56,56.34 162.56,55.42 162.29,55.14 162,55.14 161.8,55.35 v6(161.8,55.4)
SATASSD_RX_DN1: length 77.7
  TOP w0.102: U26.14 120.66,95.24 120.8,95.1 120.8,94.68 120.5,94.38 120.5,93.63 121.13,93 121.13,91.93 121.34,91.72 123.01,90.05 123.01,88.6 ; v1(124.16,87.05) 123.85,87.35 123.37,87.35 123.01,87.71 123.01,88.6 ; v3(122.63,88.6) 123.01,88.6 ; PCH1.D16 v6(163.4,52.2)
  L4 w0.102: v1(124.16,87.05) 123.84,87.36 123.51,87.36 123.27,87.12 123.27,83.99 126.74,80.52 126.74,80.05 134.5,72.29 134.64,72.29 134.86,72.07 134.86,71.93 135.07,71.71 135.22,71.71 135.43,71.5 135.43,71.36 135.65,71.14 135.79,71.14 136.01,70.92 136.01,70.78 141.32,65.46 150.52,65.46 151.27,66.22 159.66,66.22 165.07,60.8 165.07,55.35 163.22,53.49 163.22,52.38 v6(163.4,52.2)
SATASSD_RX_DP1: length 77.7
  TOP w0.102: U26.15 121.16,95.23 121.03,95.09 121.03,94.59 120.73,94.28 120.73,93.73 121.36,93.09 121.36,92.02 122.4,90.98 ; 122.4,90.98 123.24,90.14 123.24,87.8 123.46,87.58 123.83,87.58 v1(124.21,87.96) ; 122.4,90.98 v3(122.68,91.26) ; PCH1.E16 v6(162.6,52.2)
  L4 w0.102: v6(162.6,52.2) 162.99,52.59 162.99,53.59 164.85,55.44 164.85,60.71 159.56,65.99 151.37,65.99 150.61,65.24 141.23,65.24 126.51,79.96 126.51,80.43 123.04,83.9 123.04,87.21 123.42,87.59 123.84,87.59 v1(124.21,87.96)
SATASSD_TX_DN1: length 69
  TOP w0.102: v3(119.74,89.1) 120.12,89.1 ; 120.12,89.1 120.12,87.34 119.87,87.1 119.71,87.1 v1(119.35,87.45) ; 120.12,89.1 120.12,89.93 C514.1 ; v6(163.37,54.61) 163,54.24 PCH1.B16
  L4 w0.102: v6(163.37,54.61) 163.45,54.61 164.21,55.37 164.21,60.45 159.28,65.38 151.62,65.38 150.6,64.36 141.24,64.36 135.64,69.96 125.83,79.77 125.83,80.23 122.3,83.76 122.3,84.86 120.05,87.11 119.7,87.11 v1(119.35,87.45)
SATASSD_TX_DN1_C: length 5
  TOP w0.102: U26.12 119.66,95.22 119.84,95.05 119.84,94.81 119.58,94.56 119.58,92.74 120.14,92.18 120.14,91.5 C514.2
SATASSD_TX_DP1: length 69
  TOP w0.102: v6(163.4,55.55) 163.4,55.38 163.02,55 PCH1.A16 ; v3(120.75,87.99) 120.35,87.99 ; 120.35,87.99 120.35,87.25 119.96,86.87 119.68,86.87 v1(119.35,86.54) ; 120.35,87.99 120.35,89.93 C513.1
  L4 w0.102: v1(119.35,86.54) 119.7,86.88 119.96,86.88 122.07,84.77 122.07,83.67 125.6,80.14 125.6,79.68 135.48,69.79 141.15,64.13 150.69,64.13 151.71,65.15 159.19,65.15 162.26,62.08 162.26,61.94 162.47,61.72 162.62,61.72 162.83,61.51 162.83,61.36 163.05,61.15 163.19,61.15 163.41,60.93 163.41,60.79 163.62,60.57 163.77,60.57 163.98,60.36 163.98,55.47 163.8,55.29 163.66,55.29 v6(163.4,55.55)
SATASSD_TX_DP1_C: length 5.4
  TOP w0.102: C513.2 120.66,91.15 120.37,91.44 120.37,92.28 120.22,92.43 ; 120.22,92.43 119.81,92.84 119.81,94.46 120.07,94.72 120.07,95.12 120.16,95.22 U26.13 ; 120.22,92.43 v3(120.5,92.71)
SDCARD_DET_EC: length 236
  TOP w0.114: KBC1.28 103.48,48.54 103.54,48.6 104.55,48.6 v1(104.9,48.25) ; SDRDC1.1 227.92,12.9 226.77,14.05 v1(225.41,14.05)
  L3 w0.114: v1(225.41,14.05) 225.8,14.05 225.91,13.94 227.22,13.94 227.89,13.27 227.89,8.78 221.94,2.83 221.65,2.83 221.64,2.82 184.66,2.82 184.6,2.88 173.68,2.88 170.69,5.87 170.69,10.41 v1(169.93,11.18)
  L6 w0.102: v1(169.93,11.18) 169.54,11.56 169.54,16.28 168.78,17.04 168.78,20.94 175.34,27.5 175.34,36.76 176.94,38.36 176.94,43.14 179.12,45.32 179.12,55.68 180.01,56.57 181.71,56.57 182.27,57.12 182.27,66.36 179.34,69.29 163.84,69.29 163.59,69.04 148.41,69.04 147.67,68.3 137.1,68.3 136.76,68.3 131.38,62.92 127.4,62.92 126.09,61.61 125.88,61.61 121.89,57.62 121.89,57.33 120.35,55.78 118.49,55.78 117.35,54.64 114.9,54.64 113.87,53.61 113.87,52.53 112.12,50.77 110.21,50.77 109.55,50.11 107.26,50.11 105.41,48.26 104.91,48.26 v1(104.9,48.25)
  BOTTOM w0.114: v1(225.41,14.05) 225.18,14.05 223.88,12.75 222.11,12.75 v2(221.68,12.33) 221.68,11.62 221.68,11.62 R2491.1
SE_BJT_B1: length 17.2
  TOP w0.114: U20.5 205.12,147.86 204.75,148.23 203.76,148.23 202.9,147.37 202.9,143.64 205.59,140.94 209.14,140.94 209.65,141.45 v3(209.73,141.45) 211.02,142.75 R390.2
SE_BJT_B2: length 5.1
  TOP w0.114: R388.2 205.94,141.88 205.58,142.24 v3(205.58,142.32) 206.22,142.96 R392.1 206.77,142.97 C461.1 205.66,143.9 R391.2
SE_BJT_B3: length 3
  TOP w0.114: v3(203.46,143.99) 203.48,143.99 203.63,143.84 204.71,143.84 R391.1 204.75,144.32 205.12,144.7 U20.2
SE_VDDQ_EN: length 3.1
  TOP w0.114: R393.1 217.7,135.08 217.34,135.44 v3(217.23,135.44) 217.13,135.44 216.3,134.61 U21.4
SE_VPP_EN: length 7.4
  TOP w0.114: R389.1 209.78,149.08 208.52,147.81 Q23.C 210.21,147.48 v3(210.82,148.08) 212.12,148.08 212.64,147.56 RN17.3
SE_VPP_EN_B: length 9.8
  TOP w0.114: RN17.4 211.13,147 v3(210.77,146.63) 210.49,146.35 208.32,146.35 Q23.B 207.36,145.39 U20.3 205.77,145.4 205.77,146.25 205.56,146.46 204.72,146.46 204.47,146.71 U20.6
SEN_A0: length 3.5
  TOP w0.114: v6(102.1,192.43) 102.1,192.4 VRAMA1.J10
  BOTTOM w0.114: R678.1 103.45,193.46 103.45,192.27 103.21,192.03 102.5,192.03 v6(102.1,192.43)
SEN_A1: length 7
  TOP w0.114: VRAMA2.J10 86.87,220.13 v6(87,220.13)
  BOTTOM w0.114: R679.1 90.26,222.48 90.11,222.33 89.99,222.33 88.9,221.23 v2(88.39,221.23) 88.11,221.51 86.91,221.51 86.56,221.16 86.56,220.45 86.87,220.13 v6(87,220.13)
SEN_B0: length 4.9
  TOP w0.114: v6(71.54,220.15) 71.62,220.15 VRAMB1.J10
  BOTTOM w0.114: R640.1 70.1,221.07 v2(70.45,220.72) 70.67,220.72 71.34,221.4 71.83,221.4 71.97,221.25 71.97,220.59 v6(71.54,220.15)
SEN_B1: length 4.4
  TOP w0.114: v6(49.96,220.16) 49.88,220.16 49.54,220.5 VRAMB2.J10
  BOTTOM w0.114: v6(49.96,220.16) 49.55,220.57 49.55,221.18 49.88,221.52 50.64,221.52 R635.1 50.98,221.18 v2(50.98,220.31)
SEN_C0: length 4.4
  TOP w0.114: v6(29.9,200.03) 29.9,200.1 VRAMC1.J10
  BOTTOM w0.114: v6(29.9,200.03) 29.49,200.44 28.84,200.44 28.56,200.16 28.56,199.28 R682.1 28.85,198.98 v2(29.64,198.98)
SEN_C1: length 3.5
  TOP w0.114: VRAMC2.J10 29.87,178.37 v6(29.87,178.46)
  BOTTOM w0.114: R707.1 28.52,179.5 28.52,178.3 28.69,178.13 29.54,178.13 v6(29.87,178.46)
SEN_D0: length 4.3
  TOP w0.114: VRAMD1.J10 29.87,163.13 v6(29.87,163)
  BOTTOM w0.114: R634.1 28.32,162.17 28.44,162.29 v2(28.44,162.3) 28.57,162.43 28.57,163.17 28.87,163.47 29.39,163.47 v6(29.87,163)
SEN_D1: length 7.3
  TOP w0.114: VRAMD2.J10 57.65,147.85 v6(57.54,147.85)
  BOTTOM w0.114: v6(57.54,147.85) 57.59,147.85 57.99,147.45 57.99,146.89 57.97,146.87 57.97,146.86 57.73,146.62 57.72,146.62 57.53,146.43 v2(56.52,146.43) 55.5,146.43 55.01,145.94 55.01,145.09 54.77,144.85 54.56,144.85 54.34,144.63 R663.1
SIO_EUP_EN#: length 64.7
  TOP w0.114: PR66.1 98.74,35.98 98.07,35.31 96.52,35.31 95.63,36.2 v1(95.63,36.45) 95.07,35.89 95.07,35.13 94.81,34.87 94.81,31.58 95.15,31.24 95.15,28.19 95.45,27.9 95.45,25.35 96.04,24.77 v3(98.2,24.77) PR67.1
  L4 w0.114: v1(95.63,36.45) 95.5,36.58 95.5,40.15 100.21,44.86 102.78,44.86 103.23,45.3 103.23,46.09 103.14,46.18 103.14,47.23 103.43,47.53 103.43,49.93 103.33,50.02 103.33,50.41 103.43,50.5 103.43,54.48 104.52,55.58 104.52,56.01 v1(104.44,56.08)
  L6 w0.102: v1(104.44,56.08) 104.65,56.29 104.65,57.1 105.33,57.78 105.33,58.84 105.6,59.11 105.91,59.11 107.33,60.53 108.75,60.53 109.59,61.37 113.36,61.37 115.21,63.22 115.21,63.91 115.7,64.39 116.84,64.39 v1(117.14,64.08)
  BOTTOM w0.114: R173.2 117.53,63.7 v1(117.14,64.08)
SIO_GREEN_PWM: length 190.8
  TOP w0.114: v1(93.78,52.12) 93.65,52.25 85.67,52.25 v1(84.45,53.47) ; KBC1.16 103.23,53.34 103.47,53.1 104.33,53.1 v1(104.34,53.11) ; OSDC1.4 8.14,137.25 v3(9.12,138.23) 9.84,138.95 13.16,138.95 v1(13.31,138.8)
  L3 w0.114: v1(104.34,53.11) 102.29,53.11 101.85,53.55 98.94,53.55 98.22,52.83 97.7,52.31 94.75,52.31 94.56,52.12 v1(93.78,52.12) ; v1(13.31,138.8) 13.3,138.81 13.03,138.81 12.83,138.61 12.83,137.92 12.37,137.46 12.37,136.89 10.12,134.64 10.12,134.64 5.68,130.21 5.68,117.75 13.71,109.73 24.46,109.73 24.64,109.55 25.6,108.59 78.38,108.59 85.28,101.69 85.28,100 85.69,99.6 85.69,85.4 83.41,83.13 83.41,80.55 83.22,80.36 83.22,55.28 83.1,55.16 83.1,54.67 83.93,53.85 84.07,53.85 v1(84.45,53.47)
SIO_PME_N: length 217.1
  TOP w0.114: R2435.1 123.36,56.81 v1(123.57,57.02) ; v1(167.77,62.7) 167.49,62.42 v3(165.9,62.42) R154.2 U1.D ; CPU1.AL2 v6(158.5,181.5)
  L3 w0.114: v1(138.3,95.45) 138.3,95.17 139.14,94.33 139.14,87.2 146.9,79.44 156.01,79.44 157.09,80.52 163.19,80.52 166.71,76.99 166.71,72.65 167.49,71.87 v1(167.49,68.83) 167.49,62.99 167.77,62.71 v1(167.77,62.7)
  L4 w0.114: v6(158.5,181.5) 158.5,181.48 158.96,181.02 158.96,179.28 158.67,178.99 155.45,178.99 155.07,179.37 155.07,179.52 154.67,179.92 153.33,179.92 150.75,177.34 150.75,175.96 150.05,175.26 147.5,175.26 145.49,173.25 145.49,171.36 143.85,169.72 143.85,165.14 139.12,160.4 139.12,158.01 138.18,157.07 138.18,155.02 137.3,154.14 137.3,150.68 137.03,150.41 137.03,145.85 137.59,145.29 137.59,145.16 140.51,142.24 140.51,126.16 140.06,125.7 140.06,123.18 141.3,121.94 141.3,104.64 140.77,104.11 140.77,98.14 138.3,95.68 v1(138.3,95.45)
  L6 w0.102: v1(123.57,57.02) 124.66,58.11 124.66,59.61 127.57,62.51 131.55,62.51 136.93,67.89 147.84,67.89 148.58,68.63 163.76,68.63 163.96,68.83 v1(167.49,68.83)
SIO_SMCLK0: length 396.3
  TOP w0.114: KBC1.67 115.96,47.74 115.95,47.75 114.53,47.75 v1(114.05,48.23) ; v1(125.83,170.92) 125.3,170.38 124.64,170.38 124.07,169.81 Q76.3
  L3 w0.114: v1(193.27,80.59) 191.44,78.77 186.49,78.77 182.25,74.52 182.25,66.52 v1(181.08,65.35) ; v1(193.93,169.21) 194.23,169.52 197.51,169.52 199.65,167.39 201.42,167.39 202.98,165.82 v1(203.48,165.82)
  L4 w0.114: v1(181.08,65.35) 180.93,65.35 180.37,65.92 180.37,66.86 180.37,66.86 180.37,67.46 170.65,77.19 160.38,77.19 159.69,77.88 157.61,77.88 156.9,77.17 155.37,77.17 154.61,77.93 148.19,77.93 143,83.12 139.92,83.12 133.93,89.1 129.96,89.1 124.21,94.86 124.21,97.38 123.09,98.5 123.09,112.01 122.99,112.12 122.99,112.74 122.38,113.35 122.38,116.85 121.69,117.53 121.69,119.65 120.29,121.05 120.29,123.95 121.38,125.04 121.38,129.87 121.69,130.18 121.69,136.36 122.87,137.55 122.87,168.04 123.49,168.67 123.49,170.21 124.71,171.42 125.32,171.42 v1(125.83,170.92) ; v1(114.05,48.23) 114.68,48.23 115.33,48.88 115.33,50.18 116.08,50.93 116.08,51.82 v1(116.69,52.43)
  L6 w0.102: v1(203.48,165.82) 204.29,165.82 207.19,162.92 207.19,159.89 209.62,157.47 211.9,157.47 211.91,157.45 212.16,157.21 212.28,157.08 212.71,156.67 212.78,156.59 213.99,156.59 215.2,155.37 216.15,155.37 217.81,153.72 217.81,144.58 213.56,140.34 213.56,137.74 212.22,136.4 212.22,123.98 220.1,116.09 220.1,102.24 218.62,100.76 218.62,92.6 213.2,87.17 199.85,87.17 v1(193.27,80.59) ; v1(181.08,65.35) 180.06,64.34 177.42,64.34 175.57,66.19 169.71,66.19 169.05,65.53 152.73,65.53 150.34,63.14 145.56,63.14 144.7,64.01 139.55,64.01 137.39,61.84 137.39,61.84 136.73,61.19 134.4,61.19 132.49,59.28 130.43,59.28 127.28,56.13 125.37,56.13 124.48,55.24 123.18,55.24 121.28,53.34 117.6,53.34 v1(116.69,52.43)
  BOTTOM w0.114: RN12.3 116.45,52.71 116.69,52.48 v1(116.69,52.43) 116.92,52.19 Q15.6 ; Q75.6 193,171.26 192.66,170.92 192.66,169.79 192.88,169.57 193.02,169.57 193.37,169.21 v1(193.93,169.21) ; v2(181.08,64.52) v1(181.08,65.35)
SIO_SMDAT0: length 389.1
  TOP w0.114: v1(124.99,170.94) 123.47,170.94 122.61,170.08 122.61,168.81 122.31,168.51 Q76.6 ; KBC1.68 115.74,48.14 v1(114.83,49.05)
  L3 w0.114: v1(202.69,163.58) 202.2,163.58 197.4,168.38 196.27,168.38 v1(195.7,168.95) ; v1(192.3,80.67) 192.23,80.67 190.74,79.18 186.31,79.18 181.83,74.7 181.83,67.12 v1(181,66.29)
  L4 w0.114: v1(115.09,54.18) 115.57,53.7 115.57,51.01 114.83,50.28 v1(114.83,49.05) ; v1(124.99,170.94) 123.94,169.89 123.94,167.55 123.29,166.9 123.29,137.37 122.11,136.19 122.11,130 121.91,129.79 121.91,124.32 120.75,123.16 120.75,121.18 122.11,119.82 122.11,117.71 122.8,117.02 122.8,113.52 123.58,112.74 123.58,98.74 124.63,97.7 124.63,95.03 130.14,89.52 134.11,89.52 140.09,83.54 143.17,83.54 148.37,78.35 154.78,78.35 155.55,77.58 156.72,77.58 157.43,78.3 159.86,78.3 160.55,77.61 170.82,77.61 181.18,67.25 181.18,66.47 v1(181,66.29)
  L6 w0.102: v1(181,66.29) 180.59,65.89 180.31,65.89 179.2,64.77 177.57,64.77 175.74,66.6 169.55,66.6 168.89,65.94 152.56,65.94 150.17,63.55 145.73,63.55 144.87,64.41 139.39,64.41 136.98,62.01 136.57,61.59 134.23,61.59 132.32,59.69 130.2,59.69 127.05,56.54 125.2,56.54 124.31,55.65 123.01,55.65 121.11,53.75 115.52,53.75 v1(115.09,54.18) ; v1(202.69,163.58) 202.97,163.3 204.88,163.3 206.78,161.39 206.78,160.06 206.78,159.64 209.36,157.06 211.74,157.06 212.53,156.27 212.61,156.18 212.95,156.18 213.82,156.18 215.04,154.97 215.9,154.97 217.32,153.54 217.32,144.67 211.81,139.16 211.81,123.81 219.7,115.92 219.7,102.41 218.22,100.93 218.22,92.77 213.03,87.58 199.21,87.58 v1(192.3,80.67)
  BOTTOM w0.114: Q75.3 195.35,169.67 195.7,169.33 v1(195.7,168.95) ; RN12.4 115.24,54.02 115.24,54.03 v1(115.09,54.18) ; v1(114.83,49.05) 115.33,49.05 Q15.3 ; v2(180.31,65.74) 180.44,65.74 v1(181,66.29)
SIO_YELLOW: length 200.5
  TOP w0.114: KBC1.47 109.65,46.16 108.83,46.98 108.83,52.4 v1(109.25,52.82) ; v1(93.68,53.59) 93.42,53.34 88.75,53.34 88.38,52.97 86.35,52.97 84.45,54.86 v1(83.57,54.86) ; OSDC1.5 8.45,136.75 10.08,138.38 v3(11.15,138.38) 11.37,138.6 12.71,138.6 13.31,138 13.36,138 v1(13.48,137.88)
  L3 w0.114: v1(13.48,137.88) 13.42,137.82 13.41,137.82 12.79,137.2 12.79,136.72 10.29,134.22 10.29,134.22 6.1,130.03 6.1,117.93 13.88,110.15 24.65,110.15 25.79,109.01 78.55,109.01 85.7,101.86 85.7,100.18 86.11,99.77 86.11,85.23 83.83,82.95 83.83,80.38 83.64,80.19 83.64,54.94 v1(83.57,54.86) ; v1(93.68,53.59) 93.83,53.59 94,53.77 95.96,53.77 96.2,54 98.09,54 98.5,54.41 102.21,54.41 102.39,54.23 102.44,54.17 105.86,54.17 106.58,53.45 108.62,53.45 v1(109.25,52.82)
SLEEVE_CON: length 32.1
  L6 w1.016: 224.31,35.18 223.21,35.18 215.18,43.21 209.65,43.21 206.5,46.35 205.15,46.35 204.04,47.46 204.04,49.58 200.79,52.83
  vias: v2(200.58,51.94) v4(199.82,54) v4(199.87,52.83) v4(225.55,35.56) v4(225.58,34.47)
SLP_S3_N: length 846.8
  TOP w0.114: v1(153.52,181.48) 153.54,181.46 153.54,181.46 CPU1.AT2 ; R396.1 227.39,149.03 226.95,148.59 v1(225.81,148.59) ; R861.1 140.91,10.29 v3(139.75,10.29) 139.22,10.29 v1(138.81,10.69) ; R346.2 98.17,47.5 97.64,48.03 v1(97.59,48.03) ; v1(222.55,7.19) 222.68,7.32 R333.2 ; v1(5.61,196.11) 6.46,196.96 PR201.1 ; v1(122.22,40.64) 122.9,41.31 R2472.1 ; LAUOC1.10 127.75,9.13 126.44,10.44 v1(126.44,10.57)
  L3 w0.114: v1(163.58,12.32) 163.63,12.37 166.27,12.37 166.93,11.71 171.53,11.71 172.11,11.13 172.11,5.94 174.02,4.04 180.62,4.04 180.63,4.05 181.85,4.05 183.12,5.32 184.29,5.32 185.32,4.29 220.34,4.29 222.55,6.5 v1(222.55,7.19) 222.66,7.29 222.66,8.59 223.62,9.55 223.62,14.45 223.99,14.82 223.99,17.82 225.04,18.87 225.04,21.01 225.96,21.92 225.96,23.42 222.68,26.7 222.68,30.15 230.5,37.98 230.5,52.01 227.9,54.61 227.9,61 214.3,74.6 v1(214.3,76.15) ; v1(5.61,196.11) 5.61,186.66 6.6,185.67 13.21,185.67 16.26,182.63 16.26,169.42 11.51,164.67 11.51,143.56 11.13,143.18 11.13,137.43 4.54,130.85 4.54,117.13 13.08,108.59 23.84,108.59 24.98,107.45 78.1,107.45 v1(82.04,103.5)
  L4 w0.114: v1(140.05,189.36) 140.04,189.36 139.85,189.36 138.93,188.43 138.93,187.32 137.59,185.98 128.24,185.98 122.2,179.93 122.2,179.92 117.72,175.43 117.72,160.62 115.75,158.65 115.75,155.65 117.12,154.28 117.12,151.26 118.3,150.08 118.3,147.92 115.4,145.02 115.4,143.62 116.81,142.21 116.81,138.67 116.12,137.97 116.12,137.96 115.8,137.64 115.8,133.07 115.39,132.66 115.39,113.41 112.47,110.49 112.47,110.49 105.14,103.16 99.81,103.16 v1(99.31,102.67) ; v1(145.44,42.01) 145.37,42.08 145.37,42.58 146.05,43.26 147.14,43.26 147.83,43.94 147.83,45.09 143.38,49.53 133.43,49.53 v1(132.94,50.01) ; v1(214.3,76.15) 214.3,83.19 215.24,84.12 215.24,95.68 215.24,95.69 215.24,95.91 215.24,95.92 215.24,98.91 217.07,100.74 217.07,105.33 217.86,106.12 217.86,114.37 212.85,119.38 212.85,125.74 212.86,125.74 212.86,128.49 212.83,128.52 212.83,129.79 212.94,129.91 212.94,131.49 213.52,132.07 213.65,132.07 v1(213.77,132.18)
  L6 w0.102: v1(82.04,103.5) 83.95,101.6 93.22,101.6 94.51,102.9 99.09,102.9 v1(99.31,102.67) ; v1(122.22,40.64) 120.93,41.94 110.97,41.94 109.25,43.66 105.79,43.66 104.78,42.65 104.22,42.65 103.1,43.76 101.33,43.76 100.13,44.97 100.13,45.9 97.99,48.03 v1(97.59,48.03) 97.59,47.07 99.03,45.62 99.03,37.16 99.11,37.08 99.11,36.45 97.49,34.82 97.49,26.25 97.18,25.95 97.18,25.57 97.49,25.26 97.49,25.22 98.35,24.36 98.35,23.83 97.18,22.66 97.18,20.05 99.82,17.4 99.82,16.89 108.46,8.26 108.46,8 108.86,7.59 113,7.59 114.99,9.58 123.09,9.58 124.56,11.05 125.96,11.05 v1(126.44,10.57) 127.33,9.68 131.59,9.68 132.65,10.74 135.38,10.74 135.71,10.41 138.53,10.41 v1(138.81,10.69) 139.11,10.4 152.46,10.4 152.81,10.74 155.27,10.74 156.41,11.89 163.14,11.89 v1(163.58,12.32) ; v1(140.05,189.36) 140.22,189.36 142.21,187.38 150.11,187.38 152.02,185.47 152.02,184.58 153.49,183.11 153.49,181.51 v1(153.52,181.48) 154.05,180.95 154.68,180.95 155.04,180.58 155.04,179.41 155.54,178.91 155.67,178.91 156,178.57 156,178.32 156.37,177.95 158.51,177.95 159.53,176.93 159.67,176.93 160.1,176.5 160.1,176.31 160.34,176.08 160.5,176.08 163.09,173.48 163.09,173.33 163.33,173.09 170.09,173.09 171.26,171.92 188.89,171.92 190.04,173.08 191.54,173.08 191.8,173.33 191.8,173.33 192.66,174.19 198.09,174.19 203.96,168.33 203.96,167.42 211.25,160.13 211.25,159.09 211.52,158.83 212.62,158.83 213.82,157.63 214.05,157.63 215.73,155.95 219.46,155.95 225.86,149.56 225.86,148.64 v1(225.81,148.59) 225.44,148.59 225.06,148.97 222.25,148.97 221.87,148.59 221.51,148.59 218.31,145.39 218.31,143.07 215.06,139.82 215.06,133.63 213.77,132.33 v1(213.77,132.18)
  BOTTOM w0.114: v1(132.94,50.01) 134.62,48.34 134.62,42.93 133.1,41.4 132.59,41.4 130.81,39.62 123.32,39.62 122.3,40.64 v1(122.22,40.64) ; v1(145.44,42.01) 146.16,42.01 R1218.1
