# Allegro board 16544-1.0322WZS1614.brd (continued)
## Nets (continued)
PCIE_RX_SSDX4_N5: PCH1.L23 SSDC1.29
PCIE_RX_SSDX4_N6: PCH1.M22 SSDC1.17
PCIE_RX_SSDX4_N7: PCH1.N22 SSDC1.5
PCIE_RX_SSDX4_P4: PCH1.K22 U26.19
PCIE_RX_SSDX4_P5: PCH1.L24 SSDC1.31
PCIE_RX_SSDX4_P6: PCH1.M23 SSDC1.19
PCIE_RX_SSDX4_P7: PCH1.P22 SSDC1.7
PCIE_TX_CON_N0: C204.2 WLAN1.37
PCIE_TX_CON_P0: C203.2 WLAN1.35
PCIE_TX_LAN_N1: C206.2 TYPEC1.4
PCIE_TX_LAN_P1: C205.2 TYPEC1.3
PCIE_TX_PCH_N0: C204.1 PCH1.M26
PCIE_TX_PCH_N1: C206.1 PCH1.N25
PCIE_TX_PCH_P0: C203.1 PCH1.M25
PCIE_TX_PCH_P1: C205.1 PCH1.N24
PCIE_TX_SSDX4_N4: C1150.2 U26.16
PCIE_TX_SSDX4_N4_R: C1150.1 PCH1.H26
PCIE_TX_SSDX4_N5: C503.1 PCH1.J24
PCIE_TX_SSDX4_N5_C: C503.2 SSDC1.35
PCIE_TX_SSDX4_N6: C501.1 PCH1.K26
PCIE_TX_SSDX4_N6_C: C501.2 SSDC1.23
PCIE_TX_SSDX4_N7: C495.1 PCH1.L25
PCIE_TX_SSDX4_N7_C: C495.2 SSDC1.11
PCIE_TX_SSDX4_P4: C1149.2 U26.17
PCIE_TX_SSDX4_P4_R: C1149.1 PCH1.H25
PCIE_TX_SSDX4_P5: C504.1 PCH1.H24
PCIE_TX_SSDX4_P5_C: C504.2 SSDC1.37
PCIE_TX_SSDX4_P6: C502.1 PCH1.K25
PCIE_TX_SSDX4_P6_C: C502.2 SSDC1.25
PCIE_TX_SSDX4_P7: C496.1 PCH1.L26
PCIE_TX_SSDX4_P7_C: C496.2 SSDC1.13
PCIE_WAKE#: CPU1.AL5 PCH1.V5 R162.2 RN6.3(B)
PDB: PD1.A PD2.A PR1.2 U7.15 U8.15
PEDET_B: Q35.B R442.1
PEG_C_RXN0: C533.2 GPU1.AN43
PEG_C_RXN1: C537.2 GPU1.AM41
PEG_C_RXN2: C540.2 GPU1.AM42
PEG_C_RXN3: C544.2 GPU1.AK42
PEG_C_RXN4: C524.2 GPU1.AJ43
PEG_C_RXN5: C526.2 GPU1.AG41
PEG_C_RXN6: C550.2 GPU1.AG42
PEG_C_RXN7: C529.2 GPU1.AF42
PEG_C_RXN8: C555.2 GPU1.AE43
PEG_C_RXN9: C559.2 GPU1.AD41
PEG_C_RXN10: C563.2 GPU1.AD42
PEG_C_RXN11: C567.2 GPU1.AC42
PEG_C_RXN12: C571.2 GPU1.AA43
PEG_C_RXN13: C575.2 GPU1.Y41
PEG_C_RXN14: C579.2 GPU1.Y42
PEG_C_RXN15: C583.2 GPU1.W43
PEG_C_RXP0: C531.2 GPU1.AN42
PEG_C_RXP1: C535.2 GPU1.AN41
PEG_C_RXP2: C521.2 GPU1.AM43
PEG_C_RXP3: C542.2 GPU1.AK43
PEG_C_RXP4: C522.2 GPU1.AJ42
PEG_C_RXP5: C525.2 GPU1.AJ41
PEG_C_RXP6: C527.2 GPU1.AG43
PEG_C_RXP7: C551.2 GPU1.AF43
PEG_C_RXP8: C530.2 GPU1.AE42
PEG_C_RXP9: C557.2 GPU1.AE41
PEG_C_RXP10: C561.2 GPU1.AD43
PEG_C_RXP11: C565.2 GPU1.AC43
PEG_C_RXP12: C569.2 GPU1.AA42
PEG_C_RXP13: C573.2 GPU1.AA41
PEG_C_RXP14: C577.2 GPU1.Y43
PEG_C_RXP15: C581.2 GPU1.W42
PEG_C_TXN0: C534.1 GPU1.AR39
PEG_C_TXN1: C538.1 GPU1.AN37
PEG_C_TXN2: C541.1 GPU1.AN38
PEG_C_TXN3: C545.1 GPU1.AM38
PEG_C_TXN4: C546.1 GPU1.AK39
PEG_C_TXN5: C548.1 GPU1.AJ37
PEG_C_TXN6: C528.1 GPU1.AJ38
PEG_C_TXN7: C553.1 GPU1.AG38
PEG_C_TXN8: C556.1 GPU1.AF39
PEG_C_TXN9: C560.1 GPU1.AE37
PEG_C_TXN10: C564.1 GPU1.AE38
PEG_C_TXN11: C568.1 GPU1.AD38
PEG_C_TXN12: C572.1 GPU1.AC39
PEG_C_TXN13: C576.1 GPU1.AA37
PEG_C_TXN14: C580.1 GPU1.AA38
PEG_C_TXN15: C584.1 GPU1.Y39
PEG_C_TXP0: C532.1 GPU1.AR38
PEG_C_TXP1: C536.1 GPU1.AR37
PEG_C_TXP2: C539.1 GPU1.AN39
PEG_C_TXP3: C543.1 GPU1.AM39
PEG_C_TXP4: C523.1 GPU1.AK38
PEG_C_TXP5: C547.1 GPU1.AK37
PEG_C_TXP6: C549.1 GPU1.AJ39
PEG_C_TXP7: C552.1 GPU1.AG39
PEG_C_TXP8: C554.1 GPU1.AF38
PEG_C_TXP9: C558.1 GPU1.AF37
PEG_C_TXP10: C562.1 GPU1.AE39
PEG_C_TXP11: C566.1 GPU1.AD39
PEG_C_TXP12: C570.1 GPU1.AC38
PEG_C_TXP13: C574.1 GPU1.AC37
PEG_C_TXP14: C578.1 GPU1.AA39
PEG_C_TXP15: C582.1 GPU1.Y38
PEG_CLK0_WLAN_N: R2645.2 WLAN1.49
PEG_CLK0_WLAN_N_R: PCH1.AC25 R2645.1
PEG_CLK0_WLAN_P: R2644.2 WLAN1.47
PEG_CLK0_WLAN_P_R: PCH1.AC26 R2644.1
PEG_CLK1_LAN_N: R2647.2 TYPEC1.10
PEG_CLK1_LAN_N_R: PCH1.AA25 R2647.1
PEG_CLK1_LAN_P: R2646.2 TYPEC1.9
PEG_CLK1_LAN_P_R: PCH1.AA26 R2646.1
PEG_CLK4_M2SSD_N: R2649.2 SSDC1.53
PEG_CLK4_M2SSD_N_R: PCH1.AB25 R2649.1
PEG_CLK4_M2SSD_P: R2648.2 SSDC1.55
PEG_CLK4_M2SSD_P_R: PCH1.AB26 R2648.1
PEG_CLK_CPU_N: GPU1.AR43 R2651.1
PEG_CLK_CPU_N_R: CPU1.AF7 R2651.2
PEG_CLK_CPU_P: GPU1.AR42 R2650.1
PEG_CLK_CPU_P_R: CPU1.AF6 R2650.2
PEG_CLKREQ0_NGFF#_C: R2476.1 WLAN1.53
PEG_CLKREQ0_WLAN#: Q26.S R416.2 R417.2 R2476.2
PEG_CLKREQ0_WLAN_C: PCH1.AD26 Q26.D R414.2 R417.1 RN2412.3(B)
PEG_CLKREQ1_LAN#: LAUOC1.23 PCH1.AD25 RN2412.4(B)
PEG_CLKREQ4_SSD#: PCH1.AA23 RN2414.3(B) SSDC1.52
PEG_CLKREQ5#: PCH1.Y22 RN2414.4(B)
PEG_RX_CPU_N0: C534.2 CPU1.F5
PEG_RX_CPU_N1: C538.2 CPU1.G4
PEG_RX_CPU_N2: C541.2 CPU1.H6
PEG_RX_CPU_N3: C545.2 CPU1.J5
PEG_RX_CPU_N4: C546.2 CPU1.K7
PEG_RX_CPU_N5: C548.2 CPU1.K4
PEG_RX_CPU_N6: C528.2 CPU1.L6
PEG_RX_CPU_N7: C553.2 CPU1.M5
PEG_RX_CPU_N8: C556.2 CPU1.N7
PEG_RX_CPU_N9: C560.2 CPU1.N4
PEG_RX_CPU_N10: C564.2 CPU1.P6
PEG_RX_CPU_N11: C568.2 CPU1.R5
PEG_RX_CPU_N12: C572.2 CPU1.T7
PEG_RX_CPU_N13: C576.2 CPU1.T5
PEG_RX_CPU_N14: C580.2 CPU1.U6
PEG_RX_CPU_N15: C584.2 CPU1.V5
PEG_RX_CPU_P0: C532.2 CPU1.F6
PEG_RX_CPU_P1: C536.2 CPU1.G5
PEG_RX_CPU_P2: C539.2 CPU1.H7
PEG_RX_CPU_P3: C543.2 CPU1.J6
PEG_RX_CPU_P4: C523.2 CPU1.K8
PEG_RX_CPU_P5: C547.2 CPU1.K5
PEG_RX_CPU_P6: C549.2 CPU1.L7
PEG_RX_CPU_P7: C552.2 CPU1.M6
PEG_RX_CPU_P8: C554.2 CPU1.N8
PEG_RX_CPU_P9: C558.2 CPU1.N5
PEG_RX_CPU_P10: C562.2 CPU1.P7
PEG_RX_CPU_P11: C566.2 CPU1.R6
PEG_RX_CPU_P12: C570.2 CPU1.T8
PEG_RX_CPU_P13: C574.2 CPU1.T4
PEG_RX_CPU_P14: C578.2 CPU1.U7
PEG_RX_CPU_P15: C582.2 CPU1.V6
PEG_TX_CPU_N0: C533.1 CPU1.E1
PEG_TX_CPU_N1: C537.1 CPU1.F3
PEG_TX_CPU_N2: C540.1 CPU1.G2
PEG_TX_CPU_N3: C544.1 CPU1.H1
PEG_TX_CPU_N4: C524.1 CPU1.J3
PEG_TX_CPU_N5: C526.1 CPU1.K2
PEG_TX_CPU_N6: C550.1 CPU1.L1
PEG_TX_CPU_N7: C529.1 CPU1.M3
PEG_TX_CPU_N8: C555.1 CPU1.N2
PEG_TX_CPU_N9: C559.1 CPU1.P1
PEG_TX_CPU_N10: C563.1 CPU1.R3
PEG_TX_CPU_N11: C567.1 CPU1.T2
PEG_TX_CPU_N12: C571.1 CPU1.U1
PEG_TX_CPU_N13: C575.1 CPU1.V3
PEG_TX_CPU_N14: C579.1 CPU1.W2
PEG_TX_CPU_N15: C583.1 CPU1.Y1
PEG_TX_CPU_P0: C531.1 CPU1.D1
PEG_TX_CPU_P1: C535.1 CPU1.E3
PEG_TX_CPU_P2: C521.1 CPU1.F2
PEG_TX_CPU_P3: C542.1 CPU1.G1
PEG_TX_CPU_P4: C522.1 CPU1.H3
PEG_TX_CPU_P5: C525.1 CPU1.J2
PEG_TX_CPU_P6: C527.1 CPU1.K1
PEG_TX_CPU_P7: C551.1 CPU1.L3
PEG_TX_CPU_P8: C530.1 CPU1.M2
PEG_TX_CPU_P9: C557.1 CPU1.N1
PEG_TX_CPU_P10: C561.1 CPU1.P3
PEG_TX_CPU_P11: C565.1 CPU1.R2
PEG_TX_CPU_P12: C569.1 CPU1.T1
PEG_TX_CPU_P13: C573.1 CPU1.U3
PEG_TX_CPU_P14: C577.1 CPU1.V2
PEG_TX_CPU_P15: C581.1 CPU1.W1
PEX_CLKREQ_R: GPU1.AV41 R496.1
PGOOD_NB: D7.2 PR78.2 PU6.42 R375.2
PGVDD1: R324.2 R325.1 U8.6
PLT_RST#_APU: LPC1.3 R69.1 R2440.2
PLT_RST#_R: C21.1 CPU1.AU22 R69.2 TP97.1
PLTRST#_EC_R: C1020.1 KBC1.7 R2440.1
PLTRST_LAN_N: LAUOC1.22 RN48.4(B)
PLTRST_N_1: R235.2 R2539.1 RN48.1(A) RN48.2(A) U3.4
PLTRST_SSD: R2539.2 SSDC1.50
PM_DEBUG_ENABLE: PCH1.B25 R151.2
PM_GPIO0_X16_PRSNT: PCH1.B1 R35.1
PM_GPIO1_PCIEX16_DET0: PCH1.B4 R36.1
PM_GPIO2_PCIEX16_DET1: PCH1.C6 R82.1
PM_GPIO3_PCIEX16_DET2: PCH1.B6 R40.1
PM_GPIO4_SSD_DET: PCH1.A6 Q35.C R2601.1
PM_GPIO_R0: PCH1.A1 R155.2
PM_GPIO_R1: PCH1.B3 R156.2
PM_GPIO_R2: PCH1.C4 R157.2
PM_GPIO_R3: PCH1.A3 R158.2
PM_GPIO_R4: PCH1.A24 R122.2 R123.2
PM_GPIO_R5: PCH1.A26 R125.2 R126.2
PM_GPIO_R6: PCH1.E25 R127.2 R129.2
PM_GPIO_R7: PCH1.B26 R132.2 R133.2
PM_GPIO_R8: PCH1.F24 R135.2 R136.2
PM_GPIO_R9: PCH1.E22 R138.2 R139.2
PM_GPIO_R11: PCH1.F23 R150.2
PM_GPIO_R12: PCH1.F26 R438.2
PM_GPP_INT_PCI_WAKE: PCH1.AE26 R159.2 R160.2
PM_IFDET0: PCH1.C8 R147.2
PM_IFDET1: PCH1.A7 R149.2
PM_INT: PCH1.A21 U1.S
PM_PCIE_RST: C207.2 PCH1.AC10 R153.2 R235.1 U3.1 U3.2
PM_PCIE_WAKE#: LAUOC1.21 R160.1 R162.1 R439.2 R1219.1 R1220.2
PM_PKG0: PCH1.D9 R146.2
PM_PKG1: PCH1.D8 R148.2
PM_PWGD: C208.1 PCH1.C25 PR94.1 R163.2 R164.2
PM_PWRBTN_N: CPU1.AN5 R2454.2 R2470.1 RN6.4(B)
PM_SPI_SCK: PCH1.C5 R143.2
PM_SPI_SDI: PCH1.B5 R141.2
PM_SPI_SDO: PCH1.A4 R142.2
PM_TCK: PCH1.B23 TP13.1
PM_TDI: PCH1.C24 TP14.1
PM_TDO: PCH1.A23 TP15.1
PM_TESTEN: PCH1.AF26 R145.2
PM_TMS: PCH1.D24 TP16.1
PM_UART_RX: PCH1.E7 TP17.1
PM_UART_TX: PCH1.D7 R140.2
PM_UREXT: PCH1.AF10 R169.2
PM_XTAL_25M_IN: C209.1 R170.2 R2656.1 X3.1
PM_XTAL_25M_IN_R: PCH1.AE10 R2656.2
PM_XTAL_25M_OUT: C210.1 R170.1 R2657.1 X3.3
PM_XTAL_25M_OUT_R: PCH1.AD10 R2657.2
PMSCL: PMBUS1.2 PR225.2 PR245.2 TP105.1
PMSDA: PMBUS1.3 PR224.2 PR246.2 TP106.1
PPON_0: PCH1.AF6 TP18.1
PPON_1: PCH1.AE6 TP19.1
PPON_2: PCH1.AF7 TP20.1
PPON_3: PCH1.AE7 TP21.1
PPON_4: PCH1.AD7 TP22.1
PPON_5: PCH1.AC7 TP23.1
PPON_6: PCH1.AB7 TP24.1
PPON_7: PCH1.AA7 TP25.1
PPON_8: PCH1.AC9 TP26.1
PPON_9: PCH1.AB9 TP27.1
PPON_10: PCH1.AA9 TP28.1
PPON_11: PCH1.AF9 TP29.1
PPON_12: PCH1.AE9 TP30.1
PPON_13: PCH1.AD9 TP31.1
PREXT: PCH1.C9 R152.2
PROCHOT#_CPU_Q: CPU1.H15 Q1.S R1232.2 R2506.1
PSID_D: L24.2 Q21.D R386.1
PSID_D_1: Q22.B R386.2 R387.1
PSID_G: Q21.G Q22.C R385.2
PSL_IN1#: KBC1.73 Q78.D R239.1 R2779.2
PSL_IN2#: KBC1.93 R237.2
PSL_OUT#: KBC1.74 R193.1
PSW_GPIO: CPU1.AV19 JMP1.3 R456.1 TP103.1
PURE_HW_SHUTDOWN#: D3.K Q8.B Q14.D R181.2 R182.1 R1202.1 R2603.2
PURE_HW_SHUTDOWN#_R: Q50.C R2603.1
PWR_0D8V: PC375.1 PC376.1 PC377.1 PC378.1 PC379.1 PG190.2 PG192.1 PG193.1 PG195.1 PG196.1 PL21.2
PWR_0D8V_BOOT: PR318.1 PU47.1
PWR_0D8V_BOOT_A: PC373.1 PR318.2
PWR_0D8V_EN: PC499.1 PR320.2 PR321.1 PU47.11
PWR_0D8V_FB: PC383.2 PR319.2 PR322.1 PU47.14
PWR_0D8V_FB_A: PC383.1 PG190.1 PR319.1
PWR_0D8V_ILMT: PR323.1 PR325.1 PU47.13
PWR_0D8V_PG: PR324.2 PR326.2 PU47.9
PWR_0D8V_PH: PC373.2 PL21.1 PU47.6 PU47.19 PU47.20
PWR_0D8V_VCC: PC372.1 PU47.16 PU47.17
PWR_0D9V_FB: PC427.2 PR352.2 PR354.1 PU53.2
PWR_0D9V_PG: PR355.1 PU53.7
PWR_0D9V_VIN: PC419.1 PG215.1 PU53.5 PU53.9
PWR_0D775V: PC269.1 PC270.1 PG153.1 PU38.4 R2786.1
PWR_0D775V_EN: PQ11.5 PR218.1
PWR_0D775V_EN_R: PQ11.2 PQ11.3 PR216.2
PWR_0D775V_VIN: PC271.1 PG154.1 PU38.1
PWR_0D775V_VREF: PC272.1 PQ11.6 PR215.2 PR217.1 PU38.3
PWR_1D2V: PC189.1 PC190.1 PC405.1 PC406.1 PC407.1 PC408.1 PG65.1 PG67.1 PG68.1 PG69.1 PG70.1 PG71.1 PG72.1 PG73.1 PG74.1 PG75.1 PG76.1 PG77.2 PG78.1 PG79.1 PG81.1 PG83.1 PG84.1 PG85.1 PG86.1 PG87.1 PL8.2 PT21.1
PWR_1D05V: PC224.1 PC225.1 PC226.1 PC227.1 PG120.2 PG123.1 PG124.1 PG126.1 PG127.1 PG129.1 PL11.2
PWR_1D5V: PC265.1 PC266.1 PC267.1 PG151.1 PG152.1 PR359.1 PU37.3 PU37.4
PWR_1D05V_BOOT: PR188.1 PU33.1
PWR_1D05V_BOOT_A: PC223.1 PR188.2
PWR_1D05V_EN: PC431.1 PR192.1 PR337.2 PR363.2 PU33.11
PWR_1D5V_EN: PC428.1 PR210.2 PR389.1 PU37.8
PWR_1D5V_FB: PC265.2 PR359.2 PR360.1 PU37.2
PWR_1D05V_FB: PC231.2 PR189.2 PR190.1 PU33.14
PWR_1D05V_FB_A: PC231.1 PG120.1 PR189.1
PWR_1D05V_ILMT: PR191.1 PR348.1 PU33.13
PWR_1D5V_PG: PR212.2 PR214.2 PU37.7
PWR_1D05V_PG: PR335.2 PR336.2 PU33.9
PWR_1D5V_PH: PC223.2 PL11.1 PU33.6 PU33.19 PU33.20
PWR_1D05V_VCC: PC222.1 PU33.17
PWR_1D5V_VIN: PC263.1 PG150.1 PU37.5 PU37.9
PWR_1D8V: PC235.1 PC236.1 PC237.1 PC238.1 PG132.2 PG134.1 PG135.1 PG137.1 PG138.1 PG141.1 PG142.1 PL12.2
PWR_1D8V_BOOT: PR193.1 PU34.1
PWR_1D8V_BOOT_A: PC233.1 PR193.2
PWR_1D8V_EN: PC484.1 PR197.1 PR340.2 PU34.11
PWR_1D8V_FB: PC242.2 PR194.2 PR195.1 PU34.14
PWR_1D8V_FB_A: PC242.1 PG132.1 PR194.1
PWR_1D8V_ILMT: PR196.1 PR349.1 PU34.13
PWR_1D8V_PG: PR338.2 PR339.2 PU34.9
PWR_1D8V_PH: PC233.2 PL12.1 PU34.6 PU34.19 PU34.20
PWR_1D8V_VCC: PC234.1 PU34.17
PWR_1D8V_VGA: PC459.1 PC460.1 PC461.1 PG222.1 PG223.1 PR376.1 PU55.3 PU55.4
PWR_1D8V_VGA_EN: PC457.1 PC501.1 PR375.2 PR390.1 PU55.8
PWR_1D8V_VGA_FB: PC459.2 PR376.2 PR377.1 PU55.2
PWR_1D8V_VGA_PG: PR374.2 PR378.1 PU55.7
PWR_1D8V_VGA_VIN: PC458.1 PG220.1 PG221.1 PU55.5 PU55.9
PWR_1D35V: PC386.1 PC389.1 PC390.1 PC391.1 PC392.1 PC393.1 PG198.1 PG199.1 PG202.1 PG203.1 PG205.1 PG206.1 PG207.1 PG237.2 PG238.1 PG239.1 PG240.1 PG241.1 PG242.1 PG243.1 PG244.1 PG245.1 PG246.1 PG247.1 PL22.2 PT44.1
PWR_1D35V_BOOT: PR421.1 PU48.18
PWR_1D35V_BOOT_A: PC385.1 PR421.2
PWR_1D35V_CS: PR425.1 PU48.13
PWR_1D35V_EN: PC500.1 PR391.1 PR392.2 PR393.1 PU48.8
PWR_1D35V_FB: PC397.2 PR328.2 PR330.1 PU48.6
PWR_1D35V_HG: PU48.17 PU57.4
PWR_1D35V_LG: PU48.15 PU58.4
PWR_1D35V_PG: PR346.2 PR347.1 PU48.10
PWR_1D35V_PH: PC385.2 PL22.1 PR422.1 PU48.16 PU57.1 PU57.2 PU57.3 PU58.5 PU58.6 PU58.7 PU58.8
PWR_1D35V_SNUB: PC509.1 PR422.2
PWR_1D35V_TON: PR327.2 PU48.9
PWR_1D35V_VDD: PC384.1 PR423.1 PU48.12
PWR_1D35V_VDDQ: PC397.1 PG237.1 PR328.1 PU48.5
PWR_1D35V_VID: PC511.1 PR424.1 PU48.11
PWR_1D35V_VTTREF: PC510.1 PU48.4
PWR_2D5V: PC259.1 PC260.1 PC261.1 PG148.1 PG149.1 PR206.1 PU51.3 PU51.4
PWR_2D5V_EN: PC432.1 PR209.2 PR387.1 PU51.8
PWR_2D5V_FB: PC259.2 PR206.2 PR208.1 PU51.2
PWR_2D5V_PCH: PC488.1 PC489.1 PC490.1 PG226.1 PG227.1 PG236.1 PR397.1 PU56.3 PU56.4
PWR_2D5V_PCH_EN: PC487.1 PR388.1 PR396.2 PU56.8
PWR_2D5V_PCH_FB: PC488.2 PR397.2 PR398.1 PU56.2
PWR_2D5V_PCH_PG: PR395.2 PR400.2 PU56.7
PWR_2D5V_PCH_VIN: PC485.1 PG224.1 PG225.1 PG235.1 PU56.5 PU56.9
PWR_2D5V_PG: PR207.2 PR399.2 PU51.7
PWR_2D5V_VIN: PC257.1 PG147.1 PG212.1 PU51.5 PU51.9
PWR_3D3V: PC106.1 PC107.1 PC399.1 PG5.2 PG6.1 PG11.2 PG12.1 PG17.2 PG18.1 PG24.2 PG27.1 PG31.2 PG32.1 PG33.2 PG211.1 PG230.2 PG231.2 PG234.1 PL1.1 PT3.1
PWR_3D3V_5V_PG: PR65.1 PU3.7
PWR_3D3V_BOOT2: PR53.2 PU3.9
PWR_3D3V_BOOT2_A: PC104.1 PR53.1
PWR_3D3V_CS2: PR57.1 PU3.5
PWR_3D3V_EN2: PC504.1 PR67.2 PU3.6
PWR_3D3V_FB2: PR59.2 PR61.1 PU3.4
PWR_3D3V_FB2_A: PG33.1 PR59.1
PWR_3D3V_HG2: PU2.4 PU3.10
PWR_3D3V_LDO3: PC112.1 PG36.2 PU3.3
PWR_3D3V_LG2: PU3.11 PU4.4
PWR_3D3V_PH2: PC104.2 PL1.2 PR55.1 PU2.1 PU2.2 PU2.3 PU3.8 PU4.5 PU4.6 PU4.7 PU4.8
PWR_3D3V_SNUB: PC108.1 PR55.2
PWR_5V: PC110.1 PC111.1 PC400.1 PC401.1 PG9.2 PG10.1 PG15.2 PG16.1 PG21.2 PG22.1 PG25.2 PG26.1 PG29.2 PG30.1 PG34.2 PG35.2 PG213.1 PG214.2 PG232.2 PG233.1 PL2.2 PT5.1
PWR_5V3V_EMN_R: D2.3 D3.A R173.1 R175.1 R179.1
PWR_5V_BOOT1: PR54.1 PU3.17
PWR_5V_BOOT1_A: PC105.1 PR54.2
PWR_5V_BYP1: PG34.1 PU3.14
PWR_5V_CS1: PR58.1 PU3.1
PWR_5V_EN1: PC503.1 PR66.2 PU3.20
PWR_5V_FB1: PR60.2 PR62.1 PU3.2
PWR_5V_FB1_A: PG35.1 PR60.1
PWR_5V_HG1: PU1.4 PU3.16
PWR_5V_LDO5: PC113.1 PU3.13
PWR_5V_LG1: PU3.15 PU5.4
PWR_5V_PH1: PC105.2 PL2.1 PR56.1 PU1.1 PU1.2 PU1.3 PU3.18 PU5.5 PU5.6 PU5.7 PU5.8
PWR_5V_SNUB: PC109.1 PR56.2
PWR_12V: PC247.1 PC248.1 PC249.1 PC250.1 PG145.1 PG146.1 PL13.2 PR202.1 PR203.1
PWR_12V_BOOT: PR198.2 PU35.1
PWR_12V_BOOT_A: PC246.1 PR198.1
PWR_12V_EN: PC505.1 PR201.2 PR386.1 PU35.5
PWR_12V_FB: PC255.2 PR203.2 PR204.1 PU35.7
PWR_12V_FB_A: PC255.1 PR202.2
PWR_12V_LX: PC246.2 PL13.1 PR200.1 PU35.2 PU35.3 PU35.4
PWR_12V_PG: PR341.2 PR342.2 PU35.6
PWR_12V_SNB: PC254.1 PR200.2
PWR_12V_SS: PC245.2 PU35.8
PWR_12V_SVIN: PC253.1 PR199.2 PU35.10
PWR_12V_VCC: PC244.1 PU35.9
PWR_19V_DCBATOUT_RT6575: PC97.1 PC98.1 PR412.2 PU3.12
PWR_CHG_ACN: PR410.4 U24.5
PWR_CHG_ACP: PR410.3 U24.4
PWR_DCBATOUT_0D8V: PC380.1 PC381.1 PC382.1 PG191.2 PG194.2 PR323.2 PU47.2 PU47.3 PU47.4 PU47.5
PWR_DCBATOUT_1D05V: PC228.1 PC229.1 PC230.1 PG121.2 PG122.2 PG125.2 PR191.2 PU33.2 PU33.3 PU33.4 PU33.5
PWR_DCBATOUT_1D8V: PC239.1 PC240.1 PC241.1 PG131.2 PG133.2 PG136.2 PR196.2 PU34.2 PU34.3 PU34.4 PU34.5
PWR_DCBATOUT_1D35V: PC387.1 PC388.1 PC396.1 PC413.1 PC414.1 PC508.1 PG197.2 PG201.2 PG204.2 PR327.1 PU57.5 PU57.6 PU57.7 PU57.8
PWR_DCBATOUT_3D3V: PC94.1 PC95.1 PC96.1 PC424.1 PC425.1 PG7.2 PG13.2 PG19.2 PU2.5 PU2.6 PU2.7 PU2.8
PWR_DCBATOUT_5V: PC99.1 PC100.1 PC101.1 PC102.1 PC103.1 PG8.2 PG14.2 PG20.2 PG23.2 PG28.2 PU1.5 PU1.6 PU1.7 PU1.8
PWR_DCBATOUT_12V: PC251.1 PC252.1 PG143.2 PG144.2 PR199.1 PU35.11 PU35.12
PWR_DCBATOUT_VCOREA: C1154.1 PC145.1 PC146.1 PC147.1 PC148.1 PG38.2 PG39.2 PG40.2 PT6.1 PU7.5 PU7.6 PU7.7 PU7.8 PU8.5 PU8.6 PU8.7 PU8.8
PWR_DCBATOUT_VCOREB: C1153.1 C2529.1 C2530.1 C2531.1 PC151.1 PC152.1 PC153.1 PC154.1 PG43.2 PG44.2 PG45.2 PU11.5 PU11.6 PU11.7 PU11.8 PU12.5 PU12.6 PU12.7 PU12.8
PWR_DCBATOUT_VCOREC: C1152.1 PC157.1 PC158.1 PC159.1 PC160.1 PG48.2 PG49.2 PG50.2 PT14.1 PU15.5 PU15.6 PU15.7 PU15.8 PU16.5 PU16.6 PU16.7 PU16.8
PWR_DCBATOUT_VDDCA: PC304.1 PG155.2 PG157.2 PG159.2 PT25.1 PU40.8 PU40.9 PU40.10 PU40.11 PU40.12 PU40.13 PU40.14 PU40.42
PWR_DCBATOUT_VDDCB: C1159.1 PC313.1 PC316.1 PC437.1 PC438.1 PC439.1 PC440.1 PG165.2 PG167.2 PG169.2 PU42.8 PU42.9 PU42.10 PU42.11 PU42.12 PU42.13 PU42.14 PU42.42
PWR_DCBATOUT_VDDCC: C1157.1 PC344.1 PG176.2 PG178.2 PG180.2 PT27.1 PU44.8 PU44.9 PU44.10 PU44.11 PU44.12 PU44.13 PU44.14 PU44.42
PWR_DCBATOUT_VDDCD: C1158.1 PC306.1 PG156.2 PG158.2 PG160.2 PT28.1 PU41.8 PU41.9 PU41.10 PU41.11 PU41.12 PU41.13 PU41.14 PU41.42
PWR_DCBATOUT_VDDCE: C2524.1 PC314.1 PC315.1 PC491.1 PC492.1 PC493.1 PC494.1 PG166.2 PG168.2 PG170.2 PU43.8 PU43.9 PU43.10 PU43.11 PU43.12 PU43.13 PU43.14 PU43.42
PWR_DCBATOUT_VDDCF: C2523.1 PC345.1 PC346.1 PC495.1 PC496.1 PC497.1 PC498.1 PG175.2 PG177.2 PG179.2 PU45.8 PU45.9 PU45.10 PU45.11 PU45.12 PU45.13 PU45.14 PU45.42
PWR_DCBATOUT_VDDCI: PC363.1 PC364.1 PG185.2 PG186.2 PG187.2 PT41.1 PU46.8 PU46.9 PU46.10 PU46.11 PU46.12 PU46.13 PU46.14 PU46.42
PWR_DCBATOUT_VDDNBA: C1155.1 PC163.1 PC164.1 PC165.1 PC166.1 PC167.1 PC168.1 PG53.2 PG54.2 PG55.2 PU19.5 PU19.6 PU19.7 PU19.8 PU20.5 PU20.6 PU20.7 PU20.8
PWR_DCBATOUT_VDDNBB: C1156.1 PC172.1 PC173.1 PC174.1 PC175.1 PG58.2 PG59.2 PG60.2 PU24.5 PU24.6 PU24.7 PU24.8 PU25.5 PU25.6 PU25.7 PU25.8
PWR_DCBATOUT_VDDP: PC216.1 PC217.1 PC218.1 PC411.1 PC412.1 PG106.2 PG109.2 PG112.2 PR184.1 PU32.7 PU32.8 PU32.9
PWR_DCBATOUT_VDDQ: PC180.1 PC181.1 PC182.1 PC183.1 PC184.1 PC185.1 PG63.2 PG64.2 PG66.2 PQ3.5 PQ3.6 PQ3.7 PQ3.8 PQ4.5 PQ4.6 PQ4.7 PQ4.8 PR168.1
PWR_VCCDDC_SENSE_A: PC287.1 PC289.1 PR251.2 PR252.1 PR253.2
PWR_VCCDDC_SENSE_B: PR253.1 PU39.40
PWR_VCCDDCI_SENSE_A: PC295.1 PC296.1 PR260.2 PR261.2 PR262.2
PWR_VCCDDCI_SENSE_B: PR262.1 PU39.23
PWR_VCORE_COMP: PC131.1 PC133.1 PC134.1 PR108.1 PU6.22
PWR_VCORE_EN: PR94.2 PU6.9
PWR_VCORE_FB: PC133.2 PR103.1 PR105.2 PR106.2 PR107.2 PU6.21
PWR_VCORE_FB2: PC131.2 PU6.20
PWR_VCORE_FB_A: PC134.2 PR105.1
PWR_VCORE_FB_B: PC138.1 PR107.1
PWR_VCORE_FB_C: PC132.1 PR103.2
PWR_VCORE_IMON: PC130.1 PR98.1 PU6.11
PWR_VCORE_ISEN1: PC137.2 PR126.1 PR131.1 PR140.1 PU6.15
PWR_VCORE_ISEN2: PC506.2 PR104.1 PR122.1 PR135.1 PR141.1 PU6.14
PWR_VCORE_ISEN3: PC135.2 PR102.1 PR123.1 PR132.1 PR144.1 PU6.13
PWR_VCORE_ISUMN: PC144.1 PR116.1 PU6.17
PWR_VCORE_ISUMN_A: PC144.2 PR117.1
PWR_VCORE_NTC: PR97.1 PR99.2 PU6.12
PWR_VCORE_NTC_A: PR97.2 PR99.1 PR100.1
PWR_VCORE_PG: D7.1 PR101.2 PU6.23 R374.2
PWR_VCORE_RTN: PC141.1 PR114.1 PU6.19
PWR_VCORE_SVC: PR85.2 PU6.4
PWR_VCORE_SVD: PR87.2 PU6.6
PWR_VCORE_SVT: PR91.2 PU6.8
PWR_VCORE_VDD: PC128.1 PR92.2 PU6.29
PWR_VCORE_VDDIO: PR90.2 PU6.7
PWR_VCORE_VIN: PC125.2 PR83.2 PU6.35
PWR_VCORE_VRHOT: PR86.2 PU6.5
PWR_VCORE_VSEB: PC132.2 PC142.1 PR106.1 PR112.1 PU6.18
PWR_VCORE_VSUM_N: PC135.1 PC137.1 PC139.2 PC140.2 PC143.1 PC506.1 PR111.2 PR113.1 PR116.2 PR117.2 PR124.1 PR133.1 PR142.1
PWR_VCORE_VSUM_P: PC139.1 PC140.1 PR109.1 PR111.1 PR125.1 PR134.1 PR143.1 PU6.16
PWR_VCOREA_BOOT: PR120.2 PU6.24
PWR_VCOREA_BOOT_A: PC149.2 PR120.1
PWR_VCOREA_HG: PR118.2 PU6.25
PWR_VCOREA_HG_A: PR118.1 PR119.1 PU7.4 PU8.4
PWR_VCOREA_LG: PU6.27 PU9.4 PU10.4
PWR_VCOREA_PH: PC149.1 PG42.1 PL3.1 PR119.2 PR121.1 PU6.26 PU7.1 PU7.2 PU7.3 PU8.1 PU8.2 PU8.3 PU9.5 PU9.6 PU9.7 PU9.8 PU10.5 PU10.6 PU10.7 PU10.8
PWR_VCOREA_SNB: PC150.1 PR121.2
PWR_VCOREA_VSUM_N_A: PG41.2 PR122.2 PR123.2 PR124.2
PWR_VCOREA_VSUM_P_A: PG42.2 PR125.2 PR126.2
PWR_VCOREB_BOOT: PR128.2 PU6.34
PWR_VCOREB_BOOT_A: PC155.2 PR128.1
PWR_VCOREB_HG: PR127.2 PU6.33
PWR_VCOREB_HG_A: PR127.1 PR130.1 PU11.4 PU12.4
PWR_VCOREB_LG: PU6.31 PU13.4 PU14.4
PWR_VCOREB_PH: PC155.1 PG47.1 PL4.1 PR129.1 PR130.2 PU6.32 PU11.1 PU11.2 PU11.3 PU12.1 PU12.2 PU12.3 PU13.5 PU13.6 PU13.7 PU13.8 PU14.5 PU14.6 PU14.7 PU14.8
PWR_VCOREB_SNB: PC156.1 PR129.2
PWR_VCOREB_VSUM_N_A: PG46.2 PR131.2 PR132.2 PR133.2
PWR_VCOREB_VSUM_P_A: PG47.2 PR134.2 PR135.2
PWR_VCOREC_BOOT: PR137.2 PU6.36
PWR_VCOREC_BOOT_A: PC161.1 PR137.1
PWR_VCOREC_HG: PR136.2 PU6.37
PWR_VCOREC_HG_A: PR136.1 PR139.1 PU15.4 PU16.4
PWR_VCOREC_LG: PU6.39 PU17.4 PU18.4
PWR_VCOREC_PH: PC161.2 PG51.1 PL5.1 PR138.1 PR139.2 PU6.38 PU15.1 PU15.2 PU15.3 PU16.1 PU16.2 PU16.3 PU17.5 PU17.6 PU17.7 PU17.8 PU18.5 PU18.6 PU18.7 PU18.8
PWR_VCOREC_SNB: PC162.1 PR138.2
PWR_VCOREC_VSUM_N_A: PG52.2 PR140.2 PR141.2 PR142.2
PWR_VCOREC_VSUM_P_A: PG51.2 PR143.2 PR144.2
PWR_VDDC_ADDRESS: PR249.1 PU39.41
PWR_VDDC_CONFIG: PR258.2 PU39.21
PWR_VDDC_EN: PG228.1 PR235.1 PU39.13
PWR_VDDC_PALERT#: PR247.1 PU39.20
PWR_VDDC_PCLK: PR245.1 PU39.18
PWR_VDDC_PDATA: PR246.1 PU39.19
PWR_VDDC_PG: PR405.1 PU39.16
PWR_VDDC_PG_A: PR231.2 PR345.2 PR405.2 TP122.1
PWR_VDDC_SALERT#: PR243.1 PU39.9
PWR_VDDC_SCLK: PR237.1 PU39.8
PWR_VDDC_SDATA: PR238.1 PU39.10
PWR_VDDC_TEMP: PC298.1 PR265.2 PU39.44
PWR_VDDC_TEMP_A: PC299.1 PQ9.B PQ9.C PR265.1
PWR_VDDC_TEMP_B: PC299.2 PQ9.E PR266.1
PWR_VDDC_THWN: PG228.2 PR281.2 PR282.2 PR295.2 PR296.2 PR309.2 PR310.2
PWR_VDDC_VCC: PC274.1 PR221.2 PU39.42
PWR_VDDC_VCCS: PC275.1 PC298.2 PC300.2 PR266.2 PR268.2 PU39.43
PWR_VDDC_VDDIO: PR239.1 PU39.11
PWR_VDDC_VINSEN: PC278.1 PR233.1 PR234.1 PU39.22
PWR_VDDC_VRHOT: PR240.1 PU39.15
PWR_VDDCA_BOOT: PC309.1 PU40.4
PWR_VDDCA_BOOT_A: PC309.2 PR275.1
PWR_VDDCA_EN_A: PR277.1 PU40.39
PWR_VDDCA_ISEN_N: PC293.1 PC294.1 PG162.1 PU39.37
PWR_VDDCA_ISEN_P: PG161.1 PR259.2
PWR_VDDCA_ISEN_P_A: PC294.2 PR259.1 PU39.38
PWR_VDDCA_PH: PG161.2 PL14.1 PR271.1 PR275.2 PU40.7 PU40.15 PU40.29 PU40.30 PU40.31 PU40.32 PU40.33 PU40.34 PU40.35 PU40.43
PWR_VDDCA_PWM: PR279.2 PU39.1
PWR_VDDCA_PWM_A: PR279.1 PU40.40
PWR_VDDCA_SMOD#: PR273.1 PU40.1
PWR_VDDCA_SNB: PC310.1 PR271.2
PWR_VDDCA_THWN#: PR281.1 PU40.38
PWR_VDDCB_BOOT: PC330.1 PU42.4
PWR_VDDCB_BOOT_A: PC330.2 PR290.1
PWR_VDDCB_EN_A: PR292.1 PU42.39
PWR_VDDCB_ISEN_N: PC291.1 PC292.1 PG172.1 PU39.35
PWR_VDDCB_ISEN_P: PG171.1 PR257.2
PWR_VDDCB_ISEN_P_A: PC292.2 PR257.1 PU39.36
PWR_VDDCB_PH: PG171.2 PL16.1 PR285.1 PR290.2 PU42.7 PU42.15 PU42.29 PU42.30 PU42.31 PU42.32 PU42.33 PU42.34 PU42.35 PU42.43
PWR_VDDCB_PWM: PR294.2 PU39.2
PWR_VDDCB_PWM_A: PR294.1 PU42.40
PWR_VDDCB_SMOD#: PR288.1 PU42.1
PWR_VDDCB_SNB: PC332.1 PR285.2
PWR_VDDCB_THWN#: PR295.1 PU42.38
PWR_VDDCC_BOOT: PC359.1 PU44.4
PWR_VDDCC_BOOT_A: PC359.2 PR303.1
PWR_VDDCC_EN_A: PR305.1 PU44.39
PWR_VDDCC_ISEN_N: PC286.1 PC288.1 PG182.1 PU39.33
PWR_VDDCC_ISEN_P: PG181.1 PR255.2
PWR_VDDCC_ISEN_P_A: PC288.2 PR255.1 PU39.34
PWR_VDDCC_PH: PG181.2 PL18.1 PR299.1 PR303.2 PU44.7 PU44.15 PU44.29 PU44.30 PU44.31 PU44.32 PU44.33 PU44.34 PU44.35 PU44.43
PWR_VDDCC_PWM: PR307.2 PU39.3
PWR_VDDCC_PWM_A: PR307.1 PU44.40
PWR_VDDCC_SMOD#: PR301.1 PU44.1
PWR_VDDCC_SNB: PC361.1 PR299.2
PWR_VDDCC_THWN#: PR309.1 PU44.38
PWR_VDDCD_BOOT: PC311.1 PU41.4
PWR_VDDCD_BOOT_A: PC311.2 PR276.1
PWR_VDDCD_EN_A: PR278.1 PU41.39
PWR_VDDCD_ISEN_N: PC284.1 PC285.1 PG164.1 R2767.2
PWR_VDDCD_ISEN_N_A: PR414.1 PU39.31 R2767.1
PWR_VDDCD_ISEN_P: PG163.1 PR250.2
PWR_VDDCD_ISEN_P_A: PC284.2 PR250.1 PR413.1 PU39.32
PWR_VDDCD_PH: PG163.2 PL15.1 PR272.1 PR276.2 PU41.7 PU41.15 PU41.29 PU41.30 PU41.31 PU41.32 PU41.33 PU41.34 PU41.35 PU41.43
PWR_VDDCD_PWM: PR280.2 PU39.4
PWR_VDDCD_PWM_A: PR280.1 PU41.40
PWR_VDDCD_SMOD#: PR274.1 PU41.1
PWR_VDDCD_SNB: PC312.1 PR272.2
PWR_VDDCD_THWN#: PR282.1 PU41.38
PWR_VDDCE_BOOT: PC329.1 PU43.4
PWR_VDDCE_BOOT_A: PC329.2 PR289.1
PWR_VDDCE_EN_A: PR291.1 PU43.39
PWR_VDDCE_ISEN_N: PC282.2 PC283.1 PG174.1 R2768.2
PWR_VDDCE_ISEN_N_A: PR416.1 PU39.29 R2768.1
PWR_VDDCE_ISEN_P: PG173.1 PR248.2
PWR_VDDCE_ISEN_P_A: PC282.1 PR248.1 PR415.1 PU39.30
PWR_VDDCE_PH: PG173.2 PL17.1 PR286.1 PR289.2 PU43.7 PU43.15 PU43.29 PU43.30 PU43.31 PU43.32 PU43.33 PU43.34 PU43.35 PU43.43
PWR_VDDCE_PWM: PR293.2 PU39.5
PWR_VDDCE_PWM_A: PR293.1 PU43.40
PWR_VDDCE_SMOD#: PR287.1 PU43.1
PWR_VDDCE_SNB: PC331.1 PR286.2
PWR_VDDCE_THWN#: PR296.1 PU43.38
PWR_VDDCF_BOOT: PC360.1 PU45.4
PWR_VDDCF_BOOT_A: PC360.2 PR304.1
PWR_VDDCF_EN_A: PR306.1 PU45.39
PWR_VDDCF_ISEN_N: PC280.1 PC281.1 PG184.1 R2769.2
PWR_VDDCF_ISEN_N_A: PR418.1 PU39.27 R2769.1
PWR_VDDCF_ISEN_P: PG183.1 PR244.2
PWR_VDDCF_ISEN_P_A: PC280.2 PR244.1 PR417.1 PU39.28
PWR_VDDCF_PH: PG183.2 PL19.1 PR300.1 PR304.2 PU45.7 PU45.15 PU45.29 PU45.30 PU45.31 PU45.32 PU45.33 PU45.34 PU45.35 PU45.43
PWR_VDDCF_PWM: PR308.2 PU39.6
PWR_VDDCF_PWM_A: PR308.1 PU45.40
PWR_VDDCF_SMOD#: PR302.1 PU45.1
PWR_VDDCF_SNB: PC362.1 PR300.2
PWR_VDDCF_THWN#: PR310.1 PU45.38
PWR_VDDCI_BOOT: PC367.1 PU46.4
PWR_VDDCI_BOOT_A: PC367.2 PR314.1
PWR_VDDCI_EN: PG229.1 PR404.1 PU39.14
PWR_VDDCI_EN_A: PR315.1 PU46.39
PWR_VDDCI_ISEN_N: PC277.1 PC279.1 PG189.1 PU39.25
PWR_VDDCI_ISEN_P: PG188.1 PR242.2
PWR_VDDCI_ISEN_P_A: PC279.2 PR242.1 PU39.26
PWR_VDDCI_PG: PR236.1 PU39.17
PWR_VDDCI_PG_A: PR236.2 PR406.2 TP123.1
PWR_VDDCI_PH: PG188.2 PL20.1 PR312.1 PR314.2 PU46.7 PU46.15 PU46.29 PU46.30 PU46.31 PU46.32 PU46.33 PU46.34 PU46.35 PU46.43
PWR_VDDCI_PWM: PR316.2 PU39.7
PWR_VDDCI_PWM_A: PR316.1 PU46.40
PWR_VDDCI_SMOD#: PR313.1 PU46.1
PWR_VDDCI_SNB: PC371.1 PR312.2
PWR_VDDCI_TEMP: PC300.1 PR267.2 PU39.45
PWR_VDDCI_TEMP_A: PC301.1 PQ10.B PQ10.C PR267.1
PWR_VDDCI_TEMP_B: PC301.2 PQ10.E PR268.1
PWR_VDDCI_THWN: PG229.2 PR317.2
PWR_VDDCI_THWN#: PR317.1 PU46.38
PWR_VDDNB_COMP: PC115.1 PC117.1 PR74.1 PU6.43
PWR_VDDNB_FB: PC117.2 PR68.2 PR69.2 PR70.2 PR73.1 PU6.44
PWR_VDDNB_FB_A: PC116.1 PR73.2
PWR_VDDNB_FB_B: PC114.2 PR68.1
PWR_VDDNB_FB_C: PC115.2 PR70.1
PWR_VDDNB_FCCM: PR81.1 PU6.41 PU21.7
PWR_VDDNB_IMON: PC126.1 PR89.1 PU6.3
PWR_VDDNB_ISEN1: PC123.1 PR153.1 PR159.1 PU6.48
PWR_VDDNB_ISEN2: PC124.1 PR84.1 PR150.1 PR162.1 PU6.1
PWR_VDDNB_ISUMN: PC121.1 PR79.2 PU6.46
PWR_VDDNB_ISUMN_A: PC121.2 PR80.1
PWR_VDDNB_NTC: PR82.1 PR88.2 PU6.2
PWR_VDDNB_NTC_A: PR82.2 PR88.1 PR95.1
PWR_VDDNB_VSEN: PC116.2 PC119.1 PR69.1 PR72.2 PU6.45
PWR_VDDNB_VSUM_A: PR75.2 PR77.2
PWR_VDDNB_VSUMN: PC118.2 PC120.2 PC122.1 PC123.2 PC124.2 PR76.2 PR77.1 PR79.1 PR80.2 PR151.1 PR160.1
PWR_VDDNB_VSUMP: PC118.1 PC120.1 PR75.1 PR76.1 PR152.1 PR161.1 PU6.47
PWR_VDDNBA_BOOT: PR146.1 PU21.2
PWR_VDDNBA_BOOT_A: PC170.1 PR146.2
PWR_VDDNBA_HG: PR147.1 PU21.1
PWR_VDDNBA_HG_A: PR147.2 PR148.1 PU19.4 PU20.4
PWR_VDDNBA_LG: PU21.5 PU22.4 PU23.4
PWR_VDDNBA_PH: PC170.2 PG56.1 PL6.1 PR148.2 PR149.1 PU19.1 PU19.2 PU19.3 PU20.1 PU20.2 PU20.3 PU21.8 PU22.5 PU22.6 PU22.7 PU22.8 PU23.5 PU23.6 PU23.7 PU23.8
PWR_VDDNBA_PWM: PU6.28 PU21.3
PWR_VDDNBA_VCC: PC169.1 PR145.2 PU21.6
PWR_VDDNBA_VSUMN_A: PG57.2 PR150.2 PR151.2
PWR_VDDNBA_VSUMP_A: PG56.2 PR152.2 PR153.2
PWR_VDDNBB_BOOT: PR155.1 PU26.2
PWR_VDDNBB_BOOT_A: PC176.1 PR155.2
PWR_VDDNBB_HG: PR156.1 PU26.1
PWR_VDDNBB_HG_A: PR156.2 PR157.1 PU24.4 PU25.4
PWR_VDDNBB_LG: PU26.5 PU27.4 PU28.4
PWR_VDDNBB_PH: PC176.2 PG61.1 PL7.1 PR157.2 PR158.1 PU24.1 PU24.2 PU24.3 PU25.1 PU25.2 PU25.3 PU26.8 PU27.5 PU27.6 PU27.7 PU27.8 PU28.5 PU28.6 PU28.7 PU28.8
PWR_VDDNBB_PWM: PU6.40 PU26.3
PWR_VDDNBB_SNB: PC178.1 PR158.2
PWR_VDDNBB_VCC: PC177.1 PR154.2 PU26.6 PU26.7
PWR_VDDNBB_VSUMN_A: PG62.2 PR159.2 PR160.2
PWR_VDDNBB_VSUMP_A: PG61.2 PR161.2 PR162.2
PWR_VDDP: PC210.1 PC211.1 PC212.1 PC213.1 PC214.1 PC215.1 PC219.1 PC410.1 PC422.1 PC423.1 PC427.1 PG107.1 PG108.1 PG110.2 PG111.1 PG113.1 PG114.1 PG115.1 PG116.1 PG117.1 PG118.1 PG119.1 PL10.2 PR352.1 PU53.3 PU53.4
PWR_VDDP_BT: PC209.2 PU32.20
PWR_VDDP_EN: PC426.1 PC430.1 PR361.2 PR362.2 PR384.1 PU32.2 PU53.8
PWR_VDDP_FB: PC220.2 PR185.2 PR187.1 PR350.1 PU32.5
PWR_VDDP_FB_A: PC220.1 PG110.1 PR185.1
PWR_VDDP_FB_B: PR350.2 PU52.6
PWR_VDDP_FB_C: PR394.2 PU52.2 PU52.3
PWR_VDDP_PFM: PR186.1 PU32.3
PWR_VDDP_PG: PR334.1 PU32.1
PWR_VDDP_PH: PC209.1 PL10.1 PU32.10 PU32.11 PU32.16 PU32.17 PU32.18
PWR_VDDP_SS: PC221.1 PU32.22
PWR_VDDP_TON: PR184.2 PU32.6
PWR_VDDQ_BOOT: PR167.1 PU29.18
PWR_VDDQ_BOOT_A: PC187.1 PR167.2
PWR_VDDQ_CS: PR165.1 PU29.13
PWR_VDDQ_EN: PC196.1 PR172.2 PU29.8
PWR_VDDQ_EN_R: C463.1 PR172.1 R393.2
PWR_VDDQ_FB: PC192.2 PR170.2 PR171.1 PU29.6
PWR_VDDQ_HG: PQ3.4 PQ4.4 PU29.17
PWR_VDDQ_LG: PQ5.4 PQ6.4 PU29.15
PWR_VDDQ_PG: KBC1.101 PR166.2 PU29.10
PWR_VDDQ_PH: PC187.2 PL8.1 PQ3.1 PQ3.2 PQ3.3 PQ4.1 PQ4.2 PQ4.3 PQ5.5 PQ5.6 PQ5.7 PQ5.8 PQ6.5 PQ6.6 PQ6.7 PQ6.8 PR169.1 PU29.16
PWR_VDDQ_SNUB: PC191.1 PR169.2
PWR_VDDQ_TON: PR168.2 PU29.9
PWR_VDDQ_VDD: PC186.1 PR164.1 PU29.12
PWR_VDDQ_VDDQ: PC192.1 PG77.1 PR170.1 PU29.5
PWR_VDDQ_VID: PC179.1 PR163.1 PU29.11
PWR_VDDQ_VLDOIN: PC188.1 PG72.2 PG74.2 PU29.19
PWR_VDDQ_VTT: PC193.1 PC194.1 PG80.2 PG82.2 PU29.2 PU29.20
PWR_VDDQ_VTTREF: PC195.1 PU29.4
PWR_VGA_PG: PC507.1 PR344.2 PR345.1 PR419.2 PU39.12
PWR_VR_PG: PR96.2 PU6.10
PWR_VSSDDC_SENSE_A: PC287.2 PC290.1 PR254.1 PR256.1 PU39.39
PWR_VSSDDCI_SENSE_A: PC295.2 PC297.1 PR263.2 PR264.1 PU39.24
PWR_VSUM_1: PR109.2 PR113.2
PWR_VTT_EN: PR174.2 PU29.7
PWR_VTT_EN_R: C464.1 PR174.1 R396.2
PWRBTN_N: C518.1 R452.2 R2432.1
PWRBTN_N_R: C1017.1 R237.1 R2432.2 R2470.2
PWRCN_DET_EC: KBC1.72 OSDC1.1 R2495.1
PWRGD_3V_N: Q14.G R232.1
PX_EN: C592.1 GPU1.V40 R476.1 R1200.1
PX_EN_G: Q55.G R1200.2 R1201.2
PX_ENB: C952.1 Q55.D R1197.2 R1198.1
RASA0B: GPU1.P33 VRAMA1.G3
RASA1B: GPU1.M35 VRAMA2.L3
RASB0B: GPU1.K20 VRAMB1.G3
RASB1B: GPU1.M20 VRAMB2.L3
RASC0B: GPU1.Y12 VRAMC1.G3
RASC1B: GPU1.Y10 VRAMC2.L3
RASD0B: GPU1.AR12 VRAMD1.G3
RASD1B: GPU1.AN14 VRAMD2.L3
RDISPLAY1_DET_EC: DISPC1.1 KBC1.105 R2481.1
RDISPLAY2_DET_EC: DISPC2.1 KBC1.63 R2580.2
RING2_CON: C340.1 L11.2 SUSBC1.21 SUSBC1.23
RLAN_AUDIO_DET_EC: KBC1.107 LAUOC1.40 R2483.1
RPWR_CN1_DET_EC: KBC1.52 R2485.1 RPWRC1.1
RSMRST#_CPU: CPU1.AP5 Q72.6 R368.2
RSMRST_H: Q72.2 Q72.3 R2715.2
RSMRST_SIO_N: KBC1.20 R369.1 R2716.1 R2717.2
RSMRST_SIO_R: C440.1 Q72.5 R369.2
RST#_CPU: CPU1.B16 HDT1.12 R18.2
RTC_DET#: KBC1.17 Q16.D RN44.2(A)
RTYPEC_DET_EC: KBC1.106 R2482.1 TYPEC1.1
RUSB3_DET_EC: KBC1.59 R2484.1 RUSBC1.1
S5_ENABLE: KBC1.14 Q10.D R179.2 R199.2
S5_MUX_APU: CPU1.AP4 R379.2 U17.6
SA0_DIMM1: DIMM1.256 R98.1 R102.2
SA0_DIMM2: DIMM2.256 R111.1 R114.2
SA1_DIMM1: DIMM1.260 R99.1 R103.2
SA1_DIMM2: DIMM2.260 R112.1 R115.2
SA2_DIMM1: DIMM1.166 R100.1 R104.2
SA2_DIMM2: DIMM2.166 R113.1 R116.2
SATA__RXN0_C: C473.2 HDD1.5
SATA__RXP0_C: C474.2 HDD1.6
SATA__TXN0_C: C472.2 HDD1.3
SATA__TXP0_C: C471.2 HDD1.2
SATA_RXN0_C_N: C473.1 L26.1
SATA_RXP0_C_N: C474.1 L26.4
SATA_TXN0_C_N: C472.1 L25.4
SATA_TXP0_C_N: C471.1 L25.1
SATA_ZVDDP: CPU1.AV7 R2.2
SATA_ZVSS: CPU1.AV6 R6.1
SATAHDR_RX_DN0: L26.2 PCH1.D15
SATAHDR_RX_DP0: L26.3 PCH1.E15
SATAHDR_TX_DN0: L25.3 PCH1.B15
SATAHDR_TX_DP0: L25.2 PCH1.A15
SATASSD_RX_DN1: PCH1.D16 U26.14
SATASSD_RX_DP1: PCH1.E16 U26.15
SATASSD_TX_DN1: C514.1 PCH1.B16
SATASSD_TX_DN1_C: C514.2 U26.12
SATASSD_TX_DP1: C513.1 PCH1.A16
SATASSD_TX_DP1_C: C513.2 U26.13
SDCARD_DET_EC: KBC1.28 R2491.1 SDRDC1.1
SE_BJT_B1: R390.2 U20.5
SE_BJT_B2: C461.1 R388.2 R391.2 R392.1
SE_BJT_B3: R391.1 U20.2
SE_VDDQ_EN: R393.1 U21.4
SE_VPP_EN: Q23.C R389.1 RN17.3(B)
SE_VPP_EN_B: Q23.B RN17.4(B) U20.3 U20.6
SEN_A0: R678.1 VRAMA1.J10
SEN_A1: R679.1 VRAMA2.J10
SEN_B0: R640.1 VRAMB1.J10
SEN_B1: R635.1 VRAMB2.J10
SEN_C0: R682.1 VRAMC1.J10
SEN_C1: R707.1 VRAMC2.J10
SEN_D0: R634.1 VRAMD1.J10
SEN_D1: R663.1 VRAMD2.J10
SIO_EUP_EN#: PR66.1 PR67.1 R173.2
SIO_GREEN_PWM: KBC1.16 OSDC1.4
SIO_PME_N: CPU1.AL2 R154.2 R2435.1 U1.D
SIO_SMCLK0: KBC1.67 Q15.6 Q75.6 Q76.3 RN12.3(B)
SIO_SMDAT0: KBC1.68 Q15.3 Q75.3 Q76.6 RN12.4(B)
SIO_YELLOW: KBC1.47 OSDC1.5
SLEEVE_CON: C341.1 L10.2 SUSBC1.22 SUSBC1.24
SLP_S3_N: CPU1.AT2 LAUOC1.10 PR201.1 R333.2 R346.2 R396.1 R861.1 R1218.1 R2472.1
SLP_S3_N_EC: KBC1.64 R2472.2
SLP_S5_N: CPU1.AP2 Q25.5 R335.2 R342.1 R349.2 R357.1 R390.1 R2416.2 TP101.1 U21.1
SLP_S5_N_EC: KBC1.21 R2416.1
SM_A_DRAMRST#: CPU1.L33 R14.2 R15.2
SM_A_DRAMRST#_R: C151.1 D1.1 DIMM1.108 R15.1
SM_B_DRAMRST#: CPU1.K35 R8.2 R2499.2 R2500.2
SM_B_DRAMRST#_R: C1042.1 D12.1 DIMM2.108 R2500.1
SMB_CLK_MAIN: CPU1.AU25 DIMM1.253 DIMM2.253 RN4.4(B) TP99.1
SMB_DATA_MAIN: CPU1.AV25 DIMM1.254 DIMM2.254 RN4.3(B) TP102.1
SMBUS_ISP: KBC1.50 LAUOC1.9
SML1_CLK_SIO: PCH1.E8 RN7.2(A)
SML1_DATA_SIO: PCH1.F8 RN7.1(A)
SPI_CLK: R94.1 RN42.4(B) SRCON1.6 U4.6
SPI_CLK_CPU: CPU1.AW14 R94.2 R2633.1
SPI_CS0_N: R2663.2 R2664.1 RN42.3(B) SRCON1.1 U4.1
SPI_CS0_N_CPU: CPU1.AT17 R2664.2
SPI_CS2_CPU: CPU1.AW15 R83.1
SPI_IO2: R243.1 R2665.1 RN16.4(B) SRCON1.3 U4.3
SPI_IO2_CPU: CPU1.AV16 R2665.2
SPI_IO3: R2666.1 RN16.3(B) SRCON1.7 U4.7
SPI_IO3_CPU: CPU1.AV15 R2666.2
SPI_MISO: R95.1 RN43.4(B) SRCON1.2 U4.2
SPI_MISO_CPU: CPU1.AU14 R95.2
SPI_MOSI: R96.1 RN43.3(B) SRCON1.5 U4.5
SPI_SO_CPU_R: CPU1.AU16 R96.2
SPKR: CPU1.AW23 R271.2 R2461.1
SPKR_DET: KBC1.48 R873.1
SPKR_DET_C: R873.2 R2604.1 SPK1.1
SSD_DEVSLP_N: PCH1.C23 Q34.D R436.2
SSD_PM_PCIE_WAKE#: R439.1 SSDC1.54
SSON#: R560.2 R562.1 U29.5
STRAP_LPC_CLK_CPU_P0: C2528.1 CPU1.AU20 R93.2 R144.2 TP95.1
STRAP_LPC_CLK_CPU_P1: C2527.1 CPU1.AU19 R92.2 R121.1 TP96.1
SUS_CLK_CPU: CPU1.AP8 R128.1 R2760.2
SUS_CLK_CPU_EN: C2514.1 Q83.D Q84.G Q85.G R2759.2
SUS_CLK_CPU_PWR: Q84.S Q85.S R2760.1
SUSB_DET_EC: KBC1.26 R2492.1 SUSBC1.2
SUSCLK: KBC1.77 R2536.1
SUSCLK_NGFF: R2477.2 WLAN1.50
SVCLK: GPU1.AM23 PR230.2 PR237.2 R2641.1
SVDATA: GPU1.AP23 PR228.2 PR238.2 R2640.1
SVID_CLK: PR85.1 R27.2
SVID_CLK_CPU: CPU1.D17 R27.1
SVID_DATA: PR87.1 R28.2
SVID_DATA_CPU: CPU1.C17 R28.1
SVID_PWRGD: CPU1.E16 HDT1.10 PR96.1 R19.2
SVID_SVT: CPU1.A17 PR91.1 R22.2
SW_CMOS: CPU1.AT18 TP100.1
SW_ON_N_SIO: KBC1.117 R2454.1
SYS_FAN_TACH1_1: FANC1.3 R254.2 R257.1
SYS_FAN_TACH1_2: R257.2 R258.1 R260.2
SYS_RESET_L: CPU1.AM4 R2632.1
SYSTEM_FAN_PWM1_1: D5.A FANC1.4 R251.2 R253.2
T_CRIT#: R230.1 R233.2 U2.4
TEST0_APU: CPU1.AM6 R58.1
TEST1_APU: CPU1.AM7 R59.1
TEST2_APU: CPU1.AT3 R57.1
TEST18_APU: CPU1.G16 HDT1.20 RN2413.4(B)
TEST19_APU: CPU1.H16 HDT1.18 RN2413.3(B)
TEST46: CPU1.AL4 TP141.1
TESTEN: GPU1.AE30 R519.2 R523.1 TP111.1
THERM_SYS_SHDN#: Q14.S R230.2
THERMTRIP_L_CPU: CPU1.A19 Q71.S R21.2 R2708.1
THERMTRIP_L_CPU_EC: KBC1.83 Q71.D R2706.1 R2708.2
TOUCH_DET: KBC1.124 R430.2 TOUCH1.1
TP_ANALOGIO: GPU1.AW42 R2534.1 TP65.1
TP_BBR#: CPU1.AU23 TP113.1
TP_CHAR_STATUS_REAR: TP34.1 U12.9
TP_CHAR_STATUS_SIDE: TP33.1 U10.9
TP_CLINK_CLK_LAN: TP72.1 WLAN1.42
TP_CLINK_DATA_LAN: TP73.1 WLAN1.40
TP_CLINK_RST_LAN_N: TP74.1 WLAN1.38
TP_DBGDATA_0: GPU1.AV18 R551.2 R553.1 TP47.1
TP_DBGDATA_1: GPU1.AW18 R549.1 R550.1 TP48.1
TP_DBGDATA_2: GPU1.AT19 R547.1 R548.1 TP49.1
TP_DBGDATA_3: GPU1.AV19 R545.1 R546.1 R2725.1 TP50.1
TP_DBGDATA_3_R: R2725.2 U23.15
TP_DBGDATA_4: GPU1.AW19 R543.1 R544.1 R2726.1 TP51.1
TP_DBGDATA_4_R: R2726.2 U23.14
TP_DBGDATA_5: GPU1.AR20 R541.1 R542.1 R2727.1 TP52.1
TP_DBGDATA_5_R: R2727.2 U23.13
TP_DBGDATA_6: GPU1.AT20 R2776.2
TP_DBGDATA_7: GPU1.AY20 R2777.2
TP_DBGDATA_8: GPU1.AW20 TP55.1
TP_DBGDATA_9: GPU1.AU20 TP56.1
TP_DBGDATA_10: GPU1.AN21 TP57.1
TP_DBGDATA_11: GPU1.AP21 TP58.1
TP_DBGDATA_12: GPU1.AW21 TP59.1
TP_DBGDATA_13: GPU1.AV21 TP60.1
TP_DBGDATA_14: GPU1.AU21 TP61.1
TP_DBGDATA_15: GPU1.AR21 TP62.1
TP_DP_AUXN: TP80.1 WLAN1.20
TP_DP_AUXP: TP79.1 WLAN1.22
TP_DP_HPD: TP88.1 WLAN1.31
TP_DP_ML0N: TP76.1 WLAN1.32
TP_DP_ML0P: TP75.1 WLAN1.34
TP_DP_ML1N: TP78.1 WLAN1.26
TP_DP_ML1P: TP77.1 WLAN1.28
TP_DP_ML2N: TP90.1 WLAN1.25
TP_DP_ML2P: TP89.1 WLAN1.27
TP_DP_ML3N: TP92.1 WLAN1.19
TP_DP_ML3P: TP91.1 WLAN1.21
TP_ESPI_ALERT_L: CPU1.AT15 TP104.1
TP_GPU_GPIO_0: GPU1.V39 R505.2 R506.2 TP39.1
TP_GPU_GPIO_2: GPU1.W37 R509.2 R510.1 TP40.1
TP_GPU_GPIO_16: GPU1.AJ33 TP41.1
TP_LPC_PD: CPU1.AV18 R2762.2 TP12.1
TP_NGFF_COEX1: TP69.1 WLAN1.48
TP_NGFF_COEX2: TP70.1 WLAN1.46
TP_NGFF_COEX3: TP71.1 WLAN1.44
TP_NGFF_LED1: TP38.1 WLAN1.6
TP_NGFF_LED2: TP81.1 WLAN1.16
TP_NGFF_MLDIR: TP93.1 WLAN1.17
TP_NGFF_PCIE1_RXN: TP84.1 WLAN1.67
TP_NGFF_PCIE1_RXP: TP85.1 WLAN1.65
TP_NGFF_PCIE1_TXN: TP86.1 WLAN1.61
TP_NGFF_PCIE1_TXP: TP87.1 WLAN1.59
TP_NGFF_REFCLKN1: TP82.1 WLAN1.73
TP_NGFF_REFCLKP1: TP83.1 WLAN1.71
TP_PLLCHARZ_H: GPU1.AM29 TP63.1
TP_PLLCHARZ_L: GPU1.AN29 TP64.1
TP_SMB_CLK_MINI: TP114.1 WLAN1.60
TP_SMB_DATA_MINI: TP115.1 WLAN1.58
TP_TEST4: CPU1.L23 TP1.1
TP_TEST5: CPU1.M22 TP2.1
TP_TEST15: CPU1.B12 TP4.1
TP_TEST28_H: CPU1.E6 TP5.1
TP_TEST28_L: CPU1.E7 TP6.1
TP_TEST31: CPU1.AA30 TP7.1
TP_TEST40: CPU1.W30 TP8.1
TP_TEST41: CPU1.A16 TP10.1
TP_TEST47: CPU1.P28 TP3.1
TP_TS_A: GPU1.AA30 TP46.1
TSS_TEST6: GPU1.V14 R538.2
TYPE_C_CLK: R2694.2 R2698.1
TYPE_C_DATA: R2695.2 R2699.1
TYPEC_STATUS: KBC1.54 R2746.2 TYPEC1.39
U2506_CLKOUT: R2754.2 TP2503.1 U2505.7 U2506.7
U2506_INT#: R2753.2 TP2504.1 U2505.3 U2506.3
USB0_ZVSS: CPU1.AJ3 R86.2
USB1_ZVSS: CPU1.AN6 R1213.2
USB2_ZVSS: CPU1.AK6 R1214.2
USB3_ZVSS: CPU1.AK5 R1215.2
USB20_OC_CR1#: CPU1.AM1 R2781.1
USB30_RX_CPU_N0: CPU1.Y4 TYPEC1.24
USB30_RX_CPU_N1: CPU1.AA3 RUSBC1.7
USB30_RX_CPU_P0: CPU1.Y3 TYPEC1.25
USB30_RX_CPU_P1: CPU1.AA2 RUSBC1.6
USB30_RX_PCH_N0: PCH1.AC15 RUSBC1.13
USB30_RX_PCH_N1: PCH1.AB16 SUSBC1.3
USB30_RX_PCH_P0: PCH1.AB15 RUSBC1.12
USB30_RX_PCH_P1: PCH1.AC16 SUSBC1.5
USB30_TX_CPU_N0: CPU1.AF4 TYPEC1.21
USB30_TX_CPU_N1: CPU1.AC1 RUSBC1.4
USB30_TX_CPU_P0: CPU1.AF3 TYPEC1.22
USB30_TX_CPU_P1: CPU1.AB1 RUSBC1.3
USB30_TX_PCH_N0: PCH1.AE16 RUSBC1.16
USB30_TX_PCH_N1: PCH1.AE17 SUSBC1.9
USB30_TX_PCH_P0: PCH1.AF16 RUSBC1.15
USB30_TX_PCH_P1: PCH1.AF17 SUSBC1.11
USB31_RX_PCH_N0: PCH1.AA11 TYPEC1.31
USB31_RX_PCH_N1: PCH1.AB13 TYPEC1.36
USB31_RX_PCH_P0: PCH1.AB11 TYPEC1.30
USB31_RX_PCH_P1: PCH1.AC13 TYPEC1.37
USB31_TX_PCH_N0: PCH1.AF12 TYPEC1.28
USB31_TX_PCH_N1: PCH1.AF14 TYPEC1.34
USB31_TX_PCH_P0: PCH1.AE12 TYPEC1.27
USB31_TX_PCH_P1: PCH1.AE14 TYPEC1.33
USB_CON_PN4: TR2.1 WLAN1.5
USB_CON_PP4: TR2.4 WLAN1.3
USB_CPU_PN0: CPU1.AU8 TYPEC1.13
USB_CPU_PN1: CPU1.AW9 RUSBC1.28
USB_CPU_PP0: CPU1.AU7 TYPEC1.12
USB_CPU_PP1: CPU1.AW8 RUSBC1.27
USB_EN_S3WAKE: KBC1.15 R343.1 R358.1
USB_GPIO_C12: CPU1.AU17 R80.1
USB_GPIO_C13: CPU1.AN23 R79.1
USB_OC0N: LAUOC1.5 PCH1.AF1 RN9.4(B)
USB_OC1N: PCH1.AF2 RN9.3(B)
USB_OC2N: PCH1.AE3 R345.2 RN8.4(B)
USB_OC3N: PCH1.AF3 R332.2 RN8.3(B)
USB_OC4N: PCH1.AF4 RN10.3(B)
USB_OC5N: PCH1.AE4 RN10.4(B)
USB_OC6N: PCH1.AE5 RN19.3(B)
USB_OC7N: C426.1 C428.1 PCH1.AF5 R347.2 R350.1 R359.2 R360.1 R2775.2 RN19.4(B) U11.3 U13.3
USB_PCH_DN3_NN: D16.2 TR1.2 WEBCM1.11
USB_PCH_DP3_PP: D15.2 TR1.3 WEBCM1.10
USB_PCH_PN0: PCH1.AE2 TYPEC1.19
USB_PCH_PN1: PCH1.AC5 TYPEC1.16
USB_PCH_PN2: PCH1.Y4 RUSBC1.22
USB_PCH_PN3: PCH1.AB2 TR1.1
USB_PCH_PN4: PCH1.AD2 TR2.2
USB_PCH_PN10: PCH1.W6 U12.2
USB_PCH_PN10_CHAR: RUSBC1.18 U12.11
USB_PCH_PN11: PCH1.V4 U10.2
USB_PCH_PN11_CHAR: SUSBC1.12 U10.11
USB_PCH_PN12: PCH1.V2 SDRDC1.5
USB_PCH_PN13: PCH1.W2 TR3.1
USB_PCH_PP0: PCH1.AE1 TYPEC1.18
USB_PCH_PP1: PCH1.AC6 TYPEC1.15
USB_PCH_PP2: PCH1.Y3 RUSBC1.21
USB_PCH_PP3: PCH1.AB1 TR1.4
USB_PCH_PP4: PCH1.AD1 TR2.3
USB_PCH_PP10: PCH1.W5 U12.3
USB_PCH_PP10_CHAR: RUSBC1.19 U12.10
USB_PCH_PP11: PCH1.V3 U10.3
USB_PCH_PP11_CHAR: SUSBC1.10 U10.10
USB_PCH_PP12: PCH1.V1 SDRDC1.4
USB_PCH_PP13: PCH1.W1 TR3.4
USB_SS_ZVDDP_APU: CPU1.AK8 R84.2
USB_SS_ZVSS_APU: CPU1.AJ4 R90.2
USB_TOUCH_N: C493.1 TOUCH1.4 TR3.2
USB_TOUCH_P: C494.1 TOUCH1.3 TR3.3
USB_ZVSS: CPU1.AT11 R85.2
USBVCC31: C961.1 C962.1 C963.1 RPWRC1.3 U11.1
USBVCC31_EN: C424.1 R342.2 R343.2 U11.4
USBVCC32: C964.1 C965.1 C966.1 RPWRC1.21 U13.1
USBVCC32_EN: C427.1 R357.2 R358.2 U13.4
USBVCCTP: C1141.1 C1142.1 C1143.1 TOUCH1.5 U44.1
USBVCCTP_EN: KBC1.113 R2659.1
USBVCCTP_EN_R: C1144.1 R2659.2 U44.4
USBVCCTP_OC: C1145.1 R2660.1 R2661.2 R2775.1 U44.3
V_3P0_BAT_VREG: C300.1 C2511.1 D4.3 R2469.2 R2718.1 R2753.1 R2754.1 U5.3 U2505.8 U2506.8
V_3P3_PCIVAUX: C475.1 C476.1 C477.1 C478.1 Q26.G R415.1 R416.1 R419.2 R421.1 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
V_5HDD: C468.1 C469.1 C470.1 R406.2 R407.2 SATAP1.1 SATAP1.3 TC2.1
VCORE_MEM_TEST_PG: C631.1 Q41.B R486.2
VCORE_MEM_TEST_PG_BACO: C632.1 Q44.B R492.1
VD1_EN#: KBC1.66 R2431.2
VD_IN1: C986.1 C987.1 KBC1.100 KBC1.104 R1222.2 R1223.1
VD_IN2: C984.1 C985.1 KBC1.94 R372.2 R1224.1
VD_OUT1#: D2.2 KBC1.110
VD_OUT2#: D2.1 KBC1.112
VREFC_A0: C821.2 R687.1 R689.1 VRAMA1.J14
VREFC_A1: C822.2 R688.1 R690.1 VRAMA2.J14
VREFC_B0: C741.1 R643.1 R646.1 VRAMB1.J14
VREFC_B1: C742.1 R644.1 R648.1 VRAMB2.J14
VREFC_C0: C823.2 R691.1 R692.1 VRAMC1.J14
VREFC_C1: C908.2 R710.1 R711.1 VRAMC2.J14
VREFC_D0: C743.1 R645.1 R647.1 VRAMD1.J14
VREFC_D1: C818.1 R666.1 R667.1 VRAMD2.J14
VREFD1_A0: TP135.1 VRAMA1.A10
VREFD1_A1: TP133.1 VRAMA2.A10
VREFD1_B0: TP128.1 VRAMB1.A10
VREFD1_B1: TP126.1 VRAMB2.A10
VREFD1_C0: TP134.1 VRAMC1.A10
VREFD1_C1: TP139.1 VRAMC2.A10
VREFD1_D0: TP125.1 VRAMD1.A10
VREFD1_D1: TP131.1 VRAMD2.A10
VREFD2_A0: TP138.1 VRAMA1.U10
VREFD2_A1: TP136.1 VRAMA2.U10
VREFD2_B0: TP130.1 VRAMB1.U10
VREFD2_B1: TP129.1 VRAMB2.U10
VREFD2_C0: TP137.1 VRAMC1.U10
VREFD2_C1: TP140.1 VRAMC2.U10
VREFD2_D0: TP127.1 VRAMD1.U10
VREFD2_D1: TP132.1 VRAMD2.U10
VSYNC: GPU1.AR24 R2740.2
WCKA0_0: GPU1.L42 VRAMA1.D4
WCKA0_1: GPU1.L39 VRAMA1.P4
WCKA0B_0: GPU1.L41 VRAMA1.D5
WCKA0B_1: GPU1.L38 VRAMA1.P5
WCKA1_0: GPU1.B33 VRAMA2.P4
WCKA1_1: GPU1.D30 VRAMA2.D4
WCKA1B_0: GPU1.C33 VRAMA2.P5
WCKA1B_1: GPU1.E30 VRAMA2.D5
WCKB0_0: GPU1.G21 VRAMB1.P4
WCKB0_1: GPU1.A21 VRAMB1.D4
WCKB0B_0: GPU1.H21 VRAMB1.P5
WCKB0B_1: GPU1.B21 VRAMB1.D5
WCKB1_0: GPU1.F12 VRAMB2.D4
WCKB1_1: GPU1.A8 VRAMB2.P4
WCKB1B_0: GPU1.G12 VRAMB2.D5
WCKB1B_1: GPU1.B9 VRAMB2.P5
WCKC0_0: GPU1.H1 VRAMC1.D4
WCKC0_1: GPU1.M6 VRAMC1.P4
WCKC0B_0: GPU1.J2 VRAMC1.D5
WCKC0B_1: GPU1.M7 VRAMC1.P5
WCKC1_0: GPU1.AA1 VRAMC2.P4
WCKC1_1: GPU1.AA7 VRAMC2.D4
WCKC1B_0: GPU1.AA2 VRAMC2.P5
WCKC1B_1: GPU1.AA8 VRAMC2.D5
WCKD0_0: GPU1.AK4 VRAMD1.P4
WCKD0_1: GPU1.AN2 VRAMD1.D4
WCKD0B_0: GPU1.AK5 VRAMD1.P5
WCKD0B_1: GPU1.AN3 VRAMD1.D5
WCKD1_0: GPU1.AW11 VRAMD2.D4
WCKD1_1: GPU1.BB11 VRAMD2.P4
WCKD1B_0: GPU1.AV11 VRAMD2.D5
WCKD1B_1: GPU1.BA11 VRAMD2.P5
WEA0B: GPU1.V34 VRAMA1.L12
WEA1B: GPU1.H30 VRAMA2.G12
WEB0B: GPU1.J25 VRAMB1.L12
WEB1B: GPU1.M15 VRAMB2.G12
WEBCAM_DET: KBC1.34 PC67.2 R367.2 WEBCM1.1
WEC0B: GPU1.R12 VRAMC1.L12
WEC1B: GPU1.AE9 VRAMC2.G12
WED0B: GPU1.AK8 VRAMD1.L12
WED1B: GPU1.AP18 VRAMD2.G12
WOOF_ASEL_1: PR30.2 PR31.1 U8.18
WOOF_AVDD2_1: C419.1 C420.1 R326.1 U8.21
WOOF_BST_A1: C395.1 U8.2
WOOF_BST_B1: C396.2 U8.50
WOOF_BST_B_C1: C393.2 R321.1
WOOF_BST_C1: C397.1 U8.49
WOOF_BST_C_C1: C394.1 R322.2
WOOF_BST_D1: C398.2 U8.41
WOOF_DET_C: KBC1.27 R2598.1 WOOFC1.6
WOOF_GVDD_CD1: C410.1 U8.40
WOOF_I2C_SCL1: R2516.2 R2518.2 U8.8
WOOF_I2C_SDA1: R2515.2 R2517.2 U8.7
WOOF_ISENSEP_L1: PR23.2 PR29.1 U8.25
WOOF_ISENSEP_R1: PR20.2 PR28.2 U8.28
WOOF_IVSENSE_L1: PR22.2 PR27.1 U8.26
WOOF_IVSENSE_R1: PR19.2 PR26.2 U8.29
WOOF_L+_C: C388.1 L21.1 PR21.1 WOOFC1.5
WOOF_L-_C: PR22.1 R2596.1 WOOFC1.4
WOOF_LDO_1D5_1: C413.1 U8.22
WOOF_OUT_A1: C392.2 C395.2 L20.1 U8.55
WOOF_OUT_A1_L: C387.2 L20.2 PR23.1 R2596.2
WOOF_OUT_A_C1: C392.1 R320.2
WOOF_OUT_B1: C393.1 C396.1 L21.2 U8.52
WOOF_OUT_C1: C394.2 C397.2 L22.1 U8.47
WOOF_OUT_C1_L: C389.2 L22.2 PR20.1 R2737.2
WOOF_OUT_D1: C391.1 C398.1 L23.1 U8.44
WOOF_OUT_D_C1: C391.2 R319.1
WOOF_R+_C: C390.1 L23.2 PR18.1 WOOFC1.3
WOOF_R-_C: PR19.1 R2737.1 WOOFC1.2
WOOF_VREF2: C414.1 U8.23
WOOF_VSENSEN_L1: PR21.2 PR25.1 U8.27
WOOF_VSENSEN_R1: PR18.2 PR24.2 U8.30
X32K_RTC: C2510.1 R2522.1 X100.1
XIN_OSC: GPU1.BA43 R563.1
XTL_32K_X1_CPU: C18.2 CPU1.AW5 R45.1 X1.1
XTL_32K_X2_CPU: C17.2 CPU1.AW6 R45.2 X1.2
XTL_32K_XI_RTC: C2509.1 R2523.2 U2505.1 U2506.1 X100.2
XTL_32K_XO_RTC: R2522.2 R2523.1 U2505.2 U2506.2
XTL_48M_X1_CPU: C22.1 CPU1.AJ1 R81.1 X2.3
XTL_48M_X2_CPU: C23.1 CPU1.AH1 R81.2 X2.1
ZQ_A0: R680.1 VRAMA1.J13
ZQ_A1: R681.1 VRAMA2.J13
ZQ_B0: R641.1 VRAMB1.J13
ZQ_B1: R637.1 VRAMB2.J13
ZQ_C0: R685.1 VRAMC1.J13
ZQ_C1: R708.1 VRAMC2.J13
ZQ_D0: R636.1 VRAMD1.J13
ZQ_D1: R664.1 VRAMD2.J13

Pads without a net: CPU1 A5 A7 A8 A10 A11 A13 AA39 AB2 AB4 AB37 AC3 AC4 AC34 AD2 AD3 AD33 AE1 AE2 AE34 AE38 AF1 AF33 AF34 AF37 AG2 AG3 AG36 AH2 AH4 AH5 AH7 AH8 AH35 AH37 AH38 AJ6 AJ7 AK34 AL13 AL16 AL17 AL18 AL19 AL20 AL21 AL22 AM9 AM10 AM12 AM13 AM16 AM17 AM21 AM22 AM23 AN11 AN12 AN14 AN15 AN16 AN17 AN21 AP7 AP10 AP11 AP13 AP14 AP15 AP16 AP17 AP21 AP23 AR7 AR9 AR10 AR12 AR13 AR15 AR16 AR18 AR19 AR20 AR21 AR24 AT9 AT12 AT14 AT19 AT25 AT30 AU10 AU11 AV9 AV10 AV12 AV13 AW11 AW24 B6 B7 B9 B10 C8 C9 C11 C12 D11 D13 D28 E10 E19 E22 E25 E33 E34 E37 E39 F33 F36 F38 F39 G13 G14 G17 G32 G34 G37 G38 H13 H33 H34 H36 H37 H39 J32 J33 J36 J38 J39 K31 K32 K34 K38 L34 L36 L39 M33 R35 V32 V35 V36 W32 W37 Y37 Y39; DIMM1 87 88 91 92 96 100 101 104 105 162 165; DIMM2 87 88 91 92 96 100 101 104 105 162 165; DISPC1 4; DISPC2 4; GPU1 AE33 AF31 AG9 AG13 AG33 AG34 AK25 AK26 AK34 AL27 AM27 AR19 AR23 AR25 AR29 AR30 AT23 AT24 AT25 AT30 AT32 AT33 AU26 AU32 AU33 AV23 AV25 AV26 AW23 AW25 AW40 AY26 AY27 AY32 AY33 AY35 AY36 AY38 AY39 AY42 BA19 BA20 BB19 BB20 BB21 BB25 BB26 BB27 BB33 BB35 BB36 BB38 BB39 BB40 BC19 BC20 BC21 BC25 BC26 BC27 BC33 BC35 BC36 BC38 BC39 BC41 J27 K14 N27 P10 P12 W30 W35; KBC1 8 9 22 33 36 37 38 41 49 51 53 57 79; LPC1 10; PCH1 A2 A5 A10 A11 A12 A13 A14 A17 A18 A19 A20 A22 AA1 AA2 AA22 AB3 AB4 AB5 AB6 AB18 AB19 AB21 AC18 AC19 AC21 AC23 AD3 AD4 AD23 AE18 AE20 AE21 AE22 AE24 AF18 AF20 AF21 AF22 AF24 B2 B10 B11 B12 B13 B14 B17 B18 B19 B20 B21 B22 C7 C19 C20 C21 C22 C26 D11 D12 D13 D14 D17 D18 D21 D25 E11 E12 E13 E14 E17 E18 E19 E20 E23 E26 P25 P26 R25 R26 T21 T22 T23 T24 V25 V26 W22 W23 W24 W25 W26 Y5 Y6 Y23 Y24 Y25 Y26; PU3 19; PU33 10 12 16; PU34 10 12 16; PU38 5 7 8; PU39 46 47 48; PU40 6 36; PU41 6 36; PU42 6 36; PU43 6 36; PU44 6 36; PU45 6 36; PU46 6 36; PU47 10 12; PU48 19; RPWRC1 25 26 27 28 29 30; RUSBC1 9 10 24 25; SATAP1 5; SSDC1 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; U6 47 48 49 50; U7 9 13 31 32 35 36 38; U8 9 13 31 32 35 36 38; U17 5; U23 2 4 18 19 20 29 30; U26 1 10; VRAMA1 A5 U5; VRAMA2 A5 U5; VRAMB1 A5 U5; VRAMB2 A5 U5; VRAMC1 A5 U5; VRAMC2 A5 U5; VRAMD1 A5 U5; VRAMD2 A5 U5; WEBCM1 8 13 14; WLAN1 62 64; X99 2 4

## Via types
v1: diameter 0.559, hole 0.305, TOP to BOTTOM, 3002 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 659 vias
v3: diameter 0.762, hole 0.381, TOP to BOTTOM, 770 vias
v4: diameter 0.711, hole 0.406, TOP to BOTTOM, 1553 vias
v5: diameter 0.711, hole 0.356, TOP to BOTTOM, 317 vias
v6: diameter 0.508, hole 0.254, TOP to BOTTOM, 4024 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_VDDC_VGA: length 341.8
  TOP w0.483: 73.04,183 v6(73.53,183.49) 73.02,184 ; 73.04,183 GPU1.W25 ; 73.04,183 73.08,183 v6(73.56,182.52) 73.03,182 ; GPU1.AE21 GPU1.AF20 GPU1.AG21 ; GPU1.AE21 v6(69.5,177.5) GPU1.AD21 ; GPU1.AE21 v6(69.5,176.5) GPU1.AF21 ; GPU1.AE21 GPU1.AD20 GPU1.AC21 ; GPU1.V28 v6(76.5,183.5) ; v6(76.5,183.5) GPU1.W28 76.06,183 v6(76.54,182.52) ; v6(76.5,183.5) GPU1.W29 77,182.99 v6(76.54,182.52) ; GPU1.U16 v6(63.5,185.5) GPU1.T16 ; GPU1.U16 v6(63.5,184.5) GPU1.V16 ; GPU1.U16 64.41,184.59 v6(64.41,184.51) ; GPU1.U16 64.39,185.39 v6(64.39,185.5) ; 73.08,176 73.1,176 v6(73.58,175.51) 73.07,175 73.06,175 ; 73.08,176 v6(73.58,176.5) 73.09,177 ; 73.08,176 GPU1.AF25 ; GPU1.AH28 75.97,174 v6(75.48,173.5) ; GPU1.AH28 v6(76.5,174.5) ; GPU1.AH28 75.49,174.51 v6(75.49,174.52) ; GPU1.AH28 v6(76.5,173.5) ; v6(76.48,177.46) 76.01,177 GPU1.AE28 v6(76.53,176.47) ; v6(76.48,177.46) 76.94,177 GPU1.AE29 77,176.95 v6(76.53,176.47) ; v6(76.48,177.46) 77,177.99 GPU1.AD29 77,178.11 v6(76.61,178.5) ; v6(76.48,177.46) 76,177.94 GPU1.AD28 76.11,178 v6(76.61,178.5) ; v6(76.5,179.5) GPU1.AB29 77,180.11 v6(76.61,180.5) ; v6(76.5,179.5) GPU1.AC28 76.11,179 v6(76.61,178.5) ; v6(76.5,179.5) GPU1.AB28 76.11,180 v6(76.61,180.5) ; v6(76.5,179.5) GPU1.AC29 77,178.89 v6(76.61,178.5) ; GPU1.AA21 GPU1.Y20 GPU1.W21 ; GPU1.AA21 v6(69.5,181.5) GPU1.Y21 ; GPU1.AA21 v6(69.5,180.5) GPU1.AB21 ; GPU1.AA21 GPU1.AB20 GPU1.AC21 ; GPU1.AD21 GPU1.AC20 GPU1.AB21 ; GPU1.AD21 GPU1.AE20 GPU1.AF21 ; GPU1.AD21 v6(69.5,178.5) GPU1.AC21 ; v6(76.5,174.5) GPU1.AH29 v6(76.5,173.5) ; v6(76.5,174.5) GPU1.AG28 ; v6(76.5,174.5) GPU1.AG29 77,175.04 v6(76.51,175.53) ; v6(71.5,173.5) GPU1.AH24 ; v6(71.5,173.5) GPU1.AJ23 v6(70.5,173.5) ; v6(71.5,173.5) GPU1.AJ24 ; v6(71.5,173.5) GPU1.AH23 v6(70.5,173.5) ; GPU1.AH24 GPU1.AG25 ; GPU1.AH24 GPU1.AJ25 ; GPU1.AF21 GPU1.AG20 ; GPU1.AF21 v6(69.5,175.5) GPU1.AG21 ; v6(64.46,176.53) 64,176.99 GPU1.AE16 64.44,177.44 v6(64.44,177.49) ; v6(64.46,176.53) 64.46,176.46 GPU1.AF16 64.43,175.57 v6(64.43,175.53) ; v6(64.46,176.53) 64.93,177 64.93,177 ; v6(64.46,176.53) 64.99,176 ; v6(64.39,185.5) 64.89,185 GPU1.U17 64.51,184.51 v6(64.41,184.51) ; v6(64.39,185.5) 64.39,185.61 GPU1.T16 ; v6(64.39,185.5) 64.89,186 GPU1.T17 v6(64.5,186.5) GPU1.T16 ; 73.06,175 v6(73.56,174.5) ; 73.06,175 GPU1.AG25 ; GPU1.AF17 64.99,176 ; 64.99,176 64.9,176 v6(64.43,175.53) ; v6(75.49,174.52) 75,174.03 GPU1.AH27 ; v6(75.49,174.52) 75.53,174.52 GPU1.AG28 ; v6(66.5,173.5) GPU1.AJ19 v6(67.5,173.5) ; v6(66.5,173.5) GPU1.AH18 65.95,174 v6(65.51,174.45) 65.51,174.49 GPU1.AG17 64.95,175 v6(64.43,175.53) ; v6(66.5,173.5) GPU1.AH19 ; GPU1.U25 GPU1.V24 GPU1.W25 ; GPU1.U25 73.04,185 ; GPU1.U25 GPU1.T24 v6(72.5,186.5) GPU1.T25 ; v6(73.56,174.5) 73.5,174.5 GPU1.AH25 ; v6(73.56,174.5) 74,174.06 GPU1.AH26 ; v6(64.41,183.49) 64.9,183 64.92,183 ; v6(64.41,183.49) 64.41,183.41 GPU1.W16 ; v6(64.41,183.49) 64.92,184 ; v6(64.41,183.49) 64,183.9 GPU1.V16 ; 73.08,179 v6(73.58,179.5) 73.09,180 73.07,180 ; 73.08,179 GPU1.AC25 ; 73.08,179 73.1,179 v6(73.58,178.51) 73.07,178 ; v6(70.5,173.5) GPU1.AJ22 v6(69.5,173.5) ; v6(70.5,173.5) GPU1.AH22 ; GPU1.Y16 64.44,181.56 v6(64.44,181.55) ; GPU1.Y16 v6(63.5,182.5) GPU1.W16 ; GPU1.Y16 64,182.01 64.46,182.46 v6(64.46,182.54) ; 73.05,181 v6(73.56,180.49) 73.07,180 ; 73.05,181 v6(73.56,181.51) 73.07,182 73.03,182 ; 73.05,181 GPU1.AA25 ; v6(76.61,180.5) 76.11,181 GPU1.AA28 v6(76.5,181.5) ; v6(76.61,180.5) 77,180.89 GPU1.AA29 v6(76.5,181.5) ; GPU1.AH27 GPU1.AJ26 v6(73.5,173.5) ; GPU1.AH27 75,173.98 v6(75.48,173.5) ; GPU1.AH27 v6(74.5,174.5) GPU1.AH26 ; GPU1.T25 73.11,186 v6(73.61,185.5) 73.11,185 73.04,185 ; GPU1.T25 GPU1.U24 GPU1.V25 ; GPU1.AG20 68.5,174.5 ; GPU1.AG20 67.5,174.5 ; 73.09,177 GPU1.AE25 ; 73.09,177 v6(73.58,177.5) 73.08,178 73.07,178 ; v6(76.5,181.5) GPU1.Y28 76.01,182 v6(76.54,182.52) ; v6(76.5,181.5) GPU1.Y29 76.54,182.46 v6(76.54,182.52) ; GPU1.AC16 v6(64.5,178.5) ; GPU1.AC16 64.45,179.45 v6(64.45,179.49) ; GPU1.AC16 v6(63.5,178.5) GPU1.AD16 ; v6(64.5,178.5) GPU1.AD16 ; v6(64.5,178.5) GPU1.AD17 64.95,178 v6(64.44,177.49) ; v6(64.5,178.5) GPU1.AC17 64.95,179 v6(64.45,179.49) ; GPU1.V16 64.04,184 64.41,184.38 v6(64.41,184.51) ; v6(69.5,173.5) GPU1.AJ21 v6(68.5,173.5) ; v6(69.5,173.5) GPU1.AH22 ; v6(69.5,173.5) GPU1.AH21 ; 73.07,180 GPU1.AB25 ; GPU1.W21 v6(69.5,183.5) GPU1.V21 ; GPU1.W21 GPU1.V20 GPU1.U21 ; GPU1.W21 v6(69.5,182.5) GPU1.Y21 ; v6(68.5,173.5) GPU1.AH21 ; v6(68.5,173.5) GPU1.AH20 ; v6(68.5,173.5) GPU1.AJ20 v6(67.5,173.5) ; GPU1.AH21 69.5,174.5 ; GPU1.AH21 68.5,174.5 ; v6(73.5,173.5) GPU1.AJ25 ; v6(73.5,173.5) GPU1.AH25 ; v6(73.5,173.5) GPU1.AH26 ; GPU1.U21 v6(69.5,184.5) GPU1.V21 ; GPU1.U21 v6(69.5,185.5) GPU1.T21 GPU1.U20 GPU1.V21 ; GPU1.U21 GPU1.T20 ; 73.04,185 v6(73.56,184.48) 73.08,184 73.02,184 ; 73.02,184 GPU1.V25 ; GPU1.V25 GPU1.W24 GPU1.Y25 ; v6(76.51,175.53) 76.04,176 GPU1.AF28 76.47,176.47 v6(76.53,176.47) ; v6(76.51,175.53) 76.53,175.53 GPU1.AF29 v6(76.53,176.47) ; v6(76.51,175.53) 76,175.02 GPU1.AG28 ; 69.5,174.5 GPU1.AH22 ; 69.5,174.5 GPU1.AG21 ; v6(64.45,179.49) 64,179.95 GPU1.AB16 v6(64.5,180.5) ; v6(64.45,179.49) 64.96,180 GPU1.AB17 v6(64.5,180.5) ; GPU1.AA25 GPU1.Y24 GPU1.W25 ; GPU1.AA25 GPU1.AB24 GPU1.AC25 ; GPU1.AH19 v6(67.5,173.5) ; GPU1.AH19 67.5,174.5 ; v6(67.5,173.5) GPU1.AH20 ; 68.5,174.5 GPU1.AG21 ; 68.5,174.5 GPU1.AH20 ; GPU1.AB21 GPU1.AA20 GPU1.Y21 ; GPU1.AJ25 72.95,173 v6(72.4,172.45) 72.4,172.6 GPU1.AJ24 ; GPU1.AE25 GPU1.AD24 GPU1.AC25 ; GPU1.AE25 GPU1.AF24 GPU1.AG25 ; GPU1.AB25 GPU1.AA24 GPU1.Y25 ; GPU1.AB25 GPU1.AC24 GPU1.AD25 ; GPU1.AJ24 GPU1.AH25 ; GPU1.AE17 64.93,177 ; 64.93,177 v6(64.44,177.49) ; 73.07,178 GPU1.AD25 ; GPU1.AD25 GPU1.AE24 GPU1.AF25 ; v6(75.48,173.5) 75.98,173 GPU1.AJ28 v6(76.5,173.5) ; v6(75.48,173.5) 75,173.03 GPU1.AJ27 GPU1.AH26 ; GPU1.AH20 67.5,174.5 ; v6(64.46,182.54) 64.99,182 GPU1.Y17 64.55,181.55 v6(64.44,181.55) ; v6(64.46,182.54) 64.92,183 ; v6(64.46,182.54) 64.46,182.54 GPU1.W16 ; v6(64.44,181.55) 64.44,181.44 GPU1.AA16 v6(64.5,180.5) ; v6(64.44,181.55) 64.99,181 GPU1.AA17 v6(64.5,180.5) ; GPU1.V21 GPU1.W20 GPU1.Y21 ; GPU1.AH25 GPU1.AG24 GPU1.AF25 ; v6(64.41,184.51) 64.92,184 64.92,184 ; 64.92,184 GPU1.V17 ; GPU1.AD16 64.44,177.56 v6(64.44,177.49) ; 73.03,182 GPU1.Y25 ; 64.92,183 GPU1.W17
  TOP w0.635: 91.76,141.43 PT32.1 ; PT32.1 92.81,142.48 ; PT32.1 92.81,140.37 ; PT32.1 93.87,141.43 ; 43.69,149.48 44.74,149.48 ; 43.69,149.48 42.63,149.48 ; 43.69,149.48 43.69,150.53 ; 43.69,149.48 43.69,148.42 ; 76.61,140.35 PT38.1 ; PT38.1 77.66,141.4 ; PT38.1 75.55,141.4 ; 99.63,141.33 PT29.1 ; PT29.1 101.74,141.33 ; PT29.1 100.69,142.38 ; PT29.1 100.69,140.27 ; PT33.1 84.61,142.48 ; PT33.1 85.66,141.43 ; PT33.1 84.61,140.37 ; PT33.1 83.55,141.43 ; PT39.1 44.64,141.33 ; PT39.1 43.59,140.27 ; PT39.1 43.59,142.38 ; PT39.1 42.53,141.33 ; 67.27,142.62 PT30.1 ; PT30.1 68.33,141.57 ; PT30.1 69.38,142.62
  L3 w0.635: PT30.1 68.33,143.68 ; PT30.1 68.33,141.57 ; PT30.1 67.27,142.62 ; PT30.1 69.38,142.62 ; PT33.1 85.66,141.43 ; PT33.1 83.55,141.43 ; PT33.1 84.61,142.48 ; PT33.1 84.61,140.37 ; 43.69,149.48 43.69,150.53 ; 43.69,149.48 44.74,149.48 ; 43.69,149.48 43.69,148.42 ; 43.69,149.48 42.63,149.48 ; 75.55,141.4 PT38.1 ; PT38.1 76.61,142.46 ; PT38.1 76.61,140.35 ; PT38.1 77.66,141.4 ; 43.59,140.27 PT39.1 ; PT39.1 42.53,141.33 ; PT39.1 44.64,141.33 ; PT39.1 43.59,142.38 ; 92.81,140.37 PT32.1 ; PT32.1 92.81,142.48 ; PT32.1 91.76,141.43 ; PT32.1 93.87,141.43
  L4 w0.635: 100.69,140.27 PT29.1 ; PT29.1 100.69,142.38 ; PT29.1 99.63,141.33 ; PT29.1 101.74,141.33 ; PT32.1 93.87,141.43 ; PT32.1 91.76,141.43 ; PT32.1 92.81,140.37 ; PT32.1 92.81,142.48 ; 43.69,149.48 43.69,150.53 ; 43.69,149.48 42.63,149.48 ; 43.69,149.48 44.74,149.48 ; 43.69,149.48 43.69,148.42 ; PT39.1 44.64,141.33 ; PT39.1 43.59,140.27 ; PT39.1 43.59,142.38 ; PT39.1 42.53,141.33 ; 76.61,140.35 PT38.1 ; PT38.1 75.55,141.4 ; PT38.1 77.66,141.4 ; PT38.1 76.61,142.46 ; PT33.1 84.61,142.48 ; PT33.1 85.66,141.43 ; PT33.1 83.55,141.43 ; PT33.1 84.61,140.37
  L6 w0.635: PT38.1 76.61,142.46 ; PT38.1 75.55,141.4 ; PT38.1 77.66,141.4 ; PT38.1 76.61,140.35 ; PT32.1 93.87,141.43 ; PT32.1 92.81,142.48 ; PT32.1 92.81,140.37 ; PT32.1 91.76,141.43 ; PT29.1 100.69,142.38 ; PT29.1 99.63,141.33 ; PT29.1 100.69,140.27 ; PT29.1 101.74,141.33 ; PT33.1 84.61,142.48 ; PT33.1 83.55,141.43 ; PT33.1 85.66,141.43 ; PT33.1 84.61,140.37
  BOTTOM w0.381: C682.1 77.87,174.55 78.48,174.55 78.55,174.47 C719.1 ; v6(76.5,183.5) 75.55,184.45 C695.1
  BOTTOM w0.508: v6(76.5,179.5) 76.52,179.48 77.15,179.48 C687.1 ; C720.1 76.67,178.56 v6(76.61,178.5) ; C694.1 75.46,180.41 PC352.1 76.45,180.34 v6(76.61,180.5) ; PR251.1 113.02,159.84 111.47,159.84 110.23,158.6 110.23,157.39 110.23,157.39 110.23,155.87 109.5,155.14 109.09,155.14 106.48,152.53 106.48,150.81 106.48,150.32 105.84,149.68 98.04,149.68 95.42,152.3 92,152.3
  vias: v1(37.92,141.1) v1(38.23,149.66) v1(38.23,148.87) v1(38.23,146.51) v1(38.3,144.91) v1(38.3,143.76) v1(38.71,141.1) v1(38.86,148.08) v1(38.86,147.29) v1(39.09,144.91) v1(39.09,143.76) v1(39.5,141.1) v1(39.88,144.91) v1(39.88,143.76) v1(40.13,149.66) v1(40.13,148.87) v1(40.13,146.51) v1(40.28,141.1) v1(40.67,144.91) v1(40.67,143.76) v1(41.02,148.08) v1(41.02,147.29) v1(53.95,137.77) v1(53.95,136.98) v1(53.95,136.19) v1(53.95,135.41) v1(53.95,134.62) v1(54.74,137.77) v1(54.74,136.98) v1(54.74,136.19) v1(54.74,135.41) v1(54.74,134.62) v1(55.52,137.77) v1(55.52,136.98) v1(55.52,136.19) v1(55.52,135.41) v1(55.52,134.62) v1(57.99,136.47) v1(57.99,135.69) v1(57.99,134.9) v1(57.99,134.11) v1(58.78,136.47) v1(58.78,135.69) v1(58.78,134.9) v1(58.78,134.11) v1(59.56,136.47) v1(59.56,135.69) v1(59.56,134.9) v1(59.56,134.11) v1(60.35,136.47) v1(60.35,135.69) v1(60.35,134.9) v1(65.18,136.58) v1(65.18,135.79) v1(65.18,135) v1(65.18,134.21) v1(65.96,136.58) v1(65.96,135.79) v1(65.96,135) v1(65.96,134.21) v1(66.75,136.58) v1(66.75,135.79) v1(66.75,135) v1(66.75,134.21) v1(67.54,136.58) v1(67.54,135.79) v1(67.54,135) v1(67.54,134.21) v1(71.17,154.76) v1(71.3,156.77) v1(72.44,135.05) v1(72.44,134.26) v1(72.44,133.48) v1(73.23,135.05) v1(73.23,134.26) v1(73.23,133.48) v1(74.02,135.05) v1(74.02,134.26) v1(74.02,133.48) v1(74.8,135.05) v1(74.8,134.26) v1(78.18,143.51) v1(78.18,142.72) v1(78.18,141.94) v1(78.18,141.15) v1(78.18,140.36) v1(78.97,143.51) v1(78.97,142.72) v1(78.97,141.94) v1(78.97,141.15) v1(78.97,140.36) v1(79.76,143.51) v1(79.76,142.72) v1(79.76,141.94) v1(79.76,141.15) v1(79.76,140.36) v1(79.88,151.94) v1(79.88,151.16) v1(79.88,150.37) v1(79.88,149.58) v1(79.88,148.79) v1(79.88,148.01) v1(79.88,147.22) v1(79.88,146.43) v1(80.54,143.51) v1(80.54,142.72) v1(80.54,141.94) v1(80.54,141.15) v1(80.54,140.36) v1(80.67,151.94) v1(80.67,151.16) v1(80.67,150.37) v1(80.67,149.58) v1(80.67,148.79) v1(80.67,148.01) v1(80.67,147.22) v1(80.67,146.43) v1(81.33,143.51) v1(81.33,142.72) v1(81.33,141.94) v1(81.33,141.15) v1(81.33,140.36) v1(83.54,133.5) v1(83.54,132.72) v1(84.33,133.5) v1(84.33,132.72) v1(85.12,133.5) v1(85.12,132.72) v1(85.9,133.5) v1(85.9,132.72) v1(88.29,143.41) v1(88.29,142.62) v1(88.29,141.83) v1(88.29,141.05) v1(88.29,140.26) v1(89.08,143.41) v1(89.08,142.62) v1(89.08,141.83) v1(89.08,141.05) v1(89.08,140.26) v1(89.87,143.41) v1(89.87,142.62) v1(89.87,141.83) v1(89.87,141.05) v1(89.87,140.26) v1(90.07,152.1) v1(90.07,151.31) v1(90.07,150.52) v1(90.07,149.73) v1(90.07,148.95) v1(90.07,148.16) v1(90.07,147.37) v1(90.65,143.41) v1(90.65,142.62) v1(90.65,141.83) v1(90.65,141.05) v1(90.65,140.26) v1(91.11,133.99) v1(91.9,133.99) v1(91.92,133.15) v1(92.68,133.99) v1(92.71,133.15) v1(93.47,133.99) v1(93.5,133.15) v1(94.23,133.99) v1(96,132.16) v1(96.85,132.16) v1(97.69,132.19) v1(98.5,132.15) v2(69.57,179.48) v2(74.55,173.61) v2(78.87,146.89) v2(81.74,146.74) v2(90.93,152.4) v3(36.42,139.65) v3(70.66,137.59) v4(36.22,137.79) v4(36.22,136.7) v4(36.22,135.61) v4(36.22,134.52) v4(37.19,137.79) v4(37.19,136.7) v4(37.19,135.61) v4(37.19,134.52) v4(38.15,137.79) v4(38.15,136.7) v4(38.15,135.61) v4(38.15,134.52) v4(42.9,138.02) v4(42.9,136.93) v4(42.9,135.84) v4(42.9,134.75) v4(42.9,133.71) v4(43.87,138.02) v4(43.87,136.93) v4(43.87,135.84) v4(43.87,134.75) v4(43.87,133.71) v4(47.29,137.79) v4(47.29,136.7) v4(47.29,135.61) v4(47.29,134.52) v4(48.26,137.79) v4(48.26,136.7) v4(48.26,135.61) v4(48.26,134.52) v4(49.23,137.79) v4(49.23,136.7) v4(49.23,135.61) v4(49.23,134.52) v6(85.98,160.25) v6(88.09,165.58)
