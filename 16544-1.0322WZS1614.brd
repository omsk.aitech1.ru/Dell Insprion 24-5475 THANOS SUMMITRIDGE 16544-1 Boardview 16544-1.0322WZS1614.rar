# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB30_TX_CPU_N0: length 260.9
  TOP w0.102: 102.61,9.17 102.61,9.76 99.9,12.47 91.27,12.47 v1(90.93,12.81) ; 102.61,9.17 v3(103,9.17) ; 102.61,9.17 102.61,7.88 102.75,7.75 TYPEC1.21 ; CPU1.AF4 163.38,179.62 163.38,182.25 163.47,182.35 163.47,183.08 163.17,183.39 v1(162.97,183.39)
  L6 w0.102: v1(162.97,183.39) 162.52,183.39 162.28,183.63 162.28,183.75 162.15,183.87 158.08,183.87 153.55,188.4 143.02,188.4 142.52,188.9 142.38,189.04 140.41,191.01 139.55,191.01 138.98,191.58 132.52,191.58 124.33,183.39 124.33,145.72 126.09,143.97 126.09,138.13 124.26,136.3 124.26,130.02 121.26,127.02 121.26,124.33 115.65,118.72 115.65,103.45 106.15,93.95 100.97,93.95 98.04,91.03 96.16,91.03 90.83,85.7 90.83,84.38 87.38,80.92 87.38,56.95 88.98,55.35 88.98,51.87 88.65,51.54 88.65,16.81 89.84,15.62 89.84,12.72 90.05,12.51 90.18,12.51 90.48,12.81 v1(90.93,12.81)
USB30_TX_CPU_N1: length 229.3
  TOP w0.102: CPU1.AC1 167.39,182.39 167.39,183.09 166.81,183.67 166.25,183.67 v1(165.97,183.39) ; RUSBC1.4 84.48,36.25 84.61,36.11 85.09,36.11 85.52,35.69 86.33,35.69 v1(86.61,35.97)
  L6 w0.102: v1(86.61,35.97) 86.97,35.61 87.32,35.61 87.48,35.77 87.48,52 87.86,52.38 87.86,54.76 86.06,56.56 86.06,81.54 89.59,85.07 89.59,86.67 95.14,92.23 97.55,92.23 100.47,95.15 105.63,95.15 114.45,103.97 114.45,119.1 118.87,123.52 118.87,126.21 123.11,130.45 123.11,183.86 132.03,192.77 139.74,192.77 140.31,192.2 140.91,192.2 143.47,189.64 153.9,189.64 156.92,186.61 165.99,186.61 166.98,185.63 166.98,184.07 166.63,183.72 166.32,183.72 165.99,183.39 v1(165.97,183.39)
USB30_TX_CPU_P0: length 260.4
  TOP w0.102: CPU1.AF3 163.61,180.39 163.61,182.16 163.7,182.25 163.7,183.44 v1(162.97,184.18) ; TYPEC1.22 102.25,7.75 102.39,7.88 102.39,9.66 99.8,12.24 91.27,12.24 v1(90.93,11.9)
  L6 w0.102: v1(162.97,184.18) 162.2,184.18 162.15,184.13 158.19,184.13 153.66,188.66 143.12,188.66 142.56,189.22 140.52,191.26 139.65,191.26 139.08,191.83 132.42,191.83 124.08,183.49 124.08,145.61 125.83,143.86 125.83,138.23 124,136.4 124,130.12 121.01,127.12 121.01,124.44 115.39,118.82 115.39,103.56 106.04,94.21 100.86,94.21 97.94,91.29 96.06,91.29 90.58,85.81 90.58,84.48 87.12,81.03 87.12,56.84 88.72,55.24 88.72,51.97 88.39,51.64 88.39,16.71 89.59,15.52 89.59,12.61 89.94,12.26 90.58,12.26 v1(90.93,11.9)
USB30_TX_CPU_P1: length 229.1
  TOP w0.102: v1(165.97,184.18) 166.25,183.9 166.9,183.9 167.61,183.19 167.61,182.39 CPU1.AB1 ; v1(86.61,34.95) 86.11,35.46 85.43,35.46 85,35.89 84.61,35.89 84.47,35.75 RUSBC1.3
  L6 w0.102: v1(165.97,184.18) 166.18,183.97 166.52,183.97 166.73,184.17 166.73,185.52 165.89,186.36 156.82,186.36 153.8,189.38 143.37,189.38 140.8,191.95 140.21,191.95 139.64,192.52 132.13,192.52 123.37,183.75 123.37,130.35 119.13,126.11 119.13,123.42 114.71,119 114.71,103.86 105.74,94.89 100.58,94.89 97.65,91.97 95.25,91.97 92.29,89.01 92.29,88.76 92.02,88.49 91.77,88.49 91.5,88.22 91.5,87.98 91.23,87.71 90.98,87.71 89.84,86.56 89.84,84.96 86.31,81.43 86.31,56.67 88.11,54.86 88.11,52.27 87.73,51.89 87.73,35.66 87.43,35.36 87.02,35.36 v1(86.61,34.95)
USB30_TX_PCH_N0: length 139.2
  TOP w0.127: PCH1.AE16 163.39,35.41 163.39,34.2 163.5,34.09 v6(163.5,34.06) ; RUSBC1.16 84.5,42.25 84.63,42.12 85.5,42.12 85.89,42.51 86.21,42.51 v1(86.61,42.91)
  L3 w0.14: v1(86.61,42.91) 86.13,42.43 85.72,42.43 84.82,41.54 84.82,30.84 84.54,30.57 84.54,13.96 94.16,4.34 146.48,4.34 159.85,17.72 159.85,26.28 165.06,31.49 165.06,32.8 164.25,33.62 163.98,33.62 163.54,34.06 v6(163.5,34.06)
USB30_TX_PCH_N1: length 83.7
  TOP w0.127: v1(230.22,27.41) 230.63,27.83 231.06,27.83 232.12,28.88 232.87,28.88 233.25,28.5 SUSBC1.9 ; PCH1.AE17 v6(164.2,35.4)
  L4 w0.14: v6(164.2,35.4) 164.47,35.13 164.47,35.01 164.61,34.87 164.94,34.87 170.61,29.2 170.61,27.74 171.55,26.8 175.34,26.8 178.26,29.72 184.07,29.72 184.34,29.98 186.94,29.98 186.96,30.01 192.44,30.01 196.4,33.97 215.69,33.97 219.65,30.01 230.43,30.01 231.11,29.33 231.11,28.06 230.79,27.74 230.54,27.74 v1(230.22,27.41)
USB30_TX_PCH_P0: length 139.3
  TOP w0.127: RUSBC1.15 84.5,41.75 84.63,41.88 85.6,41.88 85.99,42.27 86.25,42.27 v1(86.61,41.9) ; PCH1.AF16 162.97,34.97 162.97,33.71 163.45,33.22 v6(163.45,33.2)
  L3 w0.14: v6(163.45,33.2) 163.83,33.2 163.98,33.35 164.13,33.35 164.8,32.69 164.8,31.6 159.59,26.39 159.59,25.97 159.46,25.85 159.46,25.43 159.59,25.3 159.59,24.88 159.46,24.76 159.46,24.34 159.59,24.22 159.59,23.8 159.46,23.67 159.46,23.25 159.59,23.13 159.59,21.36 159.46,21.23 159.46,20.81 159.59,20.69 159.59,20.27 159.46,20.15 159.46,19.73 159.59,19.6 159.59,17.83 146.37,4.61 94.27,4.61 93.98,4.91 93.98,5.08 93.68,5.38 93.5,5.38 93.21,5.68 93.21,5.85 92.91,6.15 92.73,6.15 92.44,6.44 92.44,6.62 92.14,6.92 91.97,6.92 88.37,10.51 88.37,10.68 88.08,10.98 87.9,10.98 87.61,11.28 87.61,11.45 87.31,11.75 87.13,11.75 86.84,12.05 86.84,12.22 86.54,12.52 86.36,12.52 84.81,14.07 84.81,16.86 84.94,16.98 84.94,17.4 84.81,17.52 84.81,17.94 84.94,18.07 84.94,18.49 84.81,18.61 84.81,20.98 84.94,21.11 84.94,21.53 84.81,21.65 84.81,22.07 84.94,22.2 84.94,22.61 84.81,22.74 84.81,23.16 84.94,23.28 84.94,23.7 84.81,23.83 84.81,26.05 84.94,26.18 84.94,26.59 84.81,26.72 84.81,27.14 84.94,27.26 84.94,27.68 84.81,27.81 84.81,28.23 84.94,28.35 84.94,28.77 84.81,28.89 84.81,30.45 85.09,30.73 85.09,41.43 85.83,42.16 86.35,42.16 v1(86.61,41.9)
USB30_TX_PCH_P1: length 83.6
  TOP w0.127: PCH1.AF17 v6(164.2,34.6) ; SUSBC1.11 233.26,29.5 232.88,29.12 232.02,29.12 230.96,28.07 230.48,28.07 v1(230.22,28.33)
  L4 w0.14: v6(164.2,34.6) 164.83,34.6 166.14,33.29 166.14,33.11 166.44,32.81 166.61,32.81 166.91,32.52 166.91,32.34 167.21,32.05 167.38,32.05 167.68,31.75 167.68,31.57 167.98,31.28 168.15,31.28 170.34,29.09 170.34,27.63 171.44,26.53 175.45,26.53 178.37,29.45 181.97,29.45 182.1,29.33 182.52,29.33 182.64,29.45 183.06,29.45 183.18,29.33 183.6,29.33 183.73,29.45 184.18,29.45 184.45,29.72 187.05,29.72 187.07,29.74 192.55,29.74 194.2,31.39 194.38,31.39 194.68,31.69 194.68,31.87 194.97,32.16 195.15,32.16 195.44,32.46 195.44,32.63 195.74,32.93 195.92,32.93 196.21,33.23 196.21,33.4 196.51,33.7 199.74,33.7 199.87,33.57 200.29,33.57 200.41,33.7 200.83,33.7 200.95,33.57 201.37,33.57 201.5,33.7 201.92,33.7 202.04,33.57 202.46,33.57 202.58,33.7 215.58,33.7 219.54,29.74 230.32,29.74 230.84,29.22 230.84,28.17 230.68,28.01 230.54,28.01 v1(230.22,28.33)
USB31_RX_PCH_N0: length 91.1
  TOP w0.127: PCH1.AA11 v6(158.6,38.6) ; TYPEC1.31 97.75,7.75 97.87,7.87 97.87,9.08 97.16,9.79 97.16,11.4 v1(96.85,11.71)
  L3 w0.14: v6(158.6,38.6) 158.6,38.56 159.03,38.13 159.03,36.8 154.89,32.67 154.89,20.75 146.91,12.78 141.14,12.78 140.42,13.5 134.26,13.5 132.77,12.01 123.63,12.01 121.66,10.05 112.85,10.05 112.75,9.94 111.69,9.94 111.59,10.05 111.37,10.05 106.24,10.05 103.49,12.79 97.62,12.79 97.17,12.33 97.17,12.03 v1(96.85,11.71)
  BOTTOM w0.127: v1(96.85,11.71) 96.85,11.18 96.84,11.16 v5(96.84,11.08)
USB31_RX_PCH_N1: length 92.1
  TOP w0.127: v1(95.43,10.71) 95.12,10.4 95.12,7.88 95.25,7.75 TYPEC1.36 ; PCH1.AB13 v6(160.2,37.8)
  L3 w0.14: v1(95.43,10.71) 95.09,10.37 95.09,10.16 95.18,10.07 96.31,10.07 97.34,11.1 103.81,11.1 105.88,9.03 122.67,9.03 123.65,10.01 132.77,10.01 134.23,11.47 146.9,11.47 155.8,20.37 155.8,31.6 158.23,34.02 158.69,34.02 159.12,34.45 159.12,36.1 159.77,36.75 159.77,37.37 v6(160.2,37.8)
  BOTTOM w0.127: v1(95.43,10.71) 95.42,10.7 v5(95.42,10.08)
USB31_RX_PCH_P0: length 91.1
  TOP w0.127: TYPEC1.30 98.25,7.75 98.11,7.89 98.11,9.18 97.4,9.89 97.4,11.34 v1(97.76,11.71) ; PCH1.AB11 v6(159.4,38.6)
  L3 w0.14: v6(159.4,38.6) 159.29,38.49 159.29,36.69 155.16,32.56 155.16,20.64 147.02,12.51 141.03,12.51 140.31,13.23 134.37,13.23 132.88,11.75 123.74,11.75 121.77,9.78 112.96,9.78 112.86,9.68 111.58,9.68 111.48,9.78 106.13,9.78 103.38,12.52 99.59,12.52 99.46,12.4 99.04,12.4 98.92,12.52 97.74,12.52 97.43,12.22 97.43,12.04 v1(97.76,11.71)
  BOTTOM w0.127: v1(97.76,11.71) 97.8,11.74 97.8,12.21 v5(97.91,12.32)
USB31_RX_PCH_P1: length 91.8
  TOP w0.127: 94.88,9.5 94.88,10.35 v1(94.52,10.71) ; 94.88,9.5 v3(94.51,9.5) ; 94.88,9.5 94.88,7.88 94.75,7.75 TYPEC1.37 ; PCH1.AC13 v6(160.2,37)
  L3 w0.14: v1(94.52,10.71) 94.82,10.4 94.82,10.05 95.07,9.8 96.42,9.8 97.45,10.83 103.7,10.83 105.77,8.76 122.78,8.76 123.76,9.74 132.88,9.74 134.34,11.2 147.01,11.2 156.07,20.26 156.07,31.49 158.34,33.76 158.8,33.76 159.38,34.34 159.38,35.99 160.2,36.81 v6(160.2,37)
USB31_TX_PCH_N0: length 87.3
  TOP w0.127: TYPEC1.28 99.25,7.75 99.38,7.88 99.38,8.72 v1(99.03,9.07) ; PCH1.AF12 v6(160.2,34.6)
  L3 w0.14: v6(160.2,34.6) 160.26,34.54 160.69,34.54 160.78,34.44 160.78,33.81 160.05,33.07 158.7,33.07 156.72,31.09 156.72,19.99 147.26,10.53 139.72,10.53 139.37,10.17 138.49,10.17 138.36,10.3 137.94,10.3 137.82,10.17 137.4,10.17 137.27,10.3 136.85,10.3 136.72,10.17 136.3,10.17 136.18,10.3 135.76,10.3 135.63,10.17 135.21,10.17 134.14,9.09 124.03,9.09 122.92,7.99 114.44,7.99 113.8,7.35 110.3,7.35 110.17,7.48 109.75,7.48 109.63,7.35 109.21,7.35 109.08,7.48 108.66,7.48 108.54,7.35 108.12,7.35 108,7.48 107.58,7.48 107.45,7.35 104.4,7.35 104.08,7.68 104.08,9.36 103.4,10.03 99.64,10.03 99.35,9.74 99.35,9.39 v1(99.03,9.07)
  BOTTOM w0.127: v5(98.4,9.09) 99.01,9.09 v1(99.03,9.07)
USB31_TX_PCH_N1: length 92.8
  TOP w0.127: v6(161.93,31.74) 161.56,32.11 161.3,32.11 161.05,32.36 161.05,32.99 ; 161.05,32.99 v3(160.68,32.99) ; 161.05,32.99 161.05,33.78 161.54,34.28 161.54,34.86 PCH1.AF14 ; TYPEC1.34 96.25,7.49 96.41,7.65 96.41,8.84 v1(96.08,9.17)
  L3 w0.14: v6(161.93,31.74) 161.68,31.99 160.63,31.99 160.54,31.89 159.19,31.89 157.9,30.6 157.9,18.38 148.77,9.25 140.15,9.25 139.86,8.95 136.31,8.95 134.28,6.92 123.71,6.92 122.96,6.17 97.46,6.17 96.39,7.24 96.39,8.86 v1(96.08,9.17)
USB31_TX_PCH_P0: length 87.4
  TOP w0.127: v1(99.95,9.07) 99.62,8.74 99.62,7.88 99.75,7.75 TYPEC1.27 ; PCH1.AE12 v6(160.2,35.4)
  L3 w0.14: v1(99.95,9.07) 99.62,9.4 99.62,9.63 99.75,9.77 103.29,9.77 103.81,9.25 103.81,7.57 104.29,7.09 113.92,7.09 114.55,7.72 123.03,7.72 124.14,8.83 134.25,8.83 135.32,9.9 139.48,9.9 139.84,10.26 147.37,10.26 156.98,19.88 156.98,30.98 158.81,32.8 160.16,32.8 161.05,33.7 161.05,34.55 v6(160.2,35.4)
  BOTTOM w0.127: v1(99.95,9.07) 100,9.12 100,9.65 v5(100.04,9.69)
USB31_TX_PCH_P1: length 93.2
  TOP w0.127: v6(161.93,32.63) 161.64,32.35 161.47,32.35 161.29,32.52 161.29,33.68 161.79,34.18 161.79,35.41 PCH1.AE14 ; TYPEC1.33 96.75,7.54 96.65,7.65 96.65,8.82 v1(96.99,9.17)
  L3 w0.14: v6(161.93,32.63) 161.55,32.25 160.52,32.25 160.43,32.16 159.08,32.16 157.63,30.71 157.63,18.49 148.66,9.51 140.04,9.51 139.75,9.22 136.19,9.22 134.17,7.19 123.6,7.19 122.85,6.44 97.57,6.44 96.66,7.35 96.66,8.83 v1(96.99,9.17)
  BOTTOM w0.127: v5(97.11,9.79) 96.98,9.66 96.98,9.18 v1(96.99,9.17)
USB_CON_PN4: length 9.2
  TOP w0.127: 180.94,40.77 180.94,40.36 182.13,39.17 183.31,39.17 183.49,38.99 183.49,38 183.3,37.81 TR2.1 ; 180.94,40.77 v3(180.54,40.77) ; 180.94,40.77 180.94,42.35 181.2,42.62 181.86,42.62 181.99,42.75 WLAN1.5
USB_CON_PP4: length 8.9
  TOP w0.127: WLAN1.3 182.03,42.25 181.9,42.38 181.3,42.38 181.18,42.25 181.18,40.46 182.23,39.41 183.41,39.41 183.73,39.09 183.73,38.71 ; 183.73,38.71 183.73,38.01 183.98,37.76 TR2.4 ; 183.73,38.71 v3(184.12,38.71)
USB_CPU_PN0: length 224.8
  TOP w0.102: 106.88,10.62 106.88,7.88 106.75,7.75 TYPEC1.13 ; 106.88,10.62 106.88,11.08 100.49,17.48 94.77,17.48 93.57,16.28 93.12,16.28 v1(92.71,15.88) ; 106.88,10.62 v3(106.48,10.62) ; CPU1.AU8 152.61,175.39 150.57,175.39 150.37,175.18 149.25,175.18 148.97,175.46 148.97,175.74 v1(148.69,176.02)
  L6 w0.102: v1(148.69,176.02) 148.69,176.02 148.98,175.73 148.98,175.03 149.26,174.75 150.26,174.75 150.9,174.11 150.9,172.17 147.96,169.22 147.96,164.06 145.84,161.95 145.21,161.95 142.49,159.23 141.02,159.23 140.75,159.51 139.77,159.51 134.77,154.51 131.75,154.51 129.15,151.91 129.15,137.13 126.9,134.88 126.9,128.71 125.86,127.66 125.86,119.81 122.66,116.61 119.15,116.61 118.39,115.85 118.39,113.79 117.5,112.9 117.5,102.81 105.85,91.16 101.52,91.16 97.05,86.69 95.7,86.69 90.98,81.97 90.98,59.57 90.86,59.45 90.86,48.54 90.5,48.19 90.5,27.25 91.24,26.51 91.24,20.81 91.11,20.68 91.11,16.63 91.49,16.26 92.33,16.26 v1(92.71,15.88)
USB_CPU_PN1: length 170.1
  TOP w0.102: CPU1.AW9 150.61,174.39 149.86,174.39 149.25,173.78 149.25,173.3 v1(149.53,173.02) ; 88.06,48.11 88.91,48.11 v1(89.26,48.46) ; 88.06,48.11 84.88,48.11 84.75,48.25 RUSBC1.28 ; 88.06,48.11 v3(88.06,48.49)
  L6 w0.102: v1(89.26,48.46) 89.63,48.46 89.74,48.56 89.74,55.57 88.8,56.51 88.8,81.31 95.76,88.27 97.02,88.27 101.95,93.19 106.28,93.19 116.31,103.22 116.31,113.21 117.32,114.23 117.32,117.24 120.58,120.5 121.79,120.5 122.78,121.49 122.78,126.47 125.7,129.39 125.7,135.36 128.07,137.72 128.07,152.51 131.79,156.24 132.54,156.24 134.04,157.73 136.75,157.73 137.02,158 137.02,158.25 137.29,158.52 137.54,158.52 139.62,160.6 141.31,160.6 146.13,165.42 146.13,172.59 148.15,174.61 148.77,174.61 149.53,173.85 v1(149.53,173.02)
USB_CPU_PP0: length 224.7
  TOP w0.102: TYPEC1.12 107.25,7.75 107.11,7.88 107.11,9.14 ; CPU1.AU7 152.61,175.61 150.47,175.61 150.27,175.41 149.35,175.41 149.2,175.56 149.2,175.74 v1(149.48,176.02) ; 107.11,9.14 107.11,11.18 100.58,17.7 94.67,17.7 93.48,16.51 93.09,16.51 v1(92.71,16.89) ; 107.11,9.14 v3(107.49,9.14)
  L6 w0.102: v1(92.71,16.89) 92.33,16.51 91.59,16.51 91.36,16.74 91.36,17.04 91.51,17.19 91.51,17.5 91.36,17.65 91.36,20.57 91.49,20.7 91.49,26.62 90.75,27.36 90.75,48.08 91.11,48.44 91.11,59.34 91.24,59.47 91.24,81.86 95.81,86.44 97.15,86.44 101.62,90.91 105.96,90.91 117.75,102.7 117.75,112.79 118.64,113.68 118.64,115.74 119.26,116.36 122.76,116.36 126.11,119.71 126.11,127.56 127.15,128.6 127.15,134.77 129.4,137.02 129.4,151.8 131.85,154.25 134.87,154.25 136.34,155.72 136.48,155.72 136.75,155.99 136.75,156.13 137.02,156.4 137.16,156.4 137.43,156.67 137.43,156.81 137.69,157.08 137.84,157.08 138.1,157.34 138.1,157.48 139.88,159.26 140.64,159.26 140.92,158.98 142.6,158.98 145.31,161.7 145.95,161.7 148.21,163.96 148.21,169.11 151.16,172.06 151.16,174.22 150.37,175.01 149.36,175.01 149.24,175.14 149.24,175.78 v1(149.48,176.02)
USB_CPU_PP1: length 170.3
  TOP w0.102: 86.49,47.89 88.91,47.89 v1(89.26,47.54) ; 86.49,47.89 84.88,47.89 84.75,47.75 RUSBC1.27 ; 86.49,47.89 v3(86.49,47.5) ; CPU1.AW8 150.61,174.61 149.77,174.61 149.02,173.87 149.02,173.3 v1(148.74,173.02)
  L6 w0.102: v1(148.74,173.02) 148.74,173.2 148.92,173.38 148.92,174.11 148.67,174.36 148.26,174.36 146.38,172.48 146.38,165.31 141.42,160.35 139.73,160.35 136.86,157.48 134.14,157.48 132.64,155.98 131.89,155.98 128.32,152.41 128.32,137.61 125.96,135.25 125.96,129.28 123.04,126.36 123.04,121.38 121.9,120.24 120.69,120.24 117.58,117.13 117.58,114.12 116.56,113.11 116.56,103.11 106.39,92.94 102.06,92.94 97.13,88.01 95.86,88.01 89.05,81.2 89.05,56.62 89.99,55.68 89.99,48.46 89.26,47.72 v1(89.26,47.54)
USB_EN_S3WAKE: length 169.9
  TOP w0.114: v1(105.23,53.24) 105.16,53.24 104.62,53.77 104.06,53.77 104.04,53.75 103.35,53.75 103.35,53.74 KBC1.15 ; v1(183.01,9.65) 182.07,9.65 181.91,9.8 R358.1
  L6 w0.102: v1(105.23,53.24) 105.27,53.28 109.12,53.28 109.69,53.85 111.06,53.85 111.43,54.22 111.43,55.93 113.36,57.86 115.54,57.86 115.98,58.29 116.69,58.29 118.83,60.44 118.83,61.06 122.14,64.36 123.55,64.36 130.15,70.97 162.79,70.97 163.24,71.42 167.97,71.42 168.25,71.7 170.46,71.7 171.75,70.41 179.8,70.41 183.39,66.82 183.39,47.98 178.05,42.65 178.05,35.68 176.45,34.08 176.45,27 169.98,20.52 169.98,17.35 170.31,17.02 v1(170.31,12.19)
  BOTTOM w0.114: v1(170.31,12.19) 170.31,12.22 171.08,12.99 175.43,12.99 175.5,12.92 177.44,12.92 177.53,13.02 R343.1 180.53,13.02 v2(182.88,10.67) 183.01,10.54 v1(183.01,9.65)
USB_GPIO_C12: length 27.9
  TOP w0.114: CPU1.AU17 v6(152.53,166.53)
  L3 w0.114: v6(152.53,166.53) 151.39,166.53 150.84,165.98 149.87,165.98 149.63,166.22 148.44,166.22 146.94,164.72 145.26,164.72 143.3,162.76 140.76,162.76 139.04,161.04 137.49,161.04 136.72,160.27 136.72,157.02 135.92,156.22 135.92,154.56 v1(135.8,154.44)
  BOTTOM w0.114: v1(135.8,154.44) 135.33,154.9 v2(135.33,155.19) 135.48,155.35 136.23,155.35 R80.1
USB_GPIO_C13: length 3
  TOP w0.114: CPU1.AN23 v6(156.5,160.5)
  BOTTOM w0.114: v6(156.5,160.5) 156.91,160.91 v2(157.35,160.91) 157.52,160.74 R79.1
USB_OC0N: length 57.2
  TOP w0.114: PCH1.AF1 150.75,34.75 150.75,32.74 151.23,32.26 151.23,29.92 150.83,29.52 RN9.4 150.83,28.25 150.03,27.45 150.03,25.68 150.23,25.48 v3(150.97,24.74) 152.25,23.47 152.25,19.89 152.83,19.3 152.83,16.29 153.63,15.49 153.63,10.37 v1(153.54,10.29) ; v1(125.25,8.08) 125.25,7.75 125.25,7.74 LAUOC1.5
  L6 w0.102: v1(125.25,8.08) 126.06,8.89 134.34,8.89 135.44,9.99 152.63,9.99 152.95,10.32 153.51,10.32 v1(153.54,10.29)
USB_OC1N: length 7
  TOP w0.114: PCH1.AF2 151.35,34.55 v3(151.35,32.94) 151.35,32.62 151.57,32.4 151.57,29.78 151.48,29.68 RN9.3
USB_OC2N: length 86.5
  TOP w0.114: v1(98.35,36.5) 98.21,36.64 R345.2 ; RN8.4 152.84,29.81 152.45,30.2 v1(152.45,30.25) 152.4,30.25 151.92,30.73 151.92,32.7 151.92,32.71 151.92,34.57 152.21,34.86 152.21,35.41 PCH1.AE3
  L6 w0.102: v1(98.35,36.5) 98.35,36.58 97.74,37.19 97.74,45.9 97.1,46.53 97.1,48.2 97.4,48.49 98.48,48.49 102.06,44.91 112.92,44.91 113.16,44.67 133.76,44.67 139.76,38.68 140.22,38.68 141.53,37.36 141.53,34.82 144.4,31.95 144.96,31.95 145.31,31.6 145.75,31.6 146.48,30.86 148.77,30.86 149.1,30.53 149.67,30.53 150.6,29.61 150.6,29.58 150.86,29.31 151.51,29.31 v1(152.45,30.25)
  BOTTOM w0.114: v1(98.35,36.5) 98.79,36.95 v5(99.06,36.95)
USB_OC3N: length 93.5
  TOP w0.114: RN8.3 153.49,30.18 153.21,30.45 v1(153.21,31.8) 152.88,31.8 152.26,32.42 152.26,34.57 152.6,34.91 PCH1.AF3 ; v1(223.77,21.77) 223.65,21.64 R332.2
  L4 w0.114: v1(153.21,31.8) 153.21,31.6 153.8,31.01 159.18,31.01 160.58,29.62 165.43,29.62 170.61,24.43 177.14,24.43 185.8,15.77 204.27,15.77 205.41,14.63 217.47,14.63 219.15,12.95 220.37,12.95 223.37,15.96 223.37,19.91 223.77,20.32 v1(223.77,21.77)
  BOTTOM w0.114: v2(223.2,22.34) v1(223.77,21.77)
USB_OC4N: length 6.9
  TOP w0.114: PCH1.AF4 153.4,34.76 153.05,34.4 153.05,33.27 153.42,32.9 153.42,32.73 154.04,32.12 154.04,31.03 v3(154.26,30.81) 154.74,30.34 155.06,30.34 155.52,29.87 RN10.3
USB_OC5N: length 7.8
  TOP w0.114: RN10.4 154.62,29.43 153.83,30.22 153.83,30.32 153.7,30.46 153.7,31.97 153.4,32.26 153.26,32.26 v3(152.86,32.66) 152.68,32.84 152.68,34.5 153.04,34.86 153.04,35.44 153.4,35.8 PCH1.AE4
USB_OC6N: length 10
  TOP w0.114: PCH1.AE5 153.84,35.44 153.84,34.69 153.4,34.25 153.4,33.43 154.15,32.68 v3(154.28,32.68) 154.38,32.57 154.38,31.5 156.08,29.79 156.08,29.48 156.65,28.91 157.41,28.91 157.55,29.05 RN19.3
USB_OC7N: length 90.5
  TOP w0.114: 156.9,29.56 156.04,30.42 155.98,30.42 155.64,30.75 155.64,30.82 155.15,31.31 155.14,31.31 154.81,31.64 154.81,32.11 154.84,32.15 154.84,32.94 154.51,33.27 154.05,33.27 153.75,33.57 153.75,34.09 154.2,34.54 PCH1.AF5 ; 156.9,29.56 RN19.4 ; 156.9,29.56 156.9,29.79 157.05,29.94 157.81,29.94 159.05,28.7 168.1,28.7 170.94,25.86 177.55,25.86 v1(177.95,25.45) ; v1(181.36,7.62) 180.78,7.62 180.25,7.09 R359.2 180.25,6.18 180.7,5.74 R360.1 C428.1 179.36,5.55 179.02,5.21 178.56,5.21 178.34,5.43 U13.3 ; R2775.2 188.2,18.02 v1(188.29,18.11)
  L4 w0.114: v1(181.36,7.62) 179.96,7.62 177.93,9.65 177.16,9.65 177.04,9.53 172.97,9.53 171.09,11.4 v1(171.09,12.32) ; v1(188.29,18.11) 187.96,18.44 186.16,18.44 182.75,21.84 182.75,23.62 181.38,24.99 178.66,24.99 178.21,25.45 v1(177.95,25.45)
  L6 w0.102: v1(171.09,12.32) 171.09,15.72 173.3,17.93 173.3,21.83 176.93,25.45 v1(177.95,25.45)
  BOTTOM w0.114: v2(178.31,24.69) 178.31,25.1 v1(177.95,25.45) ; v1(171.09,12.32) 171.21,12.2 R347.2 172.52,12.18 C426.1 R350.1 174.69,12.18 175.54,11.33 v2(175.54,10.26) 176.01,9.79 U11.3
USB_PCH_DN3_NN: length 7.3
  TOP w0.127: v1(229.83,64.11) 229.46,63.75 229.01,63.75 228.51,64.25 WEBCM1.11
  BOTTOM w0.127: 231.95,63.37 232.33,63 232.33,61.58 232.55,61.36 TR1.2 ; 231.95,63.37 v2(232.21,63.63) ; 231.95,63.37 231.82,63.51 231.11,63.51 230.85,63.76 D16.2 230.17,63.76 v1(229.83,64.11)
USB_PCH_DP3_PP: length 7
  TOP w0.127: WEBCM1.10 228.51,63 229.01,63.5 229.51,63.5 v1(229.83,63.19)
  BOTTOM w0.127: TR1.3 231.87,61.38 232.09,61.6 232.09,62.41 ; 232.09,62.41 v2(231.75,62.41) ; 232.09,62.41 232.09,62.9 231.72,63.27 231.11,63.27 230.85,63.01 D15.2 230.32,63.4 230.03,63.4 v1(229.83,63.19)
USB_PCH_PN0: length 99.9
  TOP w0.127: v3(102.9,11.51) 103.17,11.78 ; 103.17,11.78 103.88,11.07 103.88,7.88 103.75,7.75 TYPEC1.19 ; 103.17,11.78 101.33,13.61 96.27,13.61 v1(95.94,13.28) ; PCH1.AE2 v6(151.4,35.4)
  L3 w0.14: v1(95.94,13.28) 95.61,13.61 95.36,13.61 95.07,13.9 95.07,30.93 96.62,32.49 96.62,33.27 99.17,35.83 99.33,35.98 99.93,35.98 104.36,40.41 104.36,41.91 107.25,44.81 135.45,44.81 135.61,44.65 140.5,39.76 144.82,39.76 148.2,36.39 150.76,36.39 151.13,36.02 151.13,35.67 v6(151.4,35.4)
USB_PCH_PN1: length 102.5
  TOP w0.127: PCH1.AC5 v6(153.8,37.8) ; v3(104.98,10.46) 105.38,10.46 ; 105.38,10.46 105.38,11.3 101.46,15.21 98.11,15.21 v1(97.79,14.89) ; 105.38,10.46 105.38,7.88 105.25,7.75 TYPEC1.16
  L3 w0.14: v6(153.8,37.8) 153.87,37.73 153.87,36.12 151.76,34.01 148.97,34.01 144.01,38.98 139.91,38.98 136.74,42.15 131.97,42.15 130.64,43.47 126.4,43.47 125.98,43.05 121.94,43.05 120.9,44.09 107.54,44.09 105.07,41.62 105.07,40.12 98.2,33.24 98.2,32.21 98.07,32.09 98.07,31.67 98.2,31.54 98.2,31.12 98.07,31 98.07,30.58 98.2,30.46 98.2,22.75 96.86,21.42 96.86,15.57 97.22,15.21 97.47,15.21 v1(97.79,14.89)
USB_PCH_PN2: length 75.6
  TOP w0.127: 88.75,45.12 94.29,45.12 v1(94.61,45.45) ; 88.75,45.12 84.88,45.12 84.75,45.25 RUSBC1.22 ; 88.75,45.12 v3(88.75,45.52) ; PCH1.Y4 v6(153,40.2)
  L3 w0.14: v6(153,40.2) 152.15,41.05 150.98,41.05 149.66,42.37 149.66,43.79 146.25,47.19 128.83,47.19 127.97,46.33 119.08,46.33 118.21,47.19 110.69,47.19 110.34,46.84 105.85,46.84 105.24,46.23 100.09,46.23 99.83,45.96 96.21,45.96 95.42,45.17 94.89,45.17 v1(94.61,45.45)
USB_PCH_PN3: length 156.7
  TOP w0.127: PCH1.AB2 v6(151.4,38.6)
  L4 w0.14: v1(232.66,59) 232.34,58.68 232.34,57.78 232.59,57.53 232.59,37.64 233.23,37 233.23,23.31 232.84,22.92 232.84,13.44 227.44,8.04 221.6,8.04 219.67,6.11 217.05,6.11 217.04,6.12 205.9,6.12 204.46,7.56 186,7.56 182.74,10.81 182.36,10.81 176.91,16.26 175.52,16.26 174,17.77 174,18.2 171.86,20.35 169.27,20.35 165.57,24.04 164.28,24.04 164.26,24.05 154.84,24.05 154.77,24.05 154.65,24.04 154.64,24.04 v1(154.33,23.7)
  BOTTOM w0.127: 149.31,36.53 149.31,38.27 149.95,38.9 150.28,38.9 150.42,39.04 150.96,39.04 v6(151.4,38.6) ; 149.31,36.53 149.31,35.13 152.41,32.03 152.41,31.27 153.29,30.39 153.29,24.79 153.72,24.36 153.75,24.36 154.33,23.77 v1(154.33,23.7) ; 149.31,36.53 v2(148.97,36.53) ; TR1.1 232.55,59.12 v1(232.66,59)
USB_PCH_PN4: length 46.3
  TOP w0.127: 183.5,31.9 183.5,31.1 179.83,27.43 179.22,27.43 v1(178.88,27.77) ; 183.5,31.9 v3(183.11,31.9) ; 183.5,31.9 183.5,35.27 183.3,35.47 TR2.2 ; PCH1.AD2 v6(151.4,37)
  L4 w0.14: v6(151.4,37) 151.13,36.73 151.13,36.57 151.51,36.2 153.29,36.2 155.63,33.86 158.37,33.86 158.67,33.56 158.84,33.56 159.14,33.27 159.14,33.09 159.43,32.79 159.61,32.79 159.91,32.5 159.91,32.32 160.2,32.02 160.38,32.02 160.68,31.73 160.68,31.55 161.1,31.13 162.66,31.13 162.79,31.25 163.21,31.25 163.33,31.13 163.75,31.13 163.88,31.25 164.29,31.25 164.42,31.13 165.93,31.13 171.17,25.88 171.2,25.88 171.22,25.86 176.05,25.86 177.62,27.43 178.55,27.43 v1(178.88,27.77)
USB_PCH_PN10: length 61.9
  TOP w0.127: v3(101.22,41.53) 101.22,41.92 ; 101.22,41.92 101.87,41.92 v1(102.23,41.55) ; 101.22,41.92 100.59,41.92 100.46,41.79 U12.2 ; PCH1.W6 v6(154.6,40.2)
  L3 w0.14: v6(154.6,40.2) 154.33,39.93 154.33,39.68 154.02,39.37 150.44,39.37 148.82,41 148.82,43.23 146.8,45.25 105.86,45.25 103.94,43.34 103.94,42.91 102.9,41.86 102.54,41.86 v1(102.23,41.55)
USB_PCH_PN10_CHAR: length 14.1
  TOP w0.127: v3(90.32,42.75) 90.6,43.02 ; 90.6,43.02 90.01,43.61 85.37,43.61 85.14,43.38 84.63,43.38 84.5,43.25 RUSBC1.18 ; 90.6,43.02 91.7,41.92 96.01,41.92 96.14,41.79 U12.11
USB_PCH_PN11: length 88.5
  TOP w0.127: U10.2 219.82,16 v1(219.51,16.31) ; PCH1.V4 v6(153,41.8)
  L4 w0.14: v1(219.51,16.31) 219.13,15.94 205.55,15.94 204.61,16.88 186.83,16.88 179.35,24.36 178.33,24.36 177.55,25.15 170.89,25.15 165.71,30.33 160.86,30.33 158.15,33.03 154.11,33.03 152.32,34.82 150.55,34.82 149.86,35.51 149.86,40.26 150.62,41.02 152.22,41.02 v6(153,41.8)
USB_PCH_PN11_CHAR: length 20.2
  TOP w0.127: SUSBC1.12 227.62,29.5 227.1,28.98 226.91,28.98 226.49,29.4 226.03,29.4 ; v3(226.03,29.79) 226.03,29.4 ; 226.03,29.4 225.73,29.4 225.45,29.12 225.45,28.48 225.05,28.09 v1(225.04,28.09) ; U10.11 224.94,16 v1(225.2,16.26)
  L6 w0.127: v1(225.04,28.09) 225.37,27.76 225.37,24.96 226.52,23.82 226.52,16.26 226.21,15.95 225.51,15.95 v1(225.2,16.26)
USB_PCH_PN12: length 115.9
  TOP w0.127: PCH1.V2 151.4,41.8 148.24,41.8 v1(147.96,42.09) ; SDRDC1.5 227.71,16.1 v1(227.51,16.31)
  L4 w0.14: v1(147.96,42.09) 147.68,41.81 146.86,41.81 146.23,41.17 146.23,40.19 145.29,39.25 145.29,37.19 151.6,30.88 151.6,29.76 152.47,28.89 154.8,28.89 157.04,26.66 166.36,26.66 170.26,22.76 173.81,22.76 178.45,18.12 178.45,18.12 179.03,17.54 180.84,17.54 183.25,15.13 183.25,12.71 187.57,8.39 220.84,8.39 222,9.55 222,10.9 224.08,12.98 225.7,12.98 226.41,13.69 227.97,13.69 228.73,14.45 228.73,15.69 228.43,15.98 227.83,15.98 v1(227.51,16.31)
  BOTTOM w0.127: v1(227.51,16.31) 228.17,16.31 v2(228.19,16.28)
USB_PCH_PN13: length 60.7
  TOP w0.127: v1(147.98,40.09) 148.32,39.75 148.63,39.75 149.86,40.98 151.42,40.98 PCH1.W2 ; TR3.1 185.26,12.07 184.98,12.35 184.98,12.59 v1(184.53,13.03)
  L4 w0.14: v1(147.98,40.09) 147.66,39.76 147.08,39.76 146.39,39.08 146.39,37.35 153.48,30.26 155.21,30.26 156.77,28.7 165.33,28.7 170.4,23.63 175.98,23.63 184.68,14.94 184.68,13.18 v1(184.53,13.03)
  BOTTOM w0.127: v5(184.54,12.4) 184.54,13.02 v1(184.53,13.03)
USB_PCH_PP0: length 99.9
  TOP w0.127: v3(102.67,13.13) 102.41,12.88 ; 102.41,12.88 101.43,13.86 96.28,13.86 v1(95.94,14.2) ; 102.41,12.88 104.12,11.17 104.12,7.88 104.25,7.75 TYPEC1.18 ; PCH1.AE1 v6(150.6,35.4)
  L3 w0.14: v6(150.6,35.4) 150.86,35.66 150.86,35.91 150.65,36.12 148.09,36.12 144.71,39.5 140.39,39.5 135.34,44.54 107.36,44.54 104.62,41.8 104.62,40.3 100.04,35.72 99.44,35.72 96.89,33.16 96.89,32.38 95.33,30.82 95.33,29.38 95.46,29.26 95.46,28.84 95.33,28.71 95.33,28.3 95.46,28.17 95.46,27.75 95.33,27.63 95.33,27.21 95.46,27.08 95.46,26.66 95.33,26.54 95.33,25.02 95.46,24.89 95.46,24.47 95.33,24.35 95.33,23.93 95.46,23.81 95.46,23.39 95.33,23.26 95.33,22.84 95.46,22.72 95.46,22.3 95.33,22.18 95.33,20.2 95.46,20.08 95.46,19.66 95.33,19.53 95.33,19.11 95.46,18.99 95.46,18.57 95.33,18.45 95.33,18.03 95.46,17.9 95.46,17.48 95.33,17.36 95.33,14.01 95.47,13.87 95.61,13.87 v1(95.94,14.2)
USB_PCH_PP1: length 102.5
  TOP w0.127: v3(106.02,9.17) 105.62,9.17 ; 105.62,9.17 105.62,11.4 101.56,15.46 98.14,15.46 v1(97.79,15.81) ; 105.62,9.17 105.62,7.88 105.75,7.75 TYPEC1.15 ; v6(154.6,37.83) 154.61,37.82 154.61,37.79 PCH1.AC6
  L3 w0.14: v6(154.6,37.83) 154.34,37.56 154.14,37.35 154.14,36.01 151.88,33.74 148.86,33.74 143.89,38.71 139.8,38.71 136.63,41.88 131.86,41.88 130.53,43.21 126.51,43.21 126.09,42.79 121.83,42.79 120.79,43.83 107.65,43.83 105.33,41.51 105.33,40.01 98.46,33.13 98.46,22.64 97.13,21.31 97.13,15.68 97.33,15.48 97.47,15.48 v1(97.79,15.81)
USB_PCH_PP2: length 75.6
  TOP w0.127: RUSBC1.21 84.75,44.75 84.88,44.88 92.08,44.88 ; PCH1.Y3 v6(152.2,40.2) ; v3(92.08,44.48) 92.08,44.88 ; 92.08,44.88 94.27,44.88 v1(94.61,44.53)
  L3 w0.14: v6(152.2,40.2) 152.32,40.32 152.32,40.51 152.04,40.78 150.87,40.78 149.39,42.26 149.39,43.68 146.14,46.93 128.94,46.93 128.08,46.06 118.96,46.06 118.1,46.93 110.8,46.93 110.45,46.57 109.22,46.57 109.09,46.45 108.67,46.45 108.55,46.57 108.13,46.57 108.01,46.45 107.59,46.45 107.46,46.57 105.96,46.57 105.35,45.96 100.2,45.96 99.94,45.69 99.58,45.69 99.45,45.57 99.03,45.57 98.91,45.69 98.49,45.69 98.37,45.57 97.95,45.57 97.82,45.69 97.4,45.69 97.28,45.57 96.86,45.57 96.74,45.69 96.32,45.69 95.53,44.91 94.97,44.91 94.61,44.55 v1(94.61,44.53)
USB_PCH_PP3: length 157.1
  TOP w0.127: PCH1.AB1 v6(150.6,38.6)
  L4 w0.14: v1(154.28,24.61) 154.62,24.31 154.62,24.31 154.75,24.31 154.76,24.31 154.76,24.32 164.37,24.32 164.39,24.31 165.68,24.31 169.38,20.61 171.97,20.61 174.27,18.31 174.27,17.88 175.63,16.52 177.02,16.52 177.32,16.23 177.49,16.23 177.79,15.93 177.79,15.75 178.09,15.46 178.26,15.46 178.56,15.16 178.56,14.99 178.86,14.69 179.03,14.69 179.33,14.39 179.33,14.22 182.47,11.07 182.85,11.07 186.11,7.82 204.57,7.82 206.01,6.38 206.56,6.38 206.68,6.51 207.1,6.51 207.23,6.38 207.65,6.38 207.77,6.51 208.19,6.51 208.31,6.38 208.73,6.38 208.86,6.51 209.28,6.51 209.4,6.38 213.18,6.38 213.3,6.51 213.72,6.51 213.85,6.38 214.26,6.38 214.39,6.51 214.81,6.51 214.93,6.38 215.35,6.38 215.48,6.51 215.9,6.51 216.02,6.38 217.16,6.38 217.16,6.38 219.56,6.38 221.49,8.31 227.33,8.31 227.64,8.61 227.64,8.79 227.94,9.08 228.11,9.08 228.41,9.38 228.41,9.56 228.71,9.85 228.88,9.85 230.27,11.24 230.27,11.42 230.57,11.71 230.74,11.71 231.04,12.01 231.04,12.19 231.33,12.48 231.51,12.48 231.81,12.78 231.81,12.95 232.1,13.25 232.28,13.25 232.58,13.55 232.58,16.84 232.45,16.97 232.45,17.39 232.58,17.51 232.58,17.93 232.45,18.06 232.45,18.47 232.58,18.6 232.58,19.02 232.45,19.14 232.45,19.56 232.58,19.69 232.58,23.04 232.96,23.42 232.96,36.89 232.32,37.53 232.32,37.73 232.2,37.86 232.2,38.27 232.32,38.4 232.32,38.82 232.2,38.94 232.2,39.36 232.32,39.49 232.32,39.91 232.2,40.03 232.2,40.45 232.32,40.57 232.32,42.99 232.2,43.12 232.2,43.54 232.32,43.66 232.32,44.08 232.2,44.2 232.2,44.62 232.32,44.75 232.32,45.17 232.2,45.29 232.2,45.71 232.32,45.84 232.32,48.1 232.2,48.23 232.2,48.65 232.32,48.77 232.32,49.19 232.2,49.31 232.2,49.73 232.32,49.86 232.32,50.28 232.2,50.4 232.2,50.82 232.32,50.94 232.32,53.58 232.2,53.7 232.2,54.12 232.32,54.25 232.32,54.67 232.2,54.79 232.2,55.21 232.32,55.34 232.32,55.75 232.2,55.88 232.2,56.3 232.32,56.42 232.32,57.42 232.07,57.67 232.07,58.68 v1(231.75,59)
  BOTTOM w0.127: v1(154.28,24.61) 153.81,24.61 153.53,24.89 153.53,30.49 152.65,31.37 152.65,32.13 151.89,32.89 ; 151.89,32.89 v2(152.15,33.15) ; 151.89,32.89 149.56,35.23 149.56,38.17 150.05,38.66 150.54,38.66 v6(150.6,38.6) ; v1(231.75,59) 231.87,59.12 TR1.4
USB_PCH_PP4: length 46.6
  TOP w0.127: 181.92,29.18 179.93,27.19 179.22,27.19 v1(178.88,26.85) ; 181.92,29.18 v3(182.19,28.91) ; 181.92,29.18 183.74,31 183.74,35.28 183.98,35.52 TR2.3 ; PCH1.AD1 v6(150.6,37)
  L4 w0.14: v1(178.88,26.85) 178.57,27.17 177.73,27.17 176.16,25.59 171.09,25.59 165.82,30.86 160.99,30.86 158.26,33.59 155.52,33.59 153.18,35.93 151.4,35.93 150.87,36.46 150.87,36.73 v6(150.6,37)
USB_PCH_PP10: length 62
  TOP w0.127: v1(102.24,42.49) 101.91,42.16 100.59,42.16 100.46,42.29 U12.3 ; PCH1.W5 v6(153.8,40.2)
  L3 w0.14: v1(102.24,42.49) 102.6,42.13 102.78,42.13 103.68,43.02 103.68,43.45 105.75,45.52 143.54,45.52 143.67,45.64 144.09,45.64 144.21,45.52 144.63,45.52 144.75,45.64 145.17,45.64 145.3,45.52 145.72,45.52 145.84,45.64 146.26,45.64 146.38,45.52 146.91,45.52 149.09,43.35 149.09,41.11 150.55,39.64 153.91,39.64 154.07,39.79 154.07,39.93 v6(153.8,40.2)
  BOTTOM w0.127: v1(102.24,42.49) 102.25,42.5 v2(102.85,42.5)
USB_PCH_PP10_CHAR: length 14.1
  TOP w0.127: 92.66,42.16 96.01,42.16 96.14,42.29 U12.10 ; 92.66,42.16 v3(92.66,42.55) ; 92.66,42.16 91.8,42.16 90.11,43.85 85.27,43.85 85.04,43.62 84.6,43.62 84.47,43.75 RUSBC1.19
USB_PCH_PP11: length 89.3
  TOP w0.127: U10.3 220.44,15.5 220.32,15.62 219.73,15.62 v1(219.51,15.4) ; PCH1.V3 v6(152.2,41.8)
  L4 w0.14: v6(152.2,41.8) 152.2,41.56 151.93,41.29 150.51,41.29 149.59,40.37 149.59,35.4 150.44,34.56 152.21,34.56 154,32.77 158.04,32.77 160.75,30.06 165.6,30.06 170.78,24.88 177.44,24.88 178.22,24.09 179.24,24.09 186.72,16.61 204.5,16.61 205.44,15.67 219.23,15.67 v1(219.51,15.4)
  BOTTOM w0.127: v1(219.51,15.4) 219.68,15.57 v2(220.21,15.57)
USB_PCH_PP11_CHAR: length 20.5
  TOP w0.127: v1(225.96,28.12) 225.69,28.39 225.69,29.02 225.83,29.16 226.39,29.16 226.81,28.74 227.16,28.74 227.41,28.5 SUSBC1.10 ; v1(225.2,15.34) 225.05,15.5 U10.10
  L6 w0.127: v1(225.96,28.12) 225.63,27.79 225.63,25.07 226.77,23.93 226.77,19.2 226.9,19.08 226.9,18.7 226.77,18.57 226.77,18.19 226.9,18.07 226.9,17.69 226.77,17.56 226.77,16.15 226.31,15.7 225.56,15.7 v1(225.2,15.34)
  BOTTOM w0.127: v2(224.5,15.34) v1(225.2,15.34)
USB_PCH_PP12: length 115.5
  TOP w0.127: v1(227.51,15.39) 227.66,15.54 228.02,15.54 228.26,15.3 SDRDC1.4 ; PCH1.V1 150.85,41.55 150.75,41.55 150.74,41.56 149,41.56 ; v3(149,41.17) 149,41.56 ; 149,41.56 148.34,41.56 v1(147.96,41.17)
  L4 w0.14: v1(147.96,41.17) 147.59,41.54 146.97,41.54 146.49,41.06 146.49,40.08 145.55,39.14 145.55,37.3 145.85,37 146.03,37 146.32,36.71 146.32,36.53 146.62,36.23 146.8,36.23 147.09,35.94 147.09,35.76 147.39,35.47 147.56,35.47 147.86,35.17 147.86,34.99 148.73,34.12 148.91,34.12 149.2,33.83 149.2,33.65 149.5,33.36 149.67,33.36 149.97,33.06 149.97,32.88 150.27,32.59 150.44,32.59 150.74,32.29 150.74,32.12 151.87,30.99 151.87,29.87 152.58,29.16 154.91,29.16 155.21,28.86 155.39,28.86 155.68,28.57 155.68,28.39 155.98,28.09 156.16,28.09 156.45,27.8 156.45,27.62 157.15,26.92 159.33,26.92 159.46,27.05 159.88,27.05 160,26.92 160.42,26.92 160.54,27.05 160.96,27.05 161.09,26.92 161.51,26.92 161.63,27.05 162.05,27.05 162.17,26.92 163.27,26.92 163.39,27.05 163.81,27.05 163.94,26.92 164.36,26.92 164.48,27.05 164.9,27.05 165.02,26.92 166.47,26.92 170.37,23.03 173.92,23.03 177.61,19.34 177.78,19.34 178.08,19.05 178.08,18.87 178.37,18.57 178.55,18.57 178.85,18.28 178.85,18.1 179.14,17.81 180.95,17.81 183.51,15.24 183.51,12.82 185.41,10.93 185.59,10.93 185.88,10.63 185.88,10.45 186.18,10.16 186.36,10.16 186.65,9.86 186.65,9.69 187.68,8.66 188.81,8.66 188.94,8.79 189.36,8.79 189.48,8.66 189.9,8.66 190.03,8.79 190.45,8.79 190.57,8.66 190.99,8.66 191.11,8.79 191.53,8.79 191.66,8.66 211.54,8.66 211.66,8.79 212.08,8.79 212.21,8.66 213.93,8.66 214.05,8.79 214.47,8.79 214.6,8.66 215.02,8.66 215.14,8.79 215.56,8.79 215.69,8.66 216.1,8.66 216.23,8.79 216.65,8.79 216.77,8.66 220.73,8.66 221.73,9.66 221.73,11.01 223.97,13.25 225.59,13.25 226.3,13.96 227.85,13.96 228.46,14.56 228.46,15.58 228.32,15.72 227.83,15.72 v1(227.51,15.39)
USB_PCH_PP13: length 60.4
  TOP w0.127: v1(185.47,13) 185.22,12.75 185.22,12.45 185.94,11.73 TR3.4 ; v1(147.98,39.17) 148.32,39.51 148.73,39.51 148.79,39.57 ; v3(149.07,39.29) 148.79,39.57 ; 148.79,39.57 149.96,40.74 150.86,40.74 PCH1.W1
  L4 w0.14: v1(185.47,13) 184.95,13.53 184.95,15.05 181.41,18.59 181.41,18.77 181.11,19.06 180.93,19.06 180.64,19.36 180.64,19.53 180.34,19.83 180.16,19.83 179.87,20.13 179.87,20.3 179.57,20.6 179.4,20.6 178.4,21.6 178.4,21.77 178.1,22.07 177.93,22.07 177.63,22.36 177.63,22.54 177.34,22.84 177.16,22.84 176.09,23.9 170.51,23.9 165.44,28.97 164.1,28.97 163.98,29.09 163.56,29.09 163.43,28.97 163.01,28.97 162.89,29.09 162.47,29.09 162.35,28.97 160.51,28.97 160.38,29.09 159.96,29.09 159.84,28.97 159.42,28.97 159.3,29.09 158.88,29.09 158.75,28.97 158.33,28.97 158.21,29.09 157.79,29.09 157.67,28.97 156.88,28.97 155.32,30.53 153.59,30.53 146.66,37.46 146.66,38.97 147.19,39.5 147.66,39.5 v1(147.98,39.17)
USB_SS_ZVDDP_APU: length 2.9
  TOP w0.114: CPU1.AK8 v6(159.5,174.48)
  BOTTOM w0.114: v6(159.5,174.48) 159.59,174.38 R84.2 160.47,174.73 160.34,174.86 v2(160.34,175.54)
USB_SS_ZVSS_APU: length 6.8
  TOP w0.114: CPU1.AJ4 v6(161.47,179.5)
  BOTTOM w0.114: R90.2 159.64,184.47 v2(159.64,181.99) 159.64,180.78 160.33,180.09 160.89,180.09 v6(161.47,179.5)
USB_TOUCH_N: length 5.1
  TOP w0.127: TR3.2 185.26,9.59 185.47,9.37 185.47,9.04 184.95,8.52 C493.1 185.38,8.03 185.38,6.83 185,6.45 TOUCH1.4
USB_TOUCH_P: length 5.5
  TOP w0.127: TOUCH1.3 186,6.45 185.62,6.83 185.62,7.32 ; TR3.3 185.94,9.56 185.72,9.35 185.72,9.02 186.22,8.52 C494.1 185.62,7.86 185.62,7.32 ; v3(185.98,7.32) 185.62,7.32
USB_ZVSS: length 2.7
  TOP w0.114: CPU1.AT11 v6(153.45,171.48)
  BOTTOM w0.114: v2(153.47,170.36) 153.45,170.38 v6(153.45,171.48) 153.46,171.49 R85.2
USBVCC31: length 3.2
  TOP w0.508: v4(168.68,10.01) v4(168.68,8.84) 168.5,8.66 RPWRC1.3
  vias: v2(170.05,9.78) v2(173.74,8.89) v2(177.42,5.59)
USBVCC31_EN: length 5.6
  BOTTOM w0.114: v2(176.95,12.26) 177.09,12.13 R343.2 177.98,12.18 178.99,12.18 R342.2 179.06,12.14 C424.1 178.69,10.78 178.69,10.03 178.93,9.79 U11.4
USBVCC32: length 1.7
  TOP w0.508: RPWRC1.21 v4(159.5,8.51)
  vias: v3(174.12,8.26) v4(159.51,9.53) v4(174.37,7.24)
USBVCC32_EN: length 6.6
  TOP w0.114: U13.4 178.34,8.96 178.43,9.05 178.43,10.01 C427.1 179.49,10.06 R358.2 179.74,9.14 v3(180.48,8.41) R357.2
USBVCCTP: length 1.7
  TOP w0.508: v4(184,7.26) TOUCH1.5
  vias: v4(186.56,12.83) v4(187.63,12.8) v5(184.96,8.57) v5(186.11,10.84)
USBVCCTP_EN: length 158.1
  TOP w0.114: R2659.1 181.29,16.32 181.08,16.1 180.06,16.1 v1(179.74,16.42) ; KBC1.113 110.05,60.13 110.57,59.61 110.57,57.45 109.3,56.18 v1(109.3,54.36)
  L3 w0.114: v1(172.59,18.62) 173.1,18.62 173.33,18.85 177.32,18.85 v1(179.74,16.42)
  L6 w0.102: v1(172.59,18.62) 172.59,22.12 177.16,26.7 177.16,33.78 179.05,35.67 180.54,35.67 181.53,36.67 181.53,42.11 184.1,44.68 184.1,67.11 180.09,71.12 172.05,71.12 170.75,72.42 167.95,72.42 167.68,72.14 162.95,72.14 162.53,71.72 162.49,71.68 131.26,71.68 131.26,71.68 129.86,71.68 124.08,65.9 123.42,65.9 122.59,65.07 121.84,65.07 118.89,62.12 118.5,62.12 117.32,60.94 117.32,60.1 116.23,59 115.68,59 115.25,58.57 112.61,58.57 109.3,55.26 v1(109.3,54.36)
  BOTTOM w0.114: v2(173.56,18.62) v1(172.59,18.62)
USBVCCTP_EN_R: length 4.4
  TOP w0.114: R2659.2 181.55,17.12 C1144.1 181.58,17.59 182.5,17.59 v3(182.55,17.54) 183.42,16.67 U44.4
USBVCCTP_OC: length 6.1
  TOP w0.114: U44.3 185.44,16.67 184.43,17.68 R2661.2 R2660.1 186.39,18.05 C1145.1 186.46,18.02 R2775.1
V_3P0_BAT_VREG: length 253.7
  TOP w0.508: R2753.1 109.52,71.55 110.95,70.13 v1(110.95,66.5) ; U5.3 125.4,43.35 125.4,44.06 C300.1 126.1,44.76 126.1,44.95 127.23,46.08 127.23,47.9 126.75,48.39 125.5,48.39 124.49,49.4 v1(124.49,49.99) ; v1(117.6,77.9) 117.6,78.21 117.35,78.46 R2754.1 116.67,78.45 C2511.1 116.67,76.84 116.32,76.5 U2505.8
  TOP w0.762: D4.3 183.36,19.35 183.85,19.84 184.1,19.84 v1(184.78,20.52)
  L3 w0.508: v1(124.49,49.99) 124.31,50.16 124.31,50.39 123.92,50.77 123.37,50.77 123.25,50.65 121.35,50.65 121.22,50.51 120.25,50.51 120.01,50.27 119.46,50.27 119.08,50.65 118.72,50.65 118.41,50.95 117.23,50.95 114.2,53.98 114.2,54.91 112.67,56.44 111.84,56.44 111.81,56.41 108.88,56.41 v1(108.79,56.31)
  L3 w0.762: v1(176.12,14.43) 175.47,15.08 174.3,15.08 172.67,16.71 170.25,16.71 169.18,17.78 v1(166.62,17.78)
  L6 w0.508: v1(204.04,33.1) 203.45,33.68 198.53,33.68 196.22,31.37 193.62,31.37 188.85,26.59 188.85,23.34 186.75,21.23 185.5,21.23 v1(184.78,20.52) ; v1(108.79,56.31) 108.79,56.04 108.38,55.64 108.38,55.53 107.99,55.14 104.01,55.14 103.53,55.62 103.53,59.08 107.19,62.74 111.05,62.74 111.79,63.47 111.79,65.66 v1(110.95,66.5) ; v1(124.49,49.99) 124.49,49.4 125.4,48.49 128.98,48.49 130.99,50.5 130.99,51.87 133.02,53.9 133.02,55.53 135.74,58.24 138.31,58.24 140.41,60.35 147.8,60.35 154.63,60.35 157.02,62.74 162.76,62.74 163.52,61.98 165.61,61.98 166.78,60.81 170.21,60.81 170.94,61.54 172.85,61.54 173.97,62.66 174.82,62.66 176.4,61.08 176.4,58.47 175.97,58.04 175.97,49.02 176.94,48.06 176.94,45.19 175.46,43.71 175.46,39.69 173.66,37.89 173.66,36.8 170.85,33.99 169.31,33.99 162.79,27.47 162.79,22 163.8,20.98 165.04,20.98 166.62,19.4 v1(166.62,17.78)
  L6 w0.762: v1(176.12,14.43) 176.48,14.43 177.27,13.64 179.09,13.64 183.16,17.71 183.16,18.9 v1(184.78,20.52)
  BOTTOM w0.305: 115.75,73.29 115.54,73.29 114.96,73.86 U2506.8 114.35,73.65 114.61,73.38 114.61,73.17
  BOTTOM w0.508: R2718.1 203.43,33.93 203.43,33.9 204.04,33.29 v1(204.04,33.1) ; R2469.2 108.57,56.53 v1(108.79,56.31) ; 114.61,73.17 114.61,72.56 114.63,72.54 114.63,71.78 110.95,68.1 v1(110.95,66.5) ; v1(117.6,77.9) 117.6,76.81 118.36,76.05 118.36,74.7 116.95,73.29 115.75,73.29 ; v1(166.62,17.78) 167.03,18.19 v2(167.44,18.19)
V_3P3_PCIVAUX: length 25.4
  TOP w0.508: R415.1 201.5,61.46 201.5,62.5 Q26.G 201.92,62.92 202.36,62.92 202.97,63.53 203.59,63.53 R416.1 204.76,64.38 205.29,64.9 205.29,66.19 204.17,67.31 v1(194.56,67.31)
  BOTTOM w0.508: v4(193.27,60.86) 193.27,66.01 v1(194.56,67.31)
  vias: v3(192.66,64.34) v4(190.53,39.5) v4(192.25,60.91) v5(189.38,49.48) v5(189.36,43.43) v5(191.06,59.39)
V_5HDD: length 5.3
  TOP w0.635: 81,23.93 SATAP1.1 ; SATAP1.1 81,26.07 ; SATAP1.1 82.07,25 ; 82.07,20 SATAP1.3 81,21.07
VCORE_MEM_TEST_PG: length 10.9
  TOP w0.114: R486.2 99.43,223.82 99.44,223.56 99.44,223.11 98.91,222.58 v3(98.91,221.39) 98.91,218.61 99.01,218.52 99.01,217.28 99.11,217.18 Q41.B 99.08,215.09 99.81,214.36 C631.1
VCORE_MEM_TEST_PG_BACO: length 7.3
  BOTTOM w0.114: Q44.B 99.2,217.16 98.63,216.59 v5(98.63,216) 98.63,215.44 99.46,214.61 100.42,214.61 100.53,214.5 100.68,214.5 101.06,214.12 101.06,213.81 C632.1 101.19,213.68 R492.1
VD1_EN#: length 7.5
  TOP w0.114: KBC1.66 118.72,47.34 118.89,47.52 119.59,47.52 119.89,47.22 v3(119.89,45.72) 119.89,45.31 121.51,43.69 121.51,43.2 R2431.2
VD_IN1: length 249.4
  TOP w0.114: R1222.2 114.03,68.47 C986.1 C987.1 114.02,69.45 115.19,70.61 118.36,70.61 118.75,70.23 118.75,68.79 v1(119.25,68.28) ; KBC1.100 115.25,60.1 114.96,59.82 113.74,59.82 113.67,59.89 113.67,60.87 KBC1.104 113.65,61.71 113.21,62.15 112.64,62.15 v1(112.61,62.18) ; R1223.1 203.48,208.94 v1(202.74,208.2)
  L4 w0.114: v1(119.25,68.28) 119.25,68.38 118.21,69.43 118.21,79.41 113.79,83.82 113.79,87.93 112.9,88.83 112.9,99.82 114.33,101.24 114.33,109.35 116.99,112.01 116.99,116.85 116.58,117.26 116.58,131.99 116.97,132.38 116.97,137.62 118.64,139.29 118.64,143.06 118.38,143.32 118.38,144.27 118.36,144.3 118.36,146.67 119.21,147.53 119.21,157.98 118.64,158.56 118.64,174.02 129.4,184.78 129.41,184.78 138.05,184.78 144.85,191.59 144.85,196.67 v1(145.82,197.64)
  L6 w0.102: v1(145.82,197.64) 147.45,197.64 147.98,197.1 155.45,197.1 156.79,198.45 192.05,198.45 195.73,194.77 199.59,194.77 203.15,198.32 203.15,207.8 v1(202.74,208.2)
  BOTTOM w0.114: v1(112.61,62.18) 112.52,62.27 112.52,63.4 115.49,66.37 115.49,66.85 v2(116.21,67.57) 116.92,68.28 v1(119.25,68.28)
VD_IN2: length 70.3
  TOP w0.114: KBC1.94 119.1,58.54 119.41,58.85 119.41,59.52 119.89,60 119.89,60.78 v1(121.03,61.93) ; C985.1 C984.1 117.26,68.56 R372.2 120.07,66.6 120.68,67.21 v1(121.62,67.21) ; R1224.1 v1(158.45,77.34)
  BOTTOM w0.114: v1(158.45,77.34) 157.02,78.77 154.54,78.77 148.6,72.82 128.5,72.82 125.32,69.65 125.32,66.34 122.45,63.47 122.45,63.02 121.36,61.93 v1(121.03,61.93) 120.52,62.43 120.52,64.8 v2(121.03,65.3) 121.03,66.62 v1(121.62,67.21)
VD_OUT1#: length 5.1
  TOP w0.114: KBC1.110 111.25,62.22 v3(112.31,63.28) 112.63,63.28 v1(113.06,62.85)
  BOTTOM w0.114: D2.2 113.67,62.24 v1(113.06,62.85)
VD_OUT2#: length 5.3
  TOP w0.114: KBC1.112 110.45,60.14 111,59.59 v1(111.23,59.59)
  BOTTOM w0.114: D2.1 110.97,61.77 110.36,61.16 v2(110.36,60.63) 110.36,60.45 v1(111.23,59.59)
VREFC_A0: length 6.7
  TOP w0.114: VRAMA1.J14 102.5,188.8 102.9,188.4 v1(102.9,188.38)
  BOTTOM w0.114: v1(102.9,188.38) 103.63,187.64 C821.2 R689.1 103.63,185.6 103.89,185.34 v2(104.01,185.34) 105.21,185.34 105.89,186.02 R687.1
VREFC_A1: length 6.8
  TOP w0.114: VRAMA2.J14 v6(82.9,220.9)
  BOTTOM w0.114: R688.1 80.64,224.31 v2(80.36,224.03) 80.36,222.33 C822.2 R690.1 81.97,221.83 v6(82.9,220.9)
VREFC_B0: length 6.3
  TOP w0.114: VRAMB1.J14 75.57,220.9 v6(75.6,220.9)
  BOTTOM w0.114: v6(75.6,220.9) 75.86,221.16 v2(76.63,221.16) 78.58,221.16 R646.1 78.89,222.43 C741.1 78.03,222.43 R643.1
VREFC_B1: length 8.2
  TOP w0.114: VRAMB2.J14 v6(45.9,220.9)
  BOTTOM w0.114: v6(45.9,220.9) 43.46,220.9 43.18,221.18 R648.1 C742.1 43.18,224.31 v2(43.54,224.66) 43.54,225.09 R644.1
VREFC_C0: length 8.3
  TOP w0.114: VRAMC1.J14 v6(29.1,204.1)
  BOTTOM w0.114: v6(29.1,204.1) 29.1,204.1 29.1,205.78 28.88,205.99 v2(28.45,205.99) 28.32,205.87 R692.1 27.97,204.98 26.69,203.7 R691.1 25.67,202.82 C823.2
VREFC_C1: length 6.2
  TOP w0.114: VRAMC2.J14 v6(29.1,174.4)
  BOTTOM w0.114: R710.1 26.03,171.4 28.24,171.4 v2(28.29,171.45) C908.2 28.32,172.53 R711.1 28.32,173.62 v6(29.1,174.4)
VREFC_D0: length 8.3
  TOP w0.114: VRAMD1.J14 v6(29.1,167.1)
  BOTTOM w0.114: v6(29.1,167.1) 29.1,168.56 C743.1 R647.1 28.29,170.59 27.94,170.94 26.85,170.94 R645.1 24.91,170.07 v2(24.89,170.05)
VREFC_D1: length 6.8
  TOP w0.114: VRAMD2.J14 v6(61.6,147.1)
  BOTTOM w0.114: R666.1 63.54,144.19 v2(63.72,144.36) 64.34,144.98 64.34,146.02 64.07,146.29 63.6,146.29 R667.1 C818.1 62.38,146.32 v6(61.6,147.1)
VREFD1_A0: length 3.6
  TOP w0.114: VRAMA1.A10 109.87,192.97 TP135.1
VREFD1_A1: length 4.5
  TOP w0.114: TP133.1 84.26,211.21 85.88,212.83 86.06,212.83 86.54,213.31 86.54,214.06 VRAMA2.A10
VREFD1_B0: length 1.5
  TOP w0.114: v6(72.16,227.44) 72,227.28 72,226.93 VRAMB1.A10
  BOTTOM w0.114: TP128.1 72.19,227.47 v6(72.16,227.44)
VREFD1_B1: length 3.5
  TOP w0.114: VRAMB2.A10 49.51,214.09 49.51,211.09 TP126.1
VREFD1_C0: length 2.2
  TOP w0.114: v6(22.52,201.49) 22.52,201.08 VRAMC1.A10
  BOTTOM w0.114: v6(22.52,201.49) 21.94,202.07 TP134.1
VREFD1_C1: length 3.6
  TOP w0.114: TP139.1 37.8,177.68 37.39,178.09 35.99,178.09 VRAMC2.A10
VREFD1_D0: length 1.7
  TOP w0.114: v6(23.53,163.9) 23.5,163.9 VRAMD1.A10
  BOTTOM w0.114: v6(23.53,163.9) 23.17,164.26 TP125.1
VREFD1_D1: length 5.4
  TOP w0.114: VRAMD2.A10 57.8,154.1 57.8,154.51 58.42,155.13 59.53,155.13 60.87,156.46 TP131.1
VREFD2_A0: length 4.2
  TOP w0.114: TP138.1 93.09,189.77 95.34,192.03 96.07,192.03 VRAMA1.U10
VREFD2_A1: length 1.6
  TOP w0.114: v6(86.27,227.44) 86.27,227.13 VRAMA2.U10
  BOTTOM w0.114: v6(86.27,227.44) 85.98,227.72 TP136.1
VREFD2_B0: length 3.5
  TOP w0.114: TP130.1 72.31,212.11 71.85,212.56 71.85,213.95 72,214.1 VRAMB1.U10
VREFD2_B1: length 1.6
  TOP w0.114: v6(49.25,227.4) 49.27,227.39 49.27,227.26 49.5,227.03 VRAMB2.U10
  BOTTOM w0.114: TP129.1 48.94,227.71 v6(49.25,227.4)
VREFD2_C0: length 3.4
  TOP w0.114: VRAMC1.U10 35.91,200.49 36.68,200.49 36.69,200.5 38.96,200.5 TP137.1
VREFD2_C1: length 1.6
  TOP w0.114: VRAMC2.U10 23.09,178 22.71,177.62 v6(22.68,177.62)
  BOTTOM w0.114: v6(22.68,177.62) 22.49,177.42 TP140.1
VREFD2_D0: length 4.3
  TOP w0.114: TP127.1 39.25,165.79 36.94,163.49 35.91,163.49 VRAMD1.U10
VREFD2_D1: length 2
  TOP w0.114: v6(57.81,140.18) 58,140.37 VRAMD2.U10
  BOTTOM w0.114: v6(57.81,140.18) 57.9,140.27 TP132.1
VSYNC: length 17.9
  TOP w0.114: v1(72.39,167.74) 72.39,167.82 72.01,168.2 GPU1.AR24
  L6 w0.102: v1(72.39,167.74) 72.39,167.69 72.87,167.21 v1(72.87,153.37)
  BOTTOM w0.114: v2(73.81,153.14) 73.1,153.14 v1(72.87,153.37) 72.87,154.52 R2740.2
WCKA0_0: length 23.3
  TOP w0.122: GPU1.L42 87.8,190.2 88.26,190.66 91.89,190.66 94.81,193.58 105.98,193.58 106.9,194.5 106.9,195.85 106.9,195.85 106.9,195.99 VRAMA1.D4
WCKA0_1: length 18
  TOP w0.122: GPU1.L39 v6(85.55,190.8) ; VRAMA1.P4 v6(98.1,197.2)
  L6 w0.089: 98.5,195.7 98.5,196.52 v6(98.1,197.2)
  L6 w0.11: 98.5,195.7 98.5,195.47 98.31,195.28 98,194.97 94.5,194.97 90.82,191.29 86.13,191.29 86.11,191.27 v6(85.55,190.8)
WCKA0B_0: length 23.6
  TOP w0.122: VRAMA1.D5 106.65,195.85 106.65,194.6 105.88,193.83 105.12,193.83 104.99,193.96 104.63,193.96 104.5,193.83 104.13,193.83 104.01,193.96 103.64,193.96 103.52,193.83 103.15,193.83 103.03,193.96 102.66,193.96 102.54,193.83 101.03,193.83 100.91,193.96 100.54,193.96 100.42,193.83 100.05,193.83 99.93,193.96 99.56,193.96 99.43,193.83 94.71,193.83 91.78,190.91 87.61,190.91 GPU1.L41
WCKA0B_1: length 18.4
  TOP w0.122: GPU1.L38 84.51,190.2 84.7,190.39 v6(84.7,190.8) ; VRAMA1.P5 98.5,196.24 98.34,196.4 v6(98.1,196.4)
  L6 w0.11: v6(84.7,190.8) 85.11,191.21 85.6,191.21 85.9,191.52 86,191.52 86.01,191.52 90.73,191.52 94.41,195.2 95.2,195.2 95.32,195.32 95.65,195.32 95.77,195.2 96.1,195.2 96.22,195.32 96.55,195.32 96.67,195.2 97,195.2 97.12,195.32 97.45,195.32 97.57,195.2 97.9,195.2 98.27,195.57 98.27,196.22 98.23,196.27 98.23,196.27 v6(98.1,196.4)
WCKA1_0: length 32.6
  TOP w0.122: GPU1.B33 80.66,198.26 80.66,201.89 86.53,207.76 86.53,210.84 88.38,212.69 88.38,223.28 90,224.9 90.55,224.9 VRAMA2.P4
WCKA1_1: length 28.1
  TOP w0.122: v6(91.7,216.1) VRAMA2.D4 ; GPU1.D30 v6(78.4,196.45)
  L6 w0.11: v6(91.7,216.1) 91.29,216.51 90.59,216.51 90.58,216.5 89.9,216.5 87.5,214.1 87.5,209.06 79.33,200.89 79.33,197.38 v6(78.4,196.45)
WCKA1B_0: length 32.9
  TOP w0.122: GPU1.C33 80.91,197.61 80.91,201.79 86.78,207.66 86.78,210.74 88.63,212.59 88.63,213.54 88.75,213.66 88.75,214.03 88.63,214.15 88.63,214.52 88.75,214.64 88.75,215.01 88.63,215.14 88.63,215.5 88.75,215.63 88.75,215.99 88.63,216.12 88.63,220.21 88.75,220.33 88.75,220.7 88.63,220.83 88.63,221.19 88.75,221.32 88.75,221.68 88.63,221.81 88.63,222.17 88.75,222.3 88.75,222.67 88.63,222.79 88.63,223.17 90.11,224.65 90.35,224.65 90.37,224.63 VRAMA2.P5
WCKA1B_1: length 28.5
  TOP w0.122: VRAMA2.D5 v6(90.9,216.1) ; GPU1.E30 77.8,195.21 78.14,195.55 v6(78.4,195.55)
  L6 w0.11: v6(90.9,216.1) 90.73,216.27 90,216.27 89.76,216.03 89.76,215.87 89.53,215.63 89.36,215.63 89.13,215.4 89.13,215.23 88.89,215 88.73,215 88.49,214.76 88.49,214.59 88.26,214.36 88.09,214.36 87.73,214 87.73,212.03 87.85,211.91 87.85,211.58 87.73,211.46 87.73,211.13 87.85,211.01 87.85,210.68 87.73,210.56 87.73,210.23 87.85,210.11 87.85,209.78 87.73,209.66 87.73,208.96 79.56,200.8 79.56,197.28 78.94,196.66 78.94,196.09 v6(78.4,195.55)
WCKB0_0: length 26.7
  TOP w0.122: v6(66.81,216.11) 66.81,216.14 VRAMB1.P4 ; v6(68.8,193.85) 68.95,193.85 GPU1.G21
  L6 w0.11: v6(66.81,216.11) 66.81,216.09 67.2,215.7 67.78,215.7 67.78,215.7 68.81,215.7 69.8,214.71 69.8,203.9 69.39,203.49 69.39,198.39 69.62,198.16 69.62,194.18 69.29,193.85 v6(68.8,193.85)
WCKB0_1: length 29.2
  TOP w0.122: GPU1.A21 69.4,198.96 69.59,199.15 69.59,208.57 69.68,208.67 69.68,212.13 70.35,212.8 70.35,223.83 69.29,224.89 67.89,224.89 VRAMB1.D4
WCKB0B_0: length 26.9
  TOP w0.122: v6(67.57,216.11) 67.58,216.11 VRAMB1.P5 ; GPU1.H21 68.95,193.05 v6(68.8,193.05)
  L6 w0.11: v6(68.8,193.05) 69.22,193.47 69.24,193.47 69.85,194.08 69.85,198.25 69.62,198.49 69.62,203.4 70.03,203.81 70.03,214.8 68.91,215.93 67.76,215.93 v6(67.57,216.11)
