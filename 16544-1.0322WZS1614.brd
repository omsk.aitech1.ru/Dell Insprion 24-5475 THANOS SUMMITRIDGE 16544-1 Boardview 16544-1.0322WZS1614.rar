# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S3_N_EC: length 9.3
  TOP w0.114: KBC1.64 116.45,45.96 117.09,46.61 118.4,46.61 119,46.01 119,45.21 v3(120.02,44.2) 120.07,44.2 120.86,43.41 120.86,42.78 121.14,42.5 R2472.2
SLP_S5_N: length 474
  TOP w0.114: R357.1 183.11,8.34 v1(183.11,4.55) ; R349.2 97.1,47.65 96.75,48.01 94.87,48.01 93.36,46.5 v1(93.36,46.12) ; U21.1 215,131.56 214.78,131.34 v1(213.82,131.34) 211.44,133.72 211.44,142.16 R390.1 212.72,142.75 213.01,143.04 Q25.5 ; v1(156.52,181.49) 156.03,181 CPU1.AP2 ; R335.2 226.31,12.53 v1(226.96,13.18) ; R2416.2 96.39,54.03 95.68,53.31 95.63,53.31 v1(95.1,52.78)
  L3 w0.114: v1(215.26,76.2) 215.26,75.67 215.29,75.64 215.29,74.65 228.63,61.32 228.63,54.91 231.23,52.31 231.23,37.68 223.41,29.85 223.41,27.01 226.95,23.47 226.95,19.74 224.71,17.5 224.71,14.02 225.56,13.18 v1(226.96,13.18) 226.96,8.88 221.64,3.56 184.96,3.56 183.97,4.55 v1(183.11,4.55)
  L4 w0.114: v1(95.1,52.78) 95.86,52.02 95.86,48.62 v1(93.36,46.12) ; v1(213.82,131.34) 213.66,131.19 213.66,119.61 217.79,115.48 217.79,115.46 217.88,115.38 218.59,114.67 218.59,105.82 217.79,105.03 217.79,95.73 218.26,95.27 218.26,95.27 219.94,93.58 219.94,84.05 215.26,79.38 v1(215.26,76.2)
  L6 w0.102: v1(156.52,181.49) 157.04,181.49 157.44,181.08 159.03,181.08 159.49,180.62 159.49,178.12 162.69,174.92 162.69,174.65 163.27,174.07 178.68,174.07 180.52,175.91 188.96,175.91 189.48,175.39 197.91,175.39 204.67,168.63 204.67,167.72 212.47,159.92 216.12,159.92 219.37,156.66 219.76,156.66 226.57,149.85 226.57,148.35 226.1,147.88 225.51,147.88 221.81,147.88 219.02,145.09 219.02,142.77 215.77,139.52 215.77,133.3 v1(213.82,131.34) ; v1(93.36,46.12) 93.7,45.78 93.7,42.37 93.52,42.19 93.52,29.16 94.51,28.17 94.51,21.71 99.11,17.11 99.11,16.1 106.78,8.44 106.78,7.9 107.85,6.83 113.25,6.83 115.28,8.86 122.33,8.86 124.51,6.68 134.9,6.68 137.09,8.87 156.99,8.87 159.75,6.12 181.53,6.12 v1(183.11,4.55)
  BOTTOM w0.114: v1(183.11,4.55) 183.29,4.72 183.29,7.72 182.22,8.79 182.22,10.31 180.34,12.19 R342.1 ; v1(156.52,181.49) 157,181.96 TP101.1
SLP_S5_N_EC: length 6.5
  TOP w0.114: R2416.1 98.55,54.03 99.7,52.88 99.7,52.46 100.22,51.94 v3(100.22,51.82) 100.71,51.33 102.49,51.33 KBC1.21
SM_A_DRAMRST#: length 29.2
  TOP w0.114: v6(179.5,151.49) 179.5,150.5 CPU1.L33 ; R14.2 188.51,127.72 R15.2 188.51,128.98 v3(187.62,129.88) 187.6,129.9 187.6,130.38 v1(187.16,130.83)
  L3 w0.114: v1(187.16,130.83) 187.16,132.12 184.61,134.67 184.61,140.56 183.55,141.62 183.55,147.43 v6(179.5,151.49)
SM_A_DRAMRST#_R: length 40.8
  TOP w0.114: v6(188.01,103.05) 188.04,103.07 188.04,103.66 188.35,103.97 188.35,105.31 188.35,105.32 188.62,105.6 DIMM1.108 ; R15.1 189.4,129.75 C151.1 189.42,129.97 v1(188.5,130.9)
  L3 w0.114: v6(188.01,103.05) 188.01,104.5 192.54,109.03 192.54,111.63 193.11,112.21 193.11,120.14 188.5,124.75 v1(188.5,130.9)
  BOTTOM w0.114: D1.1 188.48,103.05 v6(188.01,103.05) ; v1(188.5,130.9) v2(189.33,130.9)
SM_B_DRAMRST#: length 27
  TOP w0.114: v1(185.76,136.62) 185.76,136.74 185.45,136.43 R8.2 185.45,128.78 R2499.2 R2500.2 ; CPU1.K35 v6(179.5,148.5)
  L6 w0.102: v1(185.76,136.62) 185.22,137.16 185.22,141.12 184.53,141.81 184.53,146.3 182.34,148.5 v6(179.5,148.5)
  BOTTOM w0.114: v2(185.76,135.74) v1(185.76,136.62)
SM_B_DRAMRST#_R: length 47.6
  TOP w0.114: v1(186.32,126.88) 185.45,127.74 C1042.1 185.28,127.89 R2500.1 ; DIMM2.108 188.62,93.4 v6(188.67,93.45)
  L6 w0.102: v6(188.67,93.45) 188.67,93.12 189.12,92.68 190.82,92.68 191.53,93.39 191.53,94.33 192.56,95.36 192.56,97.55 193.12,98.11 193.12,108.99 193.68,109.56 193.68,116.78 186.32,124.15 v1(186.32,126.88)
  BOTTOM w0.114: v1(186.32,126.88) v2(185.5,126.88) ; v6(188.67,93.45) 188.67,93.06 188.06,92.44 D12.1
SMB_CLK_MAIN: length 85.7
  TOP w0.102: CPU1.AU25 152.62,158.38 151.84,158.38 151.62,158.16 151.62,158.08 151.16,157.62 150.48,157.62 150.42,157.68
  TOP w0.114: v1(147.02,113.18) 147.1,113.1 149.42,113.1 149.78,113.46 149.78,113.53 150.38,114.13 DIMM1.253 ; v1(146.84,97.89) 146.94,97.79 148.55,97.79 149.4,98.63 149.99,98.63 150.37,99.02 DIMM2.253 ; 150.42,157.68 147.55,157.68 142.34,152.48 v1(140.82,152.48) 140.25,151.91 RN4.4
  L3 w0.114: v1(140.82,152.48) 141.75,151.55 141.75,125.87 142.36,125.25 142.36,117.51 146.53,113.34 146.86,113.34 v1(147.02,113.18) 147.38,112.82 147.38,112.07 147.09,111.78 147.08,111.78 146.09,110.8 146.09,100.92 146.84,100.18 v1(146.84,97.89)
  BOTTOM w0.114: v1(140.82,152.48) 140.84,152.5 TP99.1
SMB_DATA_MAIN: length 89.1
  TOP w0.102: CPU1.AV25 151.89,158 151.29,157.4 150.41,157.4 150.36,157.45 149.78,157.45
  TOP w0.114: DIMM2.254 150.12,92.69 148.98,93.83 148.98,96.16 148.21,96.93 v6(147.02,96.93) ; 149.78,157.45 147.81,157.45 141.91,151.56 v1(140.82,151.56) 140.52,151.26 RN4.3 ; DIMM1.254 150.12,107.83 149.27,108.68 149.27,110.63 147.63,112.27 v1(146.89,112.27)
  L3 w0.114: v1(140.82,151.56) 141.3,151.08 141.3,125.7 141.94,125.06 141.94,117.21 v1(146.89,112.27) 145.68,111.06 145.68,100.48 146.16,99.99 146.16,97.78 v6(147.02,96.93)
  BOTTOM w0.114: v1(140.82,151.56) 139.95,151.56 TP102.1
SMBUS_ISP: length 66.5
  TOP w0.114: v1(127.2,10.59) 126.64,11.15 126.09,11.15 125.78,10.85 125.78,10.16 126.7,9.25 v3(126.7,9.24) 127.25,8.68 LAUOC1.9 ; v1(110.48,43.11) 110.48,44.06 110.85,44.43 KBC1.50
  L6 w0.102: v1(110.48,43.11) 111.13,43.76 121.13,43.76 124.03,40.87 131.05,40.87 133.4,38.52 133.4,37.47 132.99,37.07 132.99,17.64 132.84,17.48 132.84,14.87 132.51,14.54 132.51,12.83 129.84,10.16 127.64,10.16 v1(127.2,10.59)
SML1_CLK_SIO: length 5.9
  TOP w0.114: PCH1.E8 v6(157,51.4)
  BOTTOM w0.114: v6(157,51.4) 157.43,51.83 157.43,53.71 v2(157.6,53.88) 157.6,53.92 157.66,53.98 RN7.2
SML1_DATA_SIO: length 6.9
  TOP w0.114: PCH1.F8 v6(157,50.6)
  BOTTOM w0.114: RN7.1 v2(158.31,54.94) 158.31,54.68 158.14,54.51 158.14,53.65 157.86,53.37 157.86,51.46 v6(157,50.6)
SPI_CLK: length 13.5
  TOP w0.114: R94.1 v1(131.93,97.05) 131.83,96.95 131.83,95.43 132.37,94.89 U4.6
  L4 w0.114: v1(135.97,98.91) 135.33,98.91 133.48,97.05 v1(131.93,97.05)
  BOTTOM w0.114: RN42.4 136.62,98.32 136.47,98.47 136.4,98.47 v1(135.97,98.91) ; v1(131.93,97.05) 131.93,96.77 v2(132.46,96.24)
SPI_CLK_CPU: length 87.5
  TOP w0.114: v1(132.23,160.68) 132.87,161.32 R2633.1 134.1,161.94 139.19,163.58 139.73,163.83 140.08,163.83 141.02,163.88 141.91,163.88 145.48,167.45 146.34,168.62 146.73,169 150.74,169 150.74,169 CPU1.AW14 ; R94.2 v1(130.78,102.18)
  L4 w0.114: v1(132.23,160.68) 132.06,160.68 129.65,158.27 129.54,157.97 129.54,147.35 128.75,146.56 128.75,135.33 126.62,133.2 126.62,107.01 127.33,104.84 128.73,102.84 129.26,102.31 129.64,102.18 v1(130.78,102.18)
  BOTTOM w0.114: v2(130.84,101.12) 130.78,101.85 v1(130.78,102.18)
SPI_CS0_N: length 12.4
  TOP w0.114: SRCON1.1 139.12,92.35 137.67,93.8 137.67,95.71 v1(138.23,96.27)
  BOTTOM w0.114: v2(139.14,95.12) 138.99,95.28 138.99,95.78 138.51,96.27 v1(138.23,96.27) 138.19,96.3 R2663.2 138.22,97.16 R2664.1 137.9,98.15 137.62,97.87 137.62,97.66 137.31,97.36 136.17,97.36 135.97,97.56 RN42.3
SPI_CS0_N_CPU: length 94.2
  TOP w0.102: 149.94,167.61 152.92,167.61 153.44,167.1 153.44,166.9 CPU1.AT17
  TOP w0.114: 149.94,167.61 149.71,167.61 147.37,166.78 146.61,166.01 144.17,164.97 142.39,163.19 141.22,162.92 140.84,162.74 140.71,162.68 140.03,162.39 139.31,162.18 136.71,161.11 135.58,160.32 135.28,160.3 134.78,160.3 132.72,159.39 v1(132.61,159.28)
  L4 w0.114: v1(132.61,159.28) 131.85,159.28 131.22,158.65 130.4,156.54 130.4,150.8 130.42,150.79 130.42,135.62 127.53,132.74 127.53,110.49 128.63,109.39 128.63,105 131.39,102.24 131.39,102.2 131.7,101.88 132.96,101.12 v1(136.35,99.8)
  BOTTOM w0.114: v1(136.35,99.8) 137.11,99.04 R2664.2 ; v1(132.61,159.28) v2(133.22,159.89)
SPI_CS2_CPU: length 7.2
  TOP w0.114: v1(147.09,167.47) 147.22,167.47 147.62,167.87 150.6,167.87 150.73,168 CPU1.AW15
  BOTTOM w0.114: R83.1 146.22,166.46 146.46,166.22 v2(146.58,166.22) 146.81,166.22 147.09,166.49 v1(147.09,167.47)
SPI_IO2: length 12.8
  TOP w0.114: R2665.1 140.41,100.61 R243.1 ; R243.1 v1(138.71,99.87) ; R243.1 139.88,98.22 138.79,97.13 138.79,95.38 139.27,94.89 SRCON1.3
  BOTTOM w0.114: RN16.4 137.34,99.89 137.52,99.72 138.56,99.72 v1(138.71,99.87) 138.71,99.92 v2(139.47,100.69)
SPI_IO2_CPU: length 89.6
  TOP w0.114: R2665.2 v1(135.66,102.13) ; CPU1.AV16 151.5,166.5 149.33,166.5 147.6,165.91 145.95,164.26 144.48,164.26 142.7,162.48 142.16,162.38 141.22,162.12 140.07,161.62 139.66,161.48 139.63,161.48 139.6,161.47 137.9,159.77 137.9,159.75 137.48,159.33 137.09,159.33 136.56,158.79 135.91,158.79 v1(135.33,158.22)
  L4 w0.114: v1(135.66,102.13) 135.62,102.13 135.13,101.64 133.31,101.64 129.79,105.16 129.79,109.42 129.36,109.85 129.36,120.8 129.62,121.06 129.62,125.58 128.37,126.82 128.37,130.43 128.83,130.89 128.83,131.41 131.36,133.93 131.36,154.85 134.72,158.22 v1(135.33,158.22)
  BOTTOM w0.114: v1(135.66,102.13) v2(135.66,103.17)
SPI_IO3: length 18.7
  TOP w0.114: U4.7 132.16,93.62 130.68,95.1 130.68,97.66 v1(131.09,98.07) R2666.1
  L4 w0.114: v1(135.41,99.62) 133.3,97.51 133.02,97.51 133.01,97.5 132.62,97.5 132.62,97.51 132.13,97.51 132.12,97.52 131.64,97.52 v1(131.09,98.07)
  BOTTOM w0.114: v1(131.09,98.07) 130.53,98.07 v2(130.2,98.4) ; RN16.3 137.99,100.89 137.79,101.1 136.66,101.1 135.41,99.85 v1(135.41,99.62)
SPI_IO3_CPU: length 85.1
  TOP w0.114: R2666.2 130.5,101.73 130.03,102.33 v1(129.62,102.69) ; CPU1.AV15 151.61,168.39 150.81,168.39 150.51,168.09 148.28,168.09 148.2,168.17 147.4,168.17 147.24,168.02 146.61,168.02 144.9,166.31 144.9,166.21 142.24,163.55 141.1,163.28 140.56,162.99 139.98,162.76 139.01,162.53 136.22,161.42 135.46,160.66 133.58,160.66 v3(133.17,160.25) 132.82,159.89 v1(132.14,159.89)
  L4 w0.114: v1(129.62,102.69) 129.38,103.02 127.7,105.08 127.11,106.95 127.11,132.93 129.62,135.43 129.62,146.83 129.96,147.17 129.96,150.91 129.97,150.93 129.97,156.82 130.66,158.38 130.86,158.88 131.87,159.89 v1(132.14,159.89)
SPI_MISO: length 11.1
  TOP w0.114: SRCON1.2 139.75,93.62 138.98,93.94 v1(138.33,94.34)
  BOTTOM w0.114: RN43.4 134.41,97.58 134.24,97.41 133.48,97.41 133.25,97.18 133.25,95.83 133.52,95.57 R95.1 133.72,94.53 v2(136.14,94.53) 138.13,94.53 v1(138.33,94.34)
SPI_MISO_CPU: length 95.5
  TOP w0.102: CPU1.AU14 152.61,169.39 152.18,169.39 152.17,169.39 151.84,169.39 151.84,169.39 151.19,169.39 151.18,169.39 150.83,169.39 150.65,169.22
  TOP w0.114: v1(132.23,161.44) 134.26,162.56 134.37,162.61 139.09,163.98 139.62,164.16 139.73,164.19 139.93,164.19 140.89,164.26 142.04,164.82 146.56,169.34 147.72,169.34 147.83,169.23 150.05,169.23 150.06,169.21 150.65,169.21 150.65,169.22
  L4 w0.114: v1(131.22,96.34) 130.29,97.67 126.91,103.68 126.19,106.14 126.19,133.43 128.02,135.25 128.02,146.99 128.57,147.55 128.57,156.54 129.29,158.5 v1(132.23,161.44)
  BOTTOM w0.114: R95.2 131.22,96.15 v1(131.22,96.34) 130.45,96.34 v2(130.25,96.14)
SPI_MOSI: length 6.3
  TOP w0.114: R96.1 v1(132.82,97.97) 132.82,96.42 U4.5
  BOTTOM w0.114: RN43.3 132.83,97.98 v1(132.82,97.97) 132.69,97.97 132.38,98.27 v2(132.38,98.78)
SPI_SO_CPU_R: length 86
  TOP w0.102: 149.83,167.26 149.98,167.41 152.59,167.41 CPU1.AU16
  TOP w0.114: v1(132.69,158.52) 133.53,158.52 134.95,159.94 135.64,159.94 135.77,159.99 137.08,160.86 139.35,161.77 140.21,162.08 141.11,162.45 142.54,162.84 144.32,164.62 145.75,164.62 147.43,166.31 149.83,167.26 ; v1(131.85,102.39) 133.06,101.18 R96.2
  L4 w0.114: v1(132.69,158.52) 132.69,158.47 130.94,156.72 130.94,135.25 127.95,132.27 127.95,126.65 128.35,126.25 128.35,118.39 128.93,117.81 128.93,109.69 129.05,109.57 129.05,105.19 v1(131.85,102.39)
  BOTTOM w0.114: v2(132.59,101.75) 132.46,101.75 131.85,102.36 v1(131.85,102.39)
SPKR: length 244.8
  TOP w0.114: CPU1.AW23 150.47,160 v6(150.34,159.87)
  L3 w0.114: v1(207.48,49.73) 208.91,51.17 208.91,53.64 209.6,54.33 209.6,63.27 205.31,67.56 v1(205.31,73.79)
  L4 w0.114: v1(192.89,75.93) 194.97,75.93 194.98,75.92 202.27,75.92 202.61,75.58 203.51,75.58 v1(205.31,73.79)
  L6 w0.102: v1(192.89,75.93) 192.89,76.93 192.35,77.46 192.28,77.46 182.25,87.5 160.91,87.5 158.55,85.14 158.55,82.42 v1(158.5,82.37) 157.2,83.67 152.68,83.67 147.83,88.52 147.83,92.33 144.58,95.58 144.58,111.96 143.15,113.39 143.15,127.12 139.65,130.63 139.65,144.03 138.53,145.15 138.53,152.68 140.51,154.66 141.59,154.66 143.05,156.12 143.05,156.79 145.92,159.66 149.4,159.66 149.61,159.87 v6(150.34,159.87)
  BOTTOM w0.114: R271.2 v5(206.63,49.15) 207.21,49.73 v1(207.48,49.73) ; R2461.1 107.86,60.93 109.58,60.93 115.04,66.4 115.04,67.34 116.54,68.83 122.94,68.83 124.33,70.23 125.09,70.23 128.18,73.32 148.61,73.32 154.4,79.11 156.55,79.11 158.34,80.9 158.34,82.22 v1(158.5,82.37)
SPKR_DET: length 205
  TOP w0.114: R873.1 222.57,8.01 v1(221.74,7.19) ; v1(109.29,47.4) 109.29,47.38 110.05,46.62 KBC1.48
  L3 w0.114: v1(168.91,12.32) 169.42,12.83 171.45,12.83 172.85,11.43 172.85,6.25 174.32,4.78 180.32,4.78 181.46,5.91 182.67,5.91 182.8,6.05 184.66,6.05 185.67,5.03 220.49,5.03 221.74,6.28 v1(221.74,7.19)
  L6 w0.102: v1(168.91,12.32) 168.91,15.29 167.26,16.94 167.26,19.94 165.61,21.59 164.47,21.59 163.4,22.66 163.4,27.22 169.56,33.38 171.11,33.38 174.27,36.54 174.27,37.08 176.12,38.93 176.12,43.48 177.55,44.9 177.55,48.31 176.58,49.28 176.58,56.1 177.44,56.96 177.44,60.9 175.08,63.27 173.71,63.27 172.6,62.15 170.69,62.15 170.13,61.59 167.51,61.59 166.52,62.59 163.77,62.59 163.01,63.35 156.77,63.35 154.38,60.96 140.16,60.96 138.05,58.85 135.48,58.85 130.99,54.36 130.99,52.75 128.81,50.57 122.78,50.57 122.05,49.83 110.44,49.83 109.91,49.3 109.32,49.3 109.02,49 109.02,48.46 109.27,48.21 109.27,47.42 v1(109.29,47.4)
  BOTTOM w0.114: v2(169.49,12.9) v1(168.91,12.32)
SPKR_DET_C: length 7.3
  TOP w0.114: SPK1.1 219.75,8.35 220.93,9.53 R2604.1 221.68,9.12 R873.2 221.68,8.14 221.01,7.47 v1(221.01,6.73)
  BOTTOM w0.114: v1(221.01,6.73) 220.98,6.7 v5(220.3,6.7)
SSD_DEVSLP_N: length 113.5
  TOP w0.114: v1(182.85,74.12) 182.85,73.86 181.74,72.75 181.74,71.88 180.44,70.59 179.3,70.59 174.87,66.16 v3(174.87,64.76) 174.87,62.92 175.22,62.57 175.22,61.51 v1(175.13,61.42) ; Q34.D 106.64,88.21 R436.2 107.28,87.01 v1(108.1,86.18) ; PCH1.C23 v6(168.2,53.8)
  L6 w0.102: v1(108.1,86.18) 110.06,84.23 115.92,84.23 116.28,83.87 123.34,83.87 124.94,82.27 124.94,81.97 131.78,75.13 132.69,75.13 161.06,75.13 161.62,75.69 171.36,75.69 171.78,75.27 181.7,75.27 v1(182.85,74.12) ; v6(168.2,53.8) 169.24,54.84 169.24,56.97 172.19,59.92 173.53,59.92 175.03,61.42 v1(175.13,61.42)
SSD_PM_PCIE_WAKE#: length 4.8
  TOP w0.114: SSDC1.54 110.5,93.01 110.74,92.77 v3(110.74,90.93) 111.24,90.44 R439.1
SSON#: length 4.9
  TOP w0.114: U29.5 97.09,152.91 96.5,152.32 v3(96.5,151.02) 96.39,150.92 R562.1 R560.2
STRAP_LPC_CLK_CPU_P0: length 18.2
  TOP w0.102: 150.51,163.38 152.62,163.38 CPU1.AU20
  TOP w0.114: 150.51,163.38 147.83,163.38 146.12,161.67 144.96,161.67 141.9,158.61 R144.2 141.03,157.15 C2528.1 139.97,155.91 TP95.1 139.51,155.61 R93.2
STRAP_LPC_CLK_CPU_P1: length 21.8
  TOP w0.102: 149.74,163.61 152.61,163.61 CPU1.AU19
  TOP w0.114: 149.74,163.61 147.5,163.61 145.94,162.05 144.83,162.05 142.01,159.23 139.66,159.23 C2527.1 138.42,157.49 138.56,157.35 R121.1 136.97,156.91 TP96.1 135.95,155.89 R92.2
SUS_CLK_CPU: length 57.1
  TOP w0.114: v1(144.32,153.21) 144.32,153.05 142.12,150.85 141.91,150.85 v3(141.76,150.7) 141.68,150.62 R128.1 141.87,149.44 142.64,148.67 142.64,142.67 140.54,140.56 135.23,140.56 134.56,139.89 129.78,139.89 128.32,138.43 128.32,137.8 R2760.2 ; CPU1.AP8 v6(155.5,174.5)
  L4 w0.114: v6(155.5,174.5) 154.92,174.5 151.03,170.61 149.14,170.61 148.36,169.83 148.36,165 147.83,164.47 147.83,160.07 146.05,158.29 146.05,157.61 144.61,156.18 144.61,153.5 v1(144.32,153.21)
SUS_CLK_CPU_EN: length 13.6
  TOP w0.114: Q84.G 123.8,133.32 124.84,132.28 124.84,132.08 Q83.D 126.91,131.44 C2514.1 127.51,131.15 127.54,131.12 R2759.2 128.4,130.94 v3(130.18,130.94) 130.94,131.7 130.94,134.11 130.3,134.75 Q85.G
SUS_CLK_CPU_PWR: length 5
  TOP w0.114: R2760.1 127.44,136.54 v3(127.49,136.5) Q85.S 126.91,134.17 Q84.S
SUSB_DET_EC: length 194.2
  TOP w0.114: v1(169.98,70.69) 170.18,70.89 172.44,70.89 180.62,79.07 209.93,79.07 211.05,80.19 212.9,80.19 216.03,77.06 v1(216.03,75.31) ; v1(104.57,50.24) 104.55,50.24 103.65,49.34 KBC1.26 ; SUSBC1.2 224.84,24.5 R2492.1 224.54,24.8 v3(224.54,25.96) v1(224.54,26.92)
  L3 w0.114: v1(224.54,26.92) 224.13,27.33 224.13,29.54 226.99,32.4 226.99,32.41 231.95,37.38 231.95,52.61 229.35,55.21 229.35,61.63 216.03,74.96 v1(216.03,75.31)
  L6 w0.102: v1(104.57,50.24) 105.26,50.93 109.21,50.93 110.61,52.32 111.38,52.32 111.72,52.32 113.06,53.66 113.06,54 114.5,55.45 116.71,55.45 120.32,59.05 121.14,59.05 121.14,59.05 122.18,59.05 125.25,62.12 125.25,62.81 126.95,64.52 131.75,64.52 136.35,69.11 137.44,69.11 147.34,69.11 148.07,69.85 163.25,69.85 163.71,70.31 169.6,70.31 v1(169.98,70.69)
SUSCLK: length 5
  TOP w0.114: R2536.1 121.76,51.74 v3(121.71,51.69) 121.71,51.69 120.65,51.69 120.35,51.39 119.8,51.39 119.75,51.44 119.31,51.44 119.01,51.75 KBC1.77
SUSCLK_NGFF: length 6.3
  TOP w0.114: R2477.2 195.4,55.34 195.1,55.04 193.85,55.04 v3(193.68,55.22) 192.68,55.22 191.46,54 WLAN1.50
SVCLK: length 70.9
  TOP w0.114: PR237.2 107.4,147.83 106.7,148.53 106.7,149.02 106.98,149.31 v1(106.98,149.43) 106.65,149.43 106.48,149.25 PR230.2 106.16,150.02 R2641.1 ; GPU1.AM23 70.45,170.6 70.08,170.23 v6(70.08,170.23)
  L6 w0.102: v1(72.06,145.92) 72.03,145.95 70.71,145.95 70.29,146.38 70.28,146.38 69.82,146.83 69.82,147.34 70.1,147.62 70.1,153.7 69.37,154.43 69.37,158.29 70.18,159.11 70.18,161.21 70.7,161.74 70.7,169.28 70.08,169.9 v6(70.08,170.23)
  BOTTOM w0.114: v1(72.06,145.92) 72.69,146.56 77.98,146.56 78.77,145.77 82.5,145.77 83.21,146.48 87.88,146.48 87.88,146.48 90.9,146.48 90.9,146.48 102.57,146.48 103.45,145.59 104.47,145.59 105.74,146.86 v2(105.74,146.89) 105.74,148.18 v1(106.98,149.43)
SVDATA: length 71.7
  TOP w0.114: R2640.1 105.95,147.02 PR228.2 106.13,145.9 v1(106.88,145.9) 106.98,145.8 PR238.2 ; GPU1.AP23 70.45,169 70.09,168.64 v6(70.09,168.62)
  L6 w0.102: v6(70.09,168.62) 69.89,168.62 69.21,167.94 69.21,163.91 68.48,163.19 68.48,159.59 66.83,157.93 66.83,150.13 67.31,149.65 67.31,144.22 67.64,143.89 70.36,143.89 v1(70.94,144.48)
  BOTTOM w0.114: v1(70.94,144.48) 71.07,144.35 72.42,144.35 73.33,145.26 77.44,145.26 78.24,144.46 83.07,144.46 83.62,145.01 v2(97.25,145.01) 102.16,145.01 102.9,144.27 105.03,144.27 106.65,145.9 v1(106.88,145.9)
SVID_CLK: length 79.6
  TOP w0.114: v1(201.54,164.98) 201.14,165.38 197.46,165.38 197.31,165.23 196.9,165.23 196.75,165.38 196.44,165.38 R27.2
  BOTTOM w0.114: PR85.1 224.61,217.92 225.29,217.92 226.47,216.74 226.47,214.4 222.05,209.98 220.34,209.98 217.96,207.59 216.81,207.59 214.92,205.7 213.28,205.7 209.16,201.59 209.16,198.08 208.17,197.09 207.18,197.09 203.03,192.95 201.76,192.95 199.96,191.15 199.96,186.65 201.64,184.97 201.64,183.17 202.04,182.77 v2(202.04,178.82) 202.04,178.45 201.24,177.65 201.24,170.21 202,169.45 202,165.43 v1(201.54,164.98)
SVID_CLK_CPU: length 13.3
  TOP w0.114: CPU1.D17 v6(185.5,166.5) ; R27.1 194.94,164.77 193.65,164.77 192.43,165.99 192.43,166.47 v1(192.2,166.7)
  L6 w0.102: v1(192.2,166.7) 192.14,166.76 191.27,166.76 190.99,167.05 186.25,167.05 185.7,166.5 v6(185.5,166.5)
  BOTTOM w0.114: v1(192.2,166.7) 192.88,167.38 v2(192.88,167.59)
SVID_DATA: length 77.2
  TOP w0.114: v1(201.5,166.14) 201.35,166.14 201.02,165.81 198.2,165.81 197.8,166.21 R28.2
  BOTTOM w0.114: v1(201.5,166.14) 201.5,166.19 201.6,166.29 201.6,169.34 200.89,170.05 200.89,179.96 200.91,179.98 v2(200.91,180.39) 200.91,185.21 199.62,186.51 199.62,191.29 201.62,193.29 202.87,193.29 207.01,197.43 208.03,197.43 208.82,198.22 208.82,201.73 213.13,206.04 214.27,206.04 217.88,209.65 218.85,209.65 219.66,210.46 222.02,210.46 226.11,214.55 226.11,216.61 225.15,217.58 222.94,217.58 222.42,218.1 PR87.1
SVID_DATA_CPU: length 11.7
  TOP w0.114: R28.1 194.87,165.79 193.73,165.79 193.12,166.4 v1(193.12,166.65) ; CPU1.C17 v6(186.5,166.5)
  L6 w0.102: v1(193.12,166.65) 192.43,165.96 186.99,165.96 186.5,166.46 v6(186.5,166.5)
  BOTTOM w0.114: v2(193.52,165.77) 193.12,166.17 v1(193.12,166.65)
SVID_PWRGD: length 138
  TOP w0.114: HDT1.10 217.3,150.98 215.44,149.12 R19.2 215.2,149.72 214.93,149.99 v1(214.5,149.99) ; CPU1.E16 v6(185.5,167.5)
  L6 w0.102: v1(224.74,214.91) 224.74,212.39 219.2,206.86 219.19,206.86 218.79,206.45 217.87,206.45 216.88,205.46 213.84,205.46 213.39,205 212.14,203.76 210.78,203.76 207.37,200.35 207.37,199.31 206.17,198.12 206.17,196.05 205.28,195.16 205.28,191.6 206.45,190.43 206.45,187.75 205.26,186.55 205.26,179.12 206.1,178.28 206.1,168.33 207.87,166.55 207.88,166.55 208.72,165.71 208.74,165.71 209.12,165.33 215.93,165.33 v1(217.17,164.08) ; v1(214.5,149.99) 213.61,149.99 211.66,151.94 211.66,152.74 209.97,154.43 208.67,154.43 205.73,157.38 204.76,157.38 199.09,163.05 199.09,165.83 197.83,167.08 197.83,167.67 197.83,167.67 197.83,168.09 197.15,168.77 197.15,169.21 196.55,169.82 191.08,169.82 190.53,169.27 187.96,169.27 186.66,167.97 186.06,167.97 185.58,167.5 v6(185.5,167.5)
  BOTTOM w0.114: v1(224.74,214.91) 222.83,216.81 PR96.1 ; v1(214.5,149.99) 214.57,149.99 v5(215.64,151.05) 215.65,151.06 215.7,151.06 217.04,152.4 217.04,163.96 v1(217.17,164.08)
SVID_SVT: length 90.6
  TOP w0.114: PR91.1 222.35,217.96 223.82,216.48 224.16,216.48 v1(224.71,217.04) ; CPU1.A17 189.49,166 190.86,167.37 190.86,167.6 192.12,168.86 v1(192.18,168.86) 193.42,170.1 R22.2
  BOTTOM w0.114: v1(224.71,217.04) 225.45,216.31 225.45,214.83 221.74,211.12 219.3,211.12 218.49,210.31 216.48,210.31 207.9,201.73 207.9,199.24 202.93,194.27 201.68,194.27 198.97,191.56 198.97,191.02 198.97,186.24 200.23,184.98 v2(200.23,173.81) 200.23,169.77 200.94,169.06 200.94,166.55 199.42,165.02 193.19,165.02 191.69,166.52 191.69,167.13 192.18,167.61 v1(192.18,168.86)
SW_CMOS: length 1.8
  TOP w0.114: CPU1.AT18 v6(153.5,164.5)
  BOTTOM w0.114: v6(153.5,164.5) 153.87,164.87 TP100.1
SW_ON_N_SIO: length 5.9
  TOP w0.114: KBC1.117 108.45,61.81 v3(109.42,62.79) 109.65,62.79 110.29,63.43 111.14,64.27 R2454.1
SYS_FAN_TACH1_1: length 3.4
  TOP w0.114: R257.1 R254.2 13.88,174.73 FANC1.3
SYS_FAN_TACH1_2: length 2.5
  TOP w0.114: R257.2 16.19,176.15 R260.2 R258.1
SYS_RESET_L: length 13.6
  TOP w0.114: v6(157.51,179.4) 157.67,179.4 CPU1.AM4
  L4 w0.114: v1(150.06,180.92) 150.19,180.92 150.26,180.85 151.49,180.85 151.97,181.33 152.76,181.33 153.06,181.64 153.06,181.66 153.34,181.94 155.24,181.94 155.85,181.33 155.98,181.33 156.26,181.05 156.7,181.05 156.73,181.08 157.57,181.08 157.95,180.7 157.95,179.92 157.51,179.48 v6(157.51,179.4)
  BOTTOM w0.114: v1(150.06,180.92) 149.99,181 149.99,181.48 v2(149.73,181.74) 149.35,181.74 148.76,181.15 R2632.1
SYSTEM_FAN_PWM1_1: length 6.7
  TOP w0.114: FANC1.4 12.7,171.49 D5.A 12.7,168.4 11.87,167.58 R253.2 R251.2
T_CRIT#: length 6.6
  BOTTOM w0.114: U2.4 111.35,46.16 v2(110.24,46.16) R230.1 108.94,46.28 108.94,46.92 108.67,47.18 108.67,48.3 109.63,49.25 R233.2
TEST0_APU: length 7.4
  TOP w0.114: CPU1.AM6 v6(157.5,176.5)
  BOTTOM w0.114: R58.1 152.27,176.02 155.04,176.02 155.31,175.74 v2(155.31,175.73) 156.32,175.73 157.08,176.5 v6(157.5,176.5)
TEST1_APU: length 8.8
  TOP w0.114: v6(158.49,176.52) 158.49,176.5 CPU1.AM7
  BOTTOM w0.114: R59.1 152.08,173.99 154.2,173.99 155.17,174.96 156.39,174.96 v2(156.72,175.29) 156.79,175.36 156.79,175.51 157.37,176.09 157.67,176.09 158.11,176.52 v6(158.49,176.52)
TEST2_APU: length 6.3
  TOP w0.114: v6(150.77,181.46) 150.87,181.46 151.33,181.91 151.67,181.91 152.46,181.13 152.46,180.96 152.92,180.5 153.5,180.5 CPU1.AT3
  BOTTOM w0.114: R57.1 152.22,180.73 v2(151.26,180.73) 151.26,180.97 v6(150.77,181.46)
TEST18_APU: length 51.8
  TOP w0.114: CPU1.G16 v6(182.48,167.52) ; v1(209.45,155.14) 209.89,154.7 211.49,154.7 212.34,155.55 212.34,157.06 213.2,157.91 215.04,157.91 215.56,157.39 RN2413.4 216.6,157.39 216.66,157.33 HDT1.20
  L6 w0.102: v1(209.45,155.14) 208.97,155.14 206.02,158.09 205.05,158.09 199.8,163.34 199.8,166.12 198.54,167.38 198.54,168.39 197.87,169.06 197.87,170.24 197.44,170.67 197.01,171.09 190.78,171.09 189.43,169.75 187.83,169.75 187.25,169.16 183.68,169.16 183.08,168.57 183.08,168.4 182.48,167.79 v6(182.48,167.52)
  BOTTOM w0.114: v1(209.45,155.14) 209.42,155.17 v2(208.56,155.17)
TEST19_APU: length 49.5
  TOP w0.114: v1(213.28,155.65) 213.39,155.75 213.41,155.75 213.77,156.12 214.93,156.12 215.56,156.74 RN2413.3 216.24,156.74 216.92,156.06 HDT1.18 ; CPU1.H16 182,167.01 v6(181.49,167.53)
  L3 w0.114: v1(213.28,155.65) 213.67,155.26 213.67,153.81 213.28,153.42 208.63,153.42 208.08,153.96 208.08,154.43 201.73,160.79 201.73,161.47 198.64,164.55 196.42,164.55 194.87,166.11 194.87,166.46 194.87,166.77 193.96,167.68 190.89,167.68 190.62,167.95 189.34,167.95 189.3,167.91 184.7,167.91 184.68,167.93 184.34,167.93 184.32,167.91 182.67,167.91 182.65,167.94 182.31,167.94 181.9,167.53 v6(181.49,167.53)
  BOTTOM w0.114: v1(213.28,155.65) 213.56,155.65 v2(214,156.08)
TEST46: length 1.4
  TOP w0.114: CPU1.AL4 158.55,179.44 v6(158.55,179.45)
  BOTTOM w0.114: v6(158.55,179.45) 158.06,179.93 TP141.1
TESTEN: length 64.3
  TOP w0.114: v6(78.03,177.6) 78.03,177.38 77.8,177.15 GPU1.AE30 ; TP111.1 97.84,203.3 v1(97.66,203.48) 97.26,203.48 96.89,203.85 R523.1
  L6 w0.102: v1(97.66,203.48) 97.71,203.53 98.62,203.53 99.59,203.53 99.61,203.5 102.48,203.5 105.91,200.07 105.91,199.57 106.4,199.07 106.4,197.08 106.83,196.65 107.39,196.65 108.74,195.3 108.74,192.68 108.94,192.48 108.94,191.25 108.36,190.67 108.36,188.99 107.76,188.39 107.76,187.84 104.67,184.75 102.95,184.75 99.53,181.33 90.91,181.33 90.36,180.78 86.42,180.78 86.41,180.79 84.48,180.79 83.92,181.36 82.35,181.36 82.02,181.69 79.78,181.69 78.64,180.55 78.64,178.21 v6(78.03,177.6)
  BOTTOM w0.114: v1(97.66,203.48) 97.26,203.48 96.95,203.78 96.95,203.86 R519.2
THERM_SYS_SHDN#: length 4.8
  BOTTOM w0.114: v2(106.94,46.09) 108.09,46.09 R230.2 108.17,46.77 108.03,46.91 108.03,49.32 Q14.S
THERMTRIP_L_CPU: length 229.5
  TOP w0.114: CPU1.A19 193.54,164 193.55,164 R21.2 195.48,163.76 195.48,163.73 196.09,163.12 198.5,163.12 198.62,163.24 v1(198.63,163.24) ; v1(210.19,74.68) 210.11,74.6 206.1,74.6 206.04,74.55 203.61,74.55 201.78,76.38 199.75,76.38 199.73,76.39 184.42,76.39 181.08,73.05 181.08,72.26 180.06,71.25 178.69,71.25 174.22,66.78 174.22,62.63 174.57,62.28 v1(174.57,61.98)
  L4 w0.114: v1(210.19,80.77) 210.19,80.8 212.93,83.54 212.93,97.62 215.14,99.83 215.14,111.76 215.52,112.14 215.52,115.34 211.35,119.51 211.35,127.81 211.12,128.04 211.12,131.16 212.95,132.99 214.22,132.99 216.74,135.52 216.74,137.93 219.81,140.99 219.81,142.38 219.34,142.84 216.52,142.84 211.89,147.47 211.89,147.88 204.01,155.75 204.01,157.94 198.71,163.24 v1(198.63,163.24)
  L6 w0.102: v1(174.57,61.98) 173.23,60.63 171.89,60.63 169.63,58.37 167.21,58.37 164.52,61.06 163.14,61.06 162.38,61.82 157.4,61.82 155.01,59.44 154.25,59.44 147.42,59.44 140.79,59.44 138.68,57.33 137.95,57.33 136.12,55.5 134.75,55.5 133.99,54.74 133.99,53.47 133.22,52.7 v1(132.84,52.7)
  BOTTOM w0.114: v1(132.84,52.7) 132.84,50.83 131.52,49.51 131.52,46.3 129.03,43.81 R2708.1 128.33,43.12 127.89,42.67 125.86,42.67 124.78,41.59 Q71.S ; v1(210.19,80.77) v5(210.19,78.11) v1(210.19,74.68)
THERMTRIP_L_CPU_EC: length 20.5
  TOP w0.114: KBC1.83 118.83,54.14 119.23,53.75 120.52,53.75 121.11,53.16 121.11,53.15 121.51,52.74 123.05,52.74 v1(123.19,52.6)
  BOTTOM w0.114: v1(123.19,52.6) 123.19,52.58 123.14,52.53 123.14,49.97 123.77,49.33 124.14,49.33 124.42,49.06 124.42,47.68 123.9,47.17 v5(123.9,46.84) 125.4,45.34 126.94,45.34 R2706.1 R2708.2 127.13,43.5 Q71.D
TOUCH_DET: length 179.6
  TOP w0.114: TOUCH1.1 188,6.14 188.21,6.35 188.98,6.35 v1(189.18,6.15) ; v1(98.45,63.2) 98.45,62.81 99.06,62.2 99.69,62.2 100.27,61.63 R430.2 101.08,62.41 103.83,62.41 104.12,62.12 105.24,62.12 105.64,61.72 105.64,61.26 105.65,61.26 KBC1.124
  L4 w0.114: v1(98.45,63.2) 96.65,61.39 96.65,58.62 94.77,56.74 94.77,55.8 92.88,53.91 92.88,19.26 93.46,18.68 93.46,13.75 92.56,12.84 92.56,10.1 97.74,4.91 108.99,4.91 109.88,4.03 114.58,4.03 114.66,4.1 123.63,4.1 124.37,4.84 142.76,4.84 144.25,6.32 144.25,8.36 146.53,10.64 150.61,10.64 151.62,11.66 154.94,11.66 160.58,17.3 168.25,17.3 172.59,12.95 176.28,12.95 180.7,8.53 182.3,8.53 183.44,7.39 183.44,7.04 183.77,6.71 184.23,6.71 185.17,5.76 188.79,5.76 v1(189.18,6.15)
  BOTTOM w0.114: v2(188.26,5.82) 188.85,5.82 v1(189.18,6.15)
TP_ANALOGIO: length 8.2
  TOP w0.114: R2534.1 92.72,160.11 TP65.1 91.92,160.91 91.66,160.91 91.06,161.51 91.06,161.77 88.92,163.91 88.9,163.91 88.66,164.15 88.66,164.17 87.83,165 GPU1.AW42
TP_BBR#: length 1.8
  TOP w0.114: CPU1.AU23 152.58,160.42 v6(152.58,160.5)
  BOTTOM w0.114: TP113.1 153.29,161.21 v6(152.58,160.5)
TP_CHAR_STATUS_REAR: length 3.4
  TOP w0.114: U12.9 96.35,42.79 95.91,43.23 95.91,44.15 v1(95.64,44.42)
  BOTTOM w0.114: v1(95.64,44.42) 96.04,44.81 TP34.1
TP_CHAR_STATUS_SIDE: length 3.9
  TOP w0.114: TP33.1 226.49,14.7 226.19,14.4 225.8,14.4 225.56,14.64 225.21,14.64 224.85,15 U10.9
TP_CLINK_CLK_LAN: length 4
  TOP w0.114: TP72.1 193.52,52.68 192.61,52.68 192,52.07 191.26,52.07 191.19,52 WLAN1.42
TP_CLINK_DATA_LAN: length 2.7
  TOP w0.114: TP73.1 192.45,51.71 191.41,51.71 191.2,51.5 WLAN1.40
TP_CLINK_RST_LAN_N: length 4.7
  TOP w0.114: WLAN1.38 191.21,51 191.57,51.36 193.01,51.36 193.53,51.88 TP74.1
TP_DBGDATA_0: length 67.5
  TOP w0.114: v1(27.3,138.79) TP47.1 26.53,137.06 R551.2 ; GPU1.AV18 65.8,165.53 65.21,164.94 v6(65.21,164.58)
  L6 w0.102: v1(27.3,138.79) 34.01,145.49 44.12,145.49 47.35,142.27 50.04,142.27 50.05,142.27 50.38,142.27 50.39,142.27 51.46,142.27 51.83,141.89 52.63,141.09 55.02,141.09 58.23,144.31 59.37,144.31 59.38,144.29 60.17,144.29 60.63,144.75 61.83,144.75 62.76,145.68 62.76,149.19 63.35,149.78 63.35,157.61 64.16,158.42 64.16,163.7 65.04,164.58 v6(65.21,164.58)
  BOTTOM w0.114: R553.1 26.76,138.24 v1(27.3,138.79)
TP_DBGDATA_1: length 64.2
  TOP w0.114: R549.1 27.95,137.86 TP48.1 27.86,138.07 v1(28.6,138.81) ; GPU1.AW18 65.8,164.58 65.2,163.98 v6(65.2,163.56)
  L6 w0.102: v6(65.2,163.56) 64.47,162.82 64.47,158.37 63.78,157.68 63.78,149.35 63.04,148.61 63.04,144.5 62.21,143.66 62.21,143.33 61.97,143.09 61.37,143.09 60.17,141.89 59.38,141.89 58.54,141.05 55.26,141.05 55.1,140.89 52.55,140.89 51.98,141.46 47.58,141.46 46.24,142.8 32.59,142.8 v1(28.6,138.81)
  BOTTOM w0.114: v1(28.6,138.81) 27.95,138.16 R550.1
TP_DBGDATA_2: length 66.7
  TOP w0.114: GPU1.AT19 66.85,167.4 v6(66.4,166.95) ; R547.1 29.1,137.88 TP49.1 29.2,138.06 v1(29.87,138.73)
  L6 w0.102: v1(29.87,138.73) 33.5,142.37 45.9,142.37 47.28,140.98 49.52,140.98 49.91,140.59 51.54,140.59 51.83,140.29 52.17,140.29 52.26,140.39 54.89,140.39 55.32,140.82 59.44,140.82 60.86,142.24 62.21,142.24 63.36,143.4 63.36,148.06 64.24,148.93 64.24,157.63 64.67,158.06 64.67,160.78 65.73,161.85 65.73,166.26 66.4,166.93 v6(66.4,166.95)
  BOTTOM w0.114: v1(29.87,138.73) 29.09,137.96 R548.1
TP_DBGDATA_3: length 82.8
  TOP w0.114: R545.1 30.39,137.86 TP50.1 30.49,138.14 v1(31.09,138.73) ; v1(16.71,131.29) 16.71,131.36 R2725.1 ; GPU1.AV19 66.85,165.8 v6(66.4,165.35)
  L3 w0.114: v1(16.71,131.29) 16.71,132.58 19.08,134.94 27.3,134.94 v1(31.09,138.73)
  L6 w0.102: v1(31.09,138.73) 32.72,140.36 49.53,140.36 49.8,140.09 57.14,140.09 57.64,140.59 59.54,140.59 59.83,140.29 60.17,140.29 60.31,140.44 61.59,140.44 61.6,140.42 62.06,140.42 63.58,141.94 63.58,143.68 63.66,143.76 63.66,147.78 64.72,148.83 64.72,157.68 64.95,157.91 64.95,160.22 65.94,161.22 65.94,164.89 v6(66.4,165.35)
  BOTTOM w0.114: R546.1 30.39,138.04 v1(31.09,138.73)
TP_DBGDATA_3_R: length 4.8
  TOP w0.114: R2725.2 15.49,132.47 v3(15.49,133.1) 15.16,133.43 15.16,135.53 15.54,135.91 U23.15
TP_DBGDATA_4: length 85.3
  TOP w0.114: v6(66.4,164.45) 66.85,164.9 GPU1.AW19 ; v1(32.41,138.81) 31.85,138.25 TP51.1 31.53,137.68 R543.1 ; v1(15.73,131.19) 14.48,131.19 14.05,131.62 R2726.1
  L3 w0.114: v1(15.73,131.19) 16,131.19 16.44,130.75 16.86,130.75 17.93,131.83 17.93,133.2 19.25,134.52 28.12,134.52 v1(32.41,138.81)
  L6 w0.102: v1(32.41,138.81) 33.49,139.89 34.38,139.89 34.4,139.9 49.7,139.9 49.72,139.89 57.23,139.89 57.24,139.9 57.51,139.9 57.64,139.78 57.98,139.78 58.54,140.34 59.5,140.34 59.75,140.09 60.25,140.09 60.4,140.23 61.5,140.23 61.52,140.22 62.34,140.22 63.96,141.84 63.96,147.45 65.07,148.56 65.07,157.73 65.15,157.81 65.15,159.61 66.83,161.29 66.83,163.83 66.4,164.26 v6(66.4,164.45)
  BOTTOM w0.114: R544.1 31.53,137.93 v1(32.41,138.81)
TP_DBGDATA_4_R: length 4.7
  TOP w0.114: U23.14 15.35,136.41 14.4,135.45 v3(14.4,135.02) 14.4,133.31 R2726.2
TP_DBGDATA_5: length 92.4
  TOP w0.114: v1(15.93,130.45) 14.2,130.45 13,131.65 R2727.1 ; v1(33.17,138.51) 33.89,137.79 TP52.1 33.65,136.88 R541.1 ; GPU1.AR20 68.05,168.2 v6(67.6,167.75)
  L3 w0.114: v1(15.93,130.45) 16,130.45 16.31,130.14 19.66,130.14 20.1,130.58 20.1,131.21 19.53,131.78 19.53,133.81 19.83,134.11 28.4,134.11 32.8,138.51 v1(33.17,138.51)
  L6 w0.102: v6(67.6,167.75) 67.6,167.75 67.17,167.32 67.17,160.26 65.56,158.65 65.56,148.51 64.26,147.22 64.26,141.55 62.2,139.5 34.57,139.5 33.58,138.51 v1(33.17,138.51)
  BOTTOM w0.114: v1(33.17,138.51) 32.68,138.01 R542.1
TP_DBGDATA_5_R: length 5.6
  TOP w0.114: U23.13 15.35,136.91 13.39,134.95 v3(13.39,134.09) 13,133.7 R2727.2
TP_DBGDATA_6: length 62.1
  TOP w0.114: GPU1.AT20 68.05,167.4 v6(67.6,166.95)
  L6 w0.102: v1(34.54,138.05) 34.8,138.3 34.83,138.3 35.18,138.65 62.57,138.65 64.87,140.95 64.87,142.93 65.13,143.18 65.13,146.99 66.19,148.06 66.19,158.45 67.77,160.02 67.77,162.76 68.07,163.06 68.07,166.48 v6(67.6,166.95)
  BOTTOM w0.114: R2776.2 34.25,137.16 v2(34.67,137.16) 34.8,137.29 34.8,137.79 v1(34.54,138.05)
TP_DBGDATA_7: length 60.7
  TOP w0.114: R2777.2 33.58,134.9 v1(34.21,135.53) ; v6(67.6,163.55) 68.05,164 GPU1.AY20
  L6 w0.102: v6(67.6,163.55) 67.6,162.88 67.56,162.84 67.56,160.1 65.86,158.4 65.86,148.13 64.46,146.74 64.46,141.12 62.4,139.05 34.74,139.05 34.09,138.4 34.09,135.66 v1(34.21,135.53)
  BOTTOM w0.114: v2(34.68,134.87) 34.67,134.87 34.67,135.08 v1(34.21,135.53)
TP_DBGDATA_8: length 4.3
  TOP w0.114: v6(67.6,164.45) 68.05,164.9 GPU1.AW20
  BOTTOM w0.089: v6(67.6,164.45) 68.12,163.93 68.12,162.28 68.01,162.16
  BOTTOM w0.114: TP55.1 68.01,162.16
TP_DBGDATA_9: length 7.8
  TOP w0.114: GPU1.AU20 68.05,166.6 v6(67.6,166.15)
  BOTTOM w0.089: TP56.1 67.01,160.3 68.13,161.42 68.13,161.89 68.32,162.08 68.32,164.1 68.13,164.29 68.13,165.63 v6(67.6,166.15)
TP_DBGDATA_10: length 2.2
  TOP w0.114: v6(68.8,169.35) 69.25,169.8 GPU1.AN21
  BOTTOM w0.114: v6(68.8,169.35) 69.43,168.72 TP57.1
TP_DBGDATA_11: length 1.6
  TOP w0.114: v6(68.78,168.58) 68.82,168.61 68.86,168.61 69.25,169 GPU1.AP21
  BOTTOM w0.114: v6(68.78,168.58) 68.38,168.98 TP58.1
TP_DBGDATA_12: length 1.9
  TOP w0.114: v6(68.8,164.45) 69.25,164.9 GPU1.AW21
  BOTTOM w0.114: v6(68.8,164.45) 69.12,164.13 TP59.1
TP_DBGDATA_13: length 5
  TOP w0.114: GPU1.AV21 69.25,165.8 68.75,165.3 v6(68.75,165.23)
  BOTTOM w0.114: v6(68.75,165.23) 69.7,164.28 69.7,162.85 69.3,162.45 TP60.1
TP_DBGDATA_14: length 2.3
  TOP w0.114: v6(68.77,166.19) 68.85,166.19 69.25,166.6 GPU1.AU21
  BOTTOM w0.114: TP61.1 69.7,165.26 v6(68.77,166.19)
TP_DBGDATA_15: length 2.3
  TOP w0.114: v6(68.8,167.75) 69.25,168.2 GPU1.AR21
  BOTTOM w0.114: TP62.1 69.44,167.11 v6(68.8,167.75)
TP_DP_AUXN: length 4.5
  TOP w0.114: TP80.1 193.61,47.99 192.12,46.5 WLAN1.20
TP_DP_AUXP: length 3
  TOP w0.114: WLAN1.22 192.08,47 192.74,47.65 TP79.1
TP_DP_HPD: length 3.1
  TOP w0.114: WLAN1.31 180.75,49.25 180.45,48.96 TP88.1
TP_DP_ML0N: length 4.9
  TOP w0.114: WLAN1.32 191.53,49.5 192.02,49.98 193.44,49.98 194.07,50.61 TP76.1
TP_DP_ML0P: length 3.4
  TOP w0.114: TP75.1 192.98,50.34 191.89,50.34 191.55,50 WLAN1.34
TP_DP_ML1N: length 5.6
  TOP w0.114: WLAN1.26 191.83,48 192.42,48.59 194.41,48.59 TP78.1
TP_DP_ML1P: length 4.1
  TOP w0.114: TP77.1 193.49,48.95 192.29,48.95 191.85,48.5 WLAN1.28
TP_DP_ML2N: length 2.4
  TOP w0.114: TP90.1 180.41,47.75 WLAN1.25
TP_DP_ML2P: length 4
  TOP w0.114: WLAN1.27 181.36,48.25 181.32,48.29 179.75,48.29 TP89.1
TP_DP_ML3N: length 2.7
  TOP w0.114: WLAN1.19 181.66,46.25 181.05,45.64 180.28,45.64 TP92.1
TP_DP_ML3P: length 3.9
  TOP w0.114: WLAN1.21 181.65,46.75 181.17,46.27 179.06,46.27 TP91.1
TP_ESPI_ALERT_L: length 1.6
  TOP w0.114: v6(153.5,168.48) 153.98,168 CPU1.AT15
  BOTTOM w0.114: TP104.1 154.05,169.03 v6(153.5,168.48)
TP_GPU_GPIO_0: length 47.8
  TOP w0.114: GPU1.V39 85.37,183.93 85.55,183.75 v6(85.55,183.6)
  L4 w0.114: v1(89.39,181.82) 89.39,182.48 90.42,183.51 90.93,183.51 93.31,185.89 106.67,185.89 108.66,187.88 108.66,190.58 109.19,191.11 109.19,196.85 108.11,197.93 108.11,198.17 107.67,198.61 107.67,201.45 v1(106.17,202.95)
  L6 w0.102: v1(89.39,181.82) 88.61,181.82 87.42,183.01 86.14,183.01 v6(85.55,183.6)
  BOTTOM w0.114: R506.2 R505.2 105.28,203.84 v1(106.17,202.95) ; TP39.1 88.97,182.25 v1(89.39,181.82)
TP_GPU_GPIO_2: length 50.5
  TOP w0.114: GPU1.W37 83.85,183.45 v6(83.85,183.6)
  L4 w0.114: v1(109.07,203.13) 108.83,202.89 108.83,200.02 108.79,199.98 108.79,197.63 109.46,196.96 109.46,191 108.93,190.46 108.93,187.77 106.78,185.62 93.42,185.62 90.65,182.85 v6(90.55,182.85)
  L6 w0.102: v6(90.55,182.85) 90.3,182.6 90.3,181.63 89.86,181.19 86.61,181.19 86.18,181.61 85.8,181.99 85.11,181.99 83.85,183.26 v6(83.85,183.6)
  BOTTOM w0.114: TP40.1 90.45,182.75 v6(90.55,182.85) ; v1(109.07,203.13) 108.15,203.13 107.29,203.98 R509.2 R510.1
TP_GPU_GPIO_16: length 1.7
  TOP w0.114: GPU1.AJ33 80.2,173.52 80.64,173.97 v6(80.64,173.97)
  BOTTOM w0.114: TP41.1 81.04,174.37 v6(80.64,173.97)
TP_LPC_PD: length 14.6
  TOP w0.114: R2762.2 140.72,160.25 141.68,160.25 TP12.1 142.44,160.45 143.97,161.98 143.97,162.59 144.81,163.42 146.15,163.42 147.83,165.1 149.61,165.1 149.89,165.39 151.61,165.39 CPU1.AV18
TP_NGFF_COEX1: length 4.9
  TOP w0.114: TP69.1 193.74,54.26 193.33,54.68 192.65,54.68 191.47,53.5 WLAN1.48
TP_NGFF_COEX2: length 3.2
  TOP w0.114: WLAN1.46 191.86,53 192.97,54.11 TP70.1
TP_NGFF_COEX3: length 5.6
  TOP w0.114: WLAN1.44 191.92,52.5 192.58,53.16 193.14,53.16 193.57,53.59 194.68,53.59 TP71.1
TP_NGFF_LED1: length 2.6
  TOP w0.114: TP38.1 191.87,43 WLAN1.6
TP_NGFF_LED2: length 6.6
  TOP w0.114: TP81.1 194.68,47.42 193.53,47.42 192.56,46.45 192.56,46 192.09,45.54 191.7,45.54 191.31,45.54 191.27,45.5 WLAN1.16
TP_NGFF_MLDIR: length 4
  TOP w0.114: WLAN1.17 181.59,45.75 180.86,45.02 TP93.1
TP_NGFF_PCIE1_RXN: length 2.5
  TOP w0.114: TP84.1 180.54,58.25 WLAN1.67
TP_NGFF_PCIE1_RXP: length 3.7
  TOP w0.114: TP85.1 179.77,57.52 179.84,57.45 180.57,57.45 180.86,57.75 WLAN1.65
TP_NGFF_PCIE1_TXN: length 2.4
  TOP w0.114: TP86.1 180.77,56.75 WLAN1.61
TP_NGFF_PCIE1_TXP: length 3.7
  TOP w0.114: WLAN1.59 181.09,56.25 181,56.16 179.5,56.16 TP87.1
TP_NGFF_REFCLKN1: length 2.4
  TOP w0.114: WLAN1.73 182.72,59.74 181.76,59.74 181.58,59.56 180.72,59.56 TP82.1
TP_NGFF_REFCLKP1: length 4.6
  TOP w0.114: WLAN1.71 181.21,59.25 180.73,58.78 178.54,58.78 TP83.1
TP_PLLCHARZ_H: length 1.8
  TOP w0.114: GPU1.AM29 76.75,170.6 v6(77.2,170.15)
  BOTTOM w0.114: v6(77.2,170.15) 77.87,170.81 TP63.1
TP_PLLCHARZ_L: length 2.5
  TOP w0.114: GPU1.AN29 76.75,169.8 v6(77.2,169.35)
  BOTTOM w0.114: v6(77.2,169.35) 77.85,168.7 TP64.1
TP_SMB_CLK_MINI: length 2.8
  TOP w0.114: TP114.1 191.96,57.41 191.04,56.5 WLAN1.60
TP_SMB_DATA_MINI: length 4.5
  TOP w0.114: TP115.1 194.16,57.35 193.65,56.85 191.9,56.85 191.06,56 WLAN1.58
TP_TEST4: length 1.8
  TOP w0.114: v6(179.63,159.46) 179.54,159.46 CPU1.L23
  BOTTOM w0.114: v6(179.63,159.46) 179.68,159.51 TP1.1
TP_TEST5: length 1.6
  TOP w0.114: v6(178.49,160.5) 178.46,160.53 178.46,160.54 CPU1.M22
  BOTTOM w0.114: TP2.1 178.57,160.41 v6(178.49,160.5)
TP_TEST15: length 1.5
  TOP w0.114: CPU1.B12 v6(187.5,171.5)
  BOTTOM w0.114: TP4.1 187.58,171.58 v6(187.5,171.5)
TP_TEST28_H: length 1.8
  TOP w0.114: CPU1.E6 v6(184.5,176.47)
  BOTTOM w0.114: v6(184.5,176.47) 183.79,177.19 TP5.1
TP_TEST28_L: length 1.5
  TOP w0.114: CPU1.E7 v6(185.5,176.5)
  BOTTOM w0.114: TP6.1 185.7,176.7 v6(185.5,176.5)
TP_TEST31: length 1.5
  TOP w0.114: v6(168.54,152.56) 168.98,153 CPU1.AA30
  BOTTOM w0.114: v6(168.54,152.56) 168.5,152.59 TP7.1
TP_TEST40: length 1.5
  TOP w0.114: CPU1.W30 171,152.99 v6(171.48,152.5)
  BOTTOM w0.114: TP8.1 171.26,152.73 v6(171.48,152.5)
TP_TEST41: length 2.7
  TOP w0.114: CPU1.A16 189.91,167 v6(190.45,167.54)
  BOTTOM w0.114: TP10.1 189.89,168.1 v6(190.45,167.54)
TP_TEST47: length 1.5
  TOP w0.114: CPU1.P28 175.49,154.49 v6(175.49,154.48)
  BOTTOM w0.114: TP3.1 175.99,154.99 175.49,154.49 v6(175.49,154.48)
TP_TS_A: length 2.4
  TOP w0.114: GPU1.AA30 78.21,181.01 v6(78.21,181.2)
  BOTTOM w0.114: v6(78.21,181.2) 78.66,181.66 TP46.1
TSS_TEST6: length 1.6
  TOP w0.114: v6(61.75,184.8) 61.75,184.76 62.2,184.3 GPU1.V14
  BOTTOM w0.114: R538.2 62.34,185.4 v6(61.75,184.8)
TYPE_C_CLK: length 53.5
  TOP w0.114: R2698.1 v1(128.57,14.12)
  L4 w0.114: v1(128.57,14.12) 129.06,14.12 129.71,14.77 129.71,15.62 131.95,17.86 131.95,19.71 137.59,25.35 137.59,40.42 133.36,44.65 121.82,44.65 v1(120.37,43.21)
  BOTTOM w0.114: v1(120.37,43.21) 120.12,43.46 120.12,43.94 v2(120.38,44.2) 120.93,44.75 R2694.2
TYPE_C_DATA: length 58.7
  TOP w0.114: R2699.1 126.83,12.64 v1(126.75,12.73)
  L4 w0.114: v1(119.46,43.28) 121.31,45.14 133.47,45.14 138.01,40.59 138.01,25.18 132.46,19.63 132.46,17.78 130.12,15.44 130.12,14.43 129.26,13.56 127.58,13.56 v1(126.75,12.73)
  BOTTOM w0.114: v1(119.46,43.28) 119.76,43.59 119.76,43.95 v2(119.16,44.55) 119.16,44.6 R2695.2
TYPEC_STATUS: length 51.7
  TOP w0.114: TYPEC1.39 93.75,7.98 93.6,8.13 v1(93.6,8.13) ; v1(111.38,43.15) 111.38,43.29 111.77,43.69 111.77,43.96 112.45,44.63 KBC1.54
  L3 w0.114: v1(111.38,43.15) 111.38,42.83 110.08,41.54 108.61,41.54 102.84,35.77 101.75,35.77 100.53,34.55 100.53,24.35 98.89,22.72 98.89,22.47 98.81,22.38 98.81,14.73 98.46,14.39 98.33,14.39 97.53,13.59 97,13.59 95.73,12.32 93.75,12.32 93.34,11.91 93.34,8.39 v1(93.6,8.13)
  BOTTOM w0.114: R2746.2 v5(112.14,42.62) 111.91,42.62 v1(111.38,43.15)
U2506_CLKOUT: length 12.6
  TOP w0.114: U2505.7 117.21,74.7 v1(117.66,75.16) 118.31,75.81 118.31,78.66 117.73,79.25 116.15,79.25 115.77,78.86 R2754.2
  BOTTOM w0.114: v1(117.66,75.16) 116.55,74.05 TP2503.1 115.66,74.36 U2506.7
U2506_INT#: length 5.7
  TOP w0.114: v1(109.52,73.91) R2753.2 110.01,73.11 110.34,73.43 U2505.3
  BOTTOM w0.114: v1(109.52,73.91) 109.52,75 TP2504.1 110.44,75.08 110.66,74.86 U2506.3
USB0_ZVSS: length 4.6
  TOP w0.114: CPU1.AJ3 v6(160.5,180.5)
  BOTTOM w0.114: R86.2 161.8,182.63 v2(161.67,182.5) 161.04,181.86 161.04,181.04 v6(160.5,180.5)
USB1_ZVSS: length 7
  TOP w0.114: CPU1.AN6 v6(156.5,176.5)
  BOTTOM w0.114: v6(156.5,176.5) 156.27,176.5 v2(155.35,177.42) 154.84,177.93 154.51,177.93 154.05,178.39 154.05,179.53 153.67,179.91 152.91,179.91 152.58,179.58 R1213.2
USB2_ZVSS: length 4.1
  TOP w0.114: CPU1.AK6 v6(160.51,176.48)
  BOTTOM w0.114: R1214.2 158.57,177.55 v2(158.7,177.67) 159.36,177.01 159.98,177.01 v6(160.51,176.48)
USB3_ZVSS: length 10.1
  TOP w0.114: CPU1.AK5 159.97,178 159.51,177.54 v6(159.51,177.52)
  BOTTOM w0.114: R1215.2 157.84,183.9 v2(158.3,183.43) 158.32,183.43 159.1,182.65 159.1,180.97 159.89,180.17 159.89,179.56 160.51,178.94 160.64,178.94 160.91,178.67 160.91,178.19 160.24,177.52 v6(159.51,177.52)
USB20_OC_CR1#: length 35.1
  TOP w0.114: R2781.1 131,176.17 v1(130.43,176.17) ; CPU1.AM1 158,182.11 v6(157.54,182.58)
  L4 w0.114: v6(157.54,182.58) 156.6,183.51 150.06,183.51 146.56,180.01 143.33,180.01 143.28,180.07 132.47,180.07 130.89,178.48 130.89,176.61 130.46,176.17 v1(130.43,176.17)
  BOTTOM w0.114: v2(131.34,175.94) 130.66,175.94 v1(130.43,176.17)
USB30_RX_CPU_N0: length 286
  TOP w0.102: v1(101.79,9.12) 101.45,8.78 101.45,8.48 101.11,8.14 101.11,7.88 101.25,7.75 TYPEC1.24 ; CPU1.Y4 v6(169.5,178.5)
  L6 w0.102: v1(101.79,9.12) 101.47,8.8 101.47,8.64 101.09,8.26 101.09,7.57 100.58,7.06 93.29,7.06 86.49,13.86 86.49,29.6 85.78,30.31 85.78,33.12 82.75,36.14 82.75,49.36 85.09,51.69 85.09,54.33 82.7,56.71 82.7,81.84 84.68,83.82 85.42,83.82 87.63,86.03 87.63,88.23 93.51,94.11 96.77,94.11 99.97,97.31 104.06,97.31 112.57,105.82 112.57,121.64 117.09,126.17 117.09,126.88 121.23,131.02 121.23,165.99 119.28,167.94 119.28,174.32 121.08,176.13 121.08,184.49 131.25,194.65 140.71,194.65 141.28,194.08 141.69,194.08 144.25,191.52 155.6,191.52 157.91,189.2 168.3,189.2 171.15,186.36 171.15,183.05 169.9,181.81 169.9,179.76 169.98,179.68 169.98,178.98 v6(169.5,178.5)
  BOTTOM w0.102: v1(101.79,9.12) 101.8,9.11 v5(102.42,9.11)
USB30_RX_CPU_N1: length 236.4
  TOP w0.102: RUSBC1.7 84.53,37.75 84.68,37.59 85.6,37.59 ; CPU1.AA3 168.38,180.62 168.38,182.33 168.07,182.64 168.07,183.38 168.54,183.85 168.58,183.85 v1(169.06,184.33) ; v1(86.61,38) 86.21,37.59 85.6,37.59 ; 85.6,37.59 v3(85.6,38)
  L6 w0.102: v1(169.06,184.33) 169.29,184.33 169.47,184.15 169.75,184.15 169.85,184.25 169.85,185.47 167.61,187.71 157.68,187.71 155.06,190.32 143.76,190.32 141.19,192.89 140.72,192.89 140.14,193.46 131.74,193.46 122.43,184.14 122.43,130.63 118.21,126.41 118.21,124.56 113.77,120.12 113.77,105.31 113.41,104.95 113.41,103.9 105.4,95.89 100.24,95.89 97.27,92.91 94.28,92.91 91.22,89.85 91.22,89.6 90.95,89.33 90.7,89.33 88.82,87.45 88.82,85.29 84.23,80.7 84.23,58.95 84.51,58.67 84.51,56.62 86.28,54.84 86.28,50.85 84.25,48.82 84.25,38.13 84.79,37.59 86.21,37.59 v1(86.61,38)
USB30_RX_CPU_P0: length 286
  TOP w0.102: v1(100.88,9.12) 101.22,8.78 101.22,8.57 100.89,8.24 100.89,7.88 100.75,7.75 TYPEC1.25 ; CPU1.Y3 v6(169.5,179.5)
  L6 w0.102: v6(169.5,179.5) 169.65,179.65 169.65,181.91 170.89,183.16 170.89,186.26 168.2,188.95 157.81,188.95 155.49,191.26 144.15,191.26 141.58,193.83 141.17,193.83 140.6,194.4 131.36,194.4 121.34,184.38 121.34,176.02 119.53,174.22 119.53,172.82 119.63,172.73 119.63,172.34 119.53,172.25 119.53,171.86 119.63,171.77 119.63,171.38 119.53,171.29 119.53,170.9 119.63,170.81 119.63,170.42 119.53,170.33 119.53,168.05 121.49,166.09 121.49,130.91 117.35,126.77 117.35,126.06 116.96,125.67 116.96,125.53 116.69,125.26 116.55,125.26 116.28,124.99 116.28,124.85 116.01,124.58 115.87,124.58 115.6,124.31 115.6,124.17 115.33,123.9 115.19,123.9 112.83,121.54 112.83,105.71 106.62,99.51 106.62,99.37 106.35,99.1 106.21,99.1 105.94,98.83 105.94,98.69 105.67,98.42 105.53,98.42 105.26,98.15 105.26,98.01 104.99,97.74 104.85,97.74 104.17,97.05 100.08,97.05 96.88,93.85 93.62,93.85 93.35,93.58 93.35,93.44 93.08,93.17 92.94,93.17 92.67,92.9 92.67,92.76 92.4,92.5 92.26,92.5 91.99,92.23 91.99,92.09 91.72,91.82 91.58,91.82 87.88,88.12 87.88,85.93 85.52,83.57 84.78,83.57 82.96,81.74 82.96,81.36 83.13,81.18 83.13,80.8 82.96,80.63 82.96,80.24 83.13,80.07 83.13,79.69 82.96,79.51 82.96,79.13 83.13,78.96 83.13,78.58 82.96,78.4 82.96,73.32 83.13,73.14 83.13,72.76 82.96,72.59 82.96,72.21 83.13,72.03 83.13,71.65 82.96,71.48 82.96,71.1 83.13,70.92 83.13,70.54 82.96,70.36 82.96,56.82 85.34,54.43 85.34,51.59 83.01,49.25 83.01,47.06 83.11,46.96 83.11,46.58 83.01,46.48 83.01,46.1 83.11,46 83.11,45.62 83.01,45.52 83.01,42.62 83.11,42.52 83.11,42.14 83.01,42.04 83.01,41.66 83.11,41.56 83.11,41.18 83.01,41.08 83.01,36.25 86.03,33.22 86.03,30.42 86.74,29.71 86.74,25.84 86.84,25.74 86.84,25.36 86.74,25.26 86.74,24.88 86.84,24.78 86.84,24.4 86.74,24.3 86.74,23.92 86.84,23.82 86.84,23.44 86.74,23.34 86.74,18.26 86.84,18.16 86.84,17.78 86.74,17.68 86.74,17.3 86.84,17.2 86.84,16.82 86.74,16.72 86.74,16.34 86.84,16.24 86.84,15.86 86.74,15.76 86.74,13.97 90.05,10.66 90.19,10.66 90.46,10.39 90.46,10.25 90.73,9.98 90.87,9.98 91.14,9.71 91.14,9.57 91.41,9.3 91.55,9.3 91.82,9.04 91.82,8.9 93.4,7.32 100.48,7.32 100.84,7.67 100.84,8.37 101.17,8.7 101.17,8.83 v1(100.88,9.12)
  BOTTOM w0.102: v2(169.49,180.08) 169.49,179.5 v6(169.5,179.5)
USB30_RX_CPU_P1: length 235.9
  TOP w0.102: v1(86.61,36.98) 86.23,37.36 84.61,37.36 84.49,37.25 RUSBC1.6 ; CPU1.AA2 168.61,181.39 168.61,182.42 168.3,182.73 168.3,183.28 168.63,183.62 168.98,183.62 v1(169.06,183.54)
  L6 w0.102: v1(86.61,36.98) 86.26,37.34 84.68,37.34 84,38.02 84,48.92 86.03,50.96 86.03,54.73 84.25,56.51 84.25,58.57 83.97,58.85 83.97,80.8 88.57,85.4 88.57,87.56 94.18,93.17 97.16,93.17 100.13,96.14 105.29,96.14 113.16,104 113.16,105.06 113.51,105.41 113.51,120.22 117.96,124.67 117.96,126.52 122.17,130.74 122.17,184.25 131.64,193.71 140.25,193.71 140.82,193.14 141.3,193.14 143.86,190.58 155.17,190.58 157.78,187.96 167.72,187.96 170.1,185.58 170.1,184.15 169.85,183.9 169.42,183.9 v1(169.06,183.54)
USB30_RX_PCH_N0: length 136.5
  TOP w0.127: RUSBC1.13 84.48,40.75 84.61,40.61 86.34,40.61 v1(86.59,40.87) ; PCH1.AC15 v6(161.8,37.8)
  L3 w0.14: v6(161.8,37.8) 161.88,37.8 162.08,37.6 162.08,37.49 161.84,37.25 161.84,33.62 162.82,32.64 162.94,32.64 163.3,32.28 163.3,31.45 158.55,26.7 158.55,18.08 145.99,5.52 94.86,5.52 86.04,14.34 86.04,24.38 86.17,24.5 86.17,24.92 86.04,25.05 86.04,26.8 86.17,26.92 86.17,27.34 86.04,27.47 86.04,27.89 86.17,28.01 86.17,28.43 86.04,28.55 86.04,28.97 86.17,29.1 86.17,29.52 86.04,29.64 86.04,31.18 88.6,33.73 88.6,39.47 87.56,40.5 86.96,40.5 v1(86.59,40.87)
USB30_RX_PCH_N1: length 84.9
  TOP w0.127: v1(231.78,24.89) 231.72,24.89 231.52,25.09 231.52,25.4 231.99,25.87 232.83,25.87 233.2,25.5 SUSBC1.3 ; PCH1.AB16 v6(163.4,37.8)
  L4 w0.14: v6(163.4,37.8) 163.86,37.34 165.1,37.34 168.91,33.53 174.88,33.53 177.77,30.63 183.67,30.63 184.8,31.76 191.6,31.76 195.19,35.34 215.63,35.34 220.05,30.92 230.82,30.92 232.07,29.67 232.07,25.95 231.58,25.46 231.58,25.08 v1(231.78,24.89)
USB30_RX_PCH_P0: length 136.6
  TOP w0.127: v1(86.59,39.85) 86.07,40.37 84.63,40.37 84.5,40.25 RUSBC1.12 ; PCH1.AB15 v6(162.6,37.8)
  L3 w0.14: v6(162.6,37.8) 162.36,37.56 162.36,37.39 162.1,37.13 162.1,33.73 162.93,32.91 163.05,32.91 163.56,32.39 163.56,31.33 158.81,26.58 158.81,17.97 146.1,5.26 94.75,5.26 85.78,14.23 85.78,31.29 88.33,33.84 88.33,39.36 87.45,40.23 86.97,40.23 v1(86.59,39.85)
USB30_RX_PCH_P1: length 84.8
  TOP w0.127: PCH1.AC16 v6(163.4,37) ; SUSBC1.5 233.26,26.5 232.87,26.11 231.89,26.11 230.93,25.15 v1(230.63,25.15)
  L4 w0.14: v1(230.63,25.15) 230.89,25.15 231.31,25.57 231.32,25.57 231.81,26.06 231.81,29.56 230.71,30.66 219.94,30.66 215.52,35.08 195.3,35.08 191.72,31.5 184.91,31.5 183.78,30.37 177.66,30.37 174.77,33.26 168.8,33.26 164.99,37.07 163.47,37.07 v6(163.4,37)
