# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_RX_CPU_N0_C: length 16
  TOP w0.102: 147.75,52.4 143.74,52.4 142.67,53.47 142.67,53.62 143.37,54.32 143.52,54.32 144.53,53.31 145.59,53.31 145.8,53.52 145.8,53.9 146.18,54.28 C196.1 ; 147.75,52.4 v3(147.75,52.78) ; 147.75,52.4 148.8,52.4 149.73,51.47 149.73,51.19 150.35,50.57 151.43,50.57 PCH1.G2
DMI_RX_CPU_N1: length 195.6
  TOP w0.102: C198.2 138.66,54.37 138,54.37 ; v1(136.97,54.8) 136.58,54.41 136.58,54.26 136.69,54.15 137.48,54.15 137.7,54.37 138,54.37 ; v3(138,54.76) 138,54.37 ; CPU1.AA8 v6(168.5,175.5)
  L3 w0.089: v6(168.5,175.5) 168.91,175.91 168.91,179.9 169.17,180.16 169.16,180.16 169.16,180.25
  L3 w0.102: 169.16,180.25 169.16,182.22 169.54,182.6 169.54,185.41 167.45,187.5 146.86,187.5 145.05,185.69 145.05,185.55 144.83,185.33 144.69,185.33 144.48,185.12 144.48,184.98 144.26,184.76 144.12,184.76 143.9,184.54 143.9,184.4 143.69,184.19 143.55,184.19 141.78,182.42 141.48,182.42 141.38,182.32 141.07,182.32 140.98,182.42 140.67,182.42 140.57,182.32 140.27,182.32 140.17,182.42 139.86,182.42 139.76,182.32 139.46,182.32 139.36,182.42 134.28,182.42 134.18,182.32 133.88,182.32 133.78,182.42 133.33,182.42 131.26,180.35 131.26,180.21 131.05,180 130.91,180 130.69,179.78 130.69,179.64 130.48,179.43 130.34,179.43 130.12,179.21 130.12,179.07 129.91,178.86 129.77,178.86 126.17,175.26 126.17,175.12 125.96,174.91 125.82,174.91 125.6,174.69 125.6,174.55 125.39,174.34 125.25,174.34 125.03,174.12 125.03,173.98 124.82,173.77 124.68,173.77 124.46,173.55 124.46,162.26 125.53,161.2 125.53,144.73 126.67,143.59 126.67,136.73 124.26,134.32 124.26,127.89 123.93,127.56 123.93,111.71 123.19,110.97 123.19,98.88 124.71,97.36 124.71,93.96 124.81,93.87 124.81,93.56 124.71,93.46 124.71,93.16 124.81,93.06 124.81,92.75 124.71,92.65 124.71,92.35 124.81,92.25 124.81,91.95 124.71,91.85 124.71,91.54 126.49,89.76 126.49,82.5 127.91,81.08 127.91,80.47 137.11,71.28 137.11,68.23 137.69,67.65 137.69,58.7 136.6,57.61 136.6,55.17 v1(136.97,54.8)
DMI_RX_CPU_N1_C: length 14.8
  TOP w0.102: C198.1 140.22,54.38 140.72,54.38 140.97,54.13 ; 140.97,54.13 v3(141.25,54.41) ; 140.97,54.13 143.38,51.71 147.28,51.71 149.97,49.02 151.38,49.02 PCH1.J2
DMI_RX_CPU_N2: length 204.8
  TOP w0.102: C200.2 141.44,50.62 141.1,50.62 140.79,50.93 140.79,51.69 139.93,52.55 ; CPU1.Y7 v6(169.5,175.5) ; v1(134.49,53.44) 134.98,52.96 139.52,52.96 139.93,52.55 ; v3(140.21,52.83) 139.93,52.55
  L3 w0.102: v6(169.5,175.5) 170.02,176.64 170.02,176.73 170.11,176.82 170.11,180.26 170.07,180.3 170.07,181.65 170.56,182.14 170.56,186.26 168.15,188.67 146.42,188.67 141.19,183.44 132.91,183.44 132.44,182.97 132.44,182.96 132.38,182.91 132.38,182.9 123.2,173.72 123.2,162.07 124.41,160.86 124.41,144.35 125.02,143.74 125.02,136.86 123.24,135.08 123.24,129.41 122.89,129.06 122.89,112.11 122.17,111.39 122.17,98.44 123.7,96.92 123.7,90.52 125.48,88.74 125.48,82.06 126.9,80.64 126.9,80.05 134.77,72.17 134.77,55.7 135.28,55.19 135.28,53.17 135.17,53.06 134.82,53.06 134.49,53.39 v1(134.49,53.44)
DMI_RX_CPU_N2_C: length 15.6
  TOP w0.102: 147.62,49.63 146.69,50.57 145.46,50.57 145.24,50.35 145.24,49.9 145.46,49.68 146.27,49.68 146.37,49.58 146.37,49.3 146.27,49.2 144.86,49.2 144.76,49.3 144.76,50.35 144.54,50.57 143.42,50.57 143.01,50.98 C200.1 ; 147.62,49.63 149.83,47.42 151.38,47.42 PCH1.L2 ; 147.62,49.63 v3(147.9,49.91)
DMI_RX_CPU_N3: length 206
  TOP w0.102: v3(139.85,51.08) 139.57,50.8 ; 139.57,50.8 140.26,50.11 140.26,48.93 140.37,48.82 141.59,48.82 C202.2 ; 139.57,50.8 138.71,51.66 137.92,51.66 v1(137.57,52.02) ; CPU1.W5 v6(171.5,178.5)
  L3 w0.089: 171.17,181.97 171.17,181.89 171.18,181.88 171.18,181.33 170.9,181.05 170.9,179.22 171.18,178.94 171.37,178.94 171.5,178.82 v6(171.5,178.5)
  L3 w0.102: 171.17,181.97 171.17,186.61 168.5,189.28 146,189.28 140.82,184.1 132.68,184.1 122.56,173.97 122.56,161.83 123.8,160.59 123.8,138.51 123.83,138.48 123.83,136.71 122.63,135.52 122.63,129.67 122.28,129.31 122.28,114.5 121.39,113.61 121.39,100.35 119.89,98.85 119.89,93.2 123.34,89.75 123.34,84.05 124.87,82.53 124.87,81.79 126.29,80.37 126.29,79.8 133.99,72.1 133.99,54.05 133.88,53.95 133.88,52.21 134.48,51.61 137.16,51.61 v1(137.57,52.02)
DMI_RX_CPU_N3_C: length 14.4
  TOP w0.102: 147.98,47.48 149.26,46.2 149.87,46.2 150.27,45.8 151.4,45.8 PCH1.N2 ; 147.98,47.48 146.95,48.51 145.98,48.51 145.76,48.29 145.76,47.85 145.98,47.62 146.25,47.62 146.35,47.52 146.35,47.24 146.25,47.14 145.38,47.14 145.28,47.24 145.28,48.29 145.06,48.51 144.58,48.51 144.42,48.67 143.37,48.67 143.01,49.02 C202.1 ; 147.98,47.48 v3(148.26,47.75)
DMI_RX_CPU_P0: length 176
  TOP w0.102: CPU1.AE8 v6(165.5,174.5) ; C195.2 145.32,55.18 145.56,55.43 145.56,55.57 145.24,55.9 145.24,56.08 145.23,56.18 v1(144.86,56.52)
  L3 w0.102: v6(165.5,174.5) 166.11,175.11 166.11,180.75 164.62,182.25 162.82,182.25 161.88,183.19 161.88,184.53 161.42,184.99 154.88,184.99 153.99,184.1 150.92,184.1 145.21,178.39 145.21,177.27 141.27,173.33 136.11,173.33 129.77,166.99 129.77,134.78 128.14,133.15 128.14,117.02 127.23,116.1 127.23,110.6 126.24,109.61 126.24,100.23 128.88,97.59 128.88,94.05 132.74,90.19 132.74,85.55 137.97,80.31 137.97,75.25 141.35,71.87 141.35,68.45 145.24,64.57 145.24,56.9 v1(144.86,56.52)
DMI_RX_CPU_P0_C: length 15.5
  TOP w0.102: PCH1.G1 150.83,50.37 150.27,50.37 149.53,51.1 149.53,51.38 149.12,51.79 ; C195.1 145.59,53.96 145.59,53.6 145.51,53.52 144.61,53.52 143.6,54.53 143.29,54.53 142.46,53.7 142.46,53.39 143.65,52.2 148.72,52.2 149.12,51.79 ; 149.12,51.79 v3(148.84,51.51)
DMI_RX_CPU_P1: length 196.4
  TOP w0.102: v1(135.99,54.79) 136.37,54.41 136.37,54.18 136.6,53.95 137.11,53.95 ; CPU1.AB8 v6(168.5,174.5) ; v3(137.11,53.57) 137.11,53.95 ; 137.11,53.95 137.57,53.95 137.78,54.17 138.66,54.17 C197.2
  L3 w0.089: v6(168.5,174.5) 169.1,175.1 169.1,179.82 169.37,180.09 169.37,180.25
  L3 w0.102: 169.37,180.25 169.37,182.14 169.75,182.52 169.75,185.49 167.54,187.71 146.78,187.71 141.7,182.63 133.25,182.63 124.26,173.63 124.26,162.18 125.32,161.11 125.32,144.64 126.47,143.5 126.47,136.81 124.05,134.4 124.05,127.97 123.72,127.64 123.72,111.79 122.99,111.06 122.99,98.8 124.51,97.27 124.51,91.46 126.29,89.68 126.29,82.41 127.71,80.99 127.71,80.39 136.91,71.19 136.91,68.15 137.49,67.56 137.49,58.78 136.4,57.69 136.4,55.19 v1(135.99,54.79)
DMI_RX_CPU_P1_C: length 14
  TOP w0.102: C197.1 140.25,54.18 140.63,54.18 142.31,52.5 ; 142.31,52.5 143.3,51.51 144.46,51.51 144.56,51.41 144.87,51.41 144.97,51.51 147.19,51.51 149.89,48.82 150.78,48.82 PCH1.J1 ; 142.31,52.5 v3(142.04,52.22)
DMI_RX_CPU_P2: length 205.7
  TOP w0.102: 136.53,52.76 134.72,52.76 v1(134.49,52.53) ; 136.53,52.76 139.44,52.76 140.59,51.6 140.59,50.84 141,50.43 141.01,50.43 141.35,50.09 C199.2 ; 136.53,52.76 v3(136.53,52.37) ; CPU1.Y6 v6(169.5,176.5)
  L3 w0.102: v1(134.49,52.53) 134.82,52.86 135.25,52.86 135.48,53.09 135.48,55.28 134.98,55.79 134.98,63.29 135.07,63.39 135.07,63.69 134.98,63.79 134.98,70.49 135.07,70.59 135.07,70.89 134.98,70.99 134.98,71.3 135.07,71.39 135.07,71.7 134.98,71.8 134.98,72.26 127.1,80.13 127.1,80.72 125.68,82.14 125.68,88.82 123.9,90.6 123.9,97 122.38,98.53 122.38,111.31 123.09,112.02 123.09,128.97 123.44,129.33 123.44,134.99 125.22,136.77 125.22,143.82 124.61,144.43 124.61,144.74 124.71,144.84 124.71,145.14 124.61,145.24 124.61,145.55 124.71,145.64 124.71,145.95 124.61,146.05 124.61,146.35 124.71,146.45 124.71,146.76 124.61,146.86 124.61,151.94 124.71,152.03 124.71,152.34 124.61,152.44 124.61,152.74 124.71,152.84 124.71,153.15 124.61,153.25 124.61,153.55 124.71,153.65 124.71,153.95 124.61,154.05 124.61,159.13 124.71,159.23 124.71,159.54 124.61,159.64 124.61,159.94 124.71,160.04 124.71,160.35 124.61,160.44 124.61,160.94 123.4,162.16 123.4,162.46 123.5,162.56 123.5,162.87 123.4,162.96 123.4,163.27 123.5,163.37 123.5,163.67 123.4,163.77 123.4,164.08 123.5,164.18 123.5,164.48 123.4,164.58 123.4,169.66 123.5,169.76 123.5,170.06 123.4,170.16 123.4,170.47 123.5,170.57 123.5,170.87 123.4,170.97 123.4,171.28 123.5,171.37 123.5,171.68 123.4,171.78 123.4,173.64 132.64,182.88 132.64,182.88 132.99,183.24 141.27,183.24 146.5,188.47 146.81,188.47 146.91,188.37 147.21,188.37 147.31,188.47 147.62,188.47 147.71,188.37 148.02,188.37 148.12,188.47 148.42,188.47 148.52,188.37 148.83,188.37 148.93,188.47 154.01,188.47 154.1,188.37 154.41,188.37 154.51,188.47 154.81,188.47 154.91,188.37 155.22,188.37 155.32,188.47 155.62,188.47 155.72,188.37 156.03,188.37 156.12,188.47 161.2,188.47 161.3,188.37 161.61,188.37 161.71,188.47 162.01,188.47 162.11,188.37 162.42,188.37 162.51,188.47 162.82,188.47 162.92,188.37 163.22,188.37 163.32,188.47 168.06,188.47 168.64,187.88 168.64,187.74 168.86,187.53 169,187.53 169.22,187.31 169.22,187.17 169.43,186.96 169.57,186.96 169.79,186.74 169.79,186.6 170,186.39 170.14,186.39 170.36,186.17 170.36,182.23 169.86,181.73 169.86,180.22 169.91,180.17 169.91,176.91 v6(169.5,176.5)
DMI_RX_CPU_P2_C: length 14.6
  TOP w0.102: v3(143.87,49.99) 143.87,50.37 ; 143.87,50.37 144.45,50.37 144.56,50.27 144.56,49.22 144.78,49 146.35,49 146.58,49.22 146.58,49.67 146.35,49.89 145.55,49.89 145.45,49.99 145.45,50.27 145.55,50.37 146.6,50.37 149.75,47.22 150.78,47.22 PCH1.L1 ; 143.87,50.37 143.31,50.37 143.03,50.09 C199.1
DMI_RX_CPU_P3: length 206.9
  TOP w0.102: C201.2 141.31,48.62 140.61,48.62 ; 140.61,48.62 v3(140.61,48.23) ; 140.61,48.62 140.28,48.62 140.06,48.84 140.06,50.03 138.63,51.46 137.92,51.46 v1(137.57,51.1) ; CPU1.W4 v6(171.5,179.5)
  L3 w0.089: 171.37,181.97 171.37,181.25 171.1,180.98 171.1,179.3 171.26,179.13 171.41,179.13 171.5,179.22 v6(171.5,179.5)
  L3 w0.102: 171.37,181.97 171.37,186.7 168.59,189.48 145.91,189.48 140.73,184.3 132.6,184.3 122.35,174.06 122.35,161.75 123.6,160.5 123.6,138.3 123.62,138.28 123.62,136.8 122.43,135.6 122.43,129.75 122.07,129.4 122.07,114.59 121.18,113.7 121.18,100.43 119.68,98.93 119.68,93.12 123.14,89.66 123.14,83.97 124.66,82.44 124.66,81.7 126.09,80.28 126.09,79.71 131.87,73.93 131.87,73.79 132.08,73.58 132.22,73.58 132.44,73.36 132.44,73.22 132.65,73.01 132.79,73.01 133.01,72.79 133.01,72.65 133.22,72.43 133.36,72.43 133.78,72.02 133.78,54.14 133.68,54.03 133.68,52.12 134.39,51.41 137.26,51.41 v1(137.57,51.1)
DMI_RX_CPU_P3_C: length 13.5
  TOP w0.102: v3(143.87,48.08) 143.87,48.46 ; 143.87,48.46 143.43,48.46 143.1,48.13 C201.1 ; 143.87,48.46 144.34,48.46 144.49,48.31 144.98,48.31 145.08,48.21 145.08,47.16 145.3,46.94 146.34,46.94 146.56,47.16 146.56,47.61 146.34,47.83 146.07,47.83 145.97,47.93 145.97,48.21 146.07,48.31 146.86,48.31 149.17,46 149.78,46 150.19,45.59 150.81,45.59 PCH1.N1
DMI_TX_CPU_N0: length 137
  TOP w0.102: C2.2 134.78,165.74 133,165.74 v1(132.59,165.33) ; PCH1.G4 v6(153,49.8)
  L3 w0.102: v6(153,49.8) 152.58,49.38 150.6,49.38 150.38,49.59 150.38,49.73 150.17,49.95 150.03,49.95 149.81,50.16 149.81,50.3 149.59,50.52 149.45,50.52 147.85,52.12 147.85,52.26 147.64,52.48 147.5,52.48 147.28,52.69 147.28,52.83 147.07,53.05 146.93,53.05 146.71,53.26 146.71,55.03 146.81,55.13 146.81,55.43 146.71,55.53 146.71,55.84 146.81,55.94 146.81,56.24 146.71,56.34 146.71,56.65 146.81,56.74 146.81,57.05 146.71,57.15 146.71,62.23 146.81,62.33 146.81,62.63 146.71,62.73 146.71,63.04 146.81,63.13 146.81,63.44 146.71,63.54 146.71,63.84 146.81,63.94 146.81,64.25 146.71,64.35 146.71,64.65 144.16,67.2 144.16,67.35 143.94,67.56 143.8,67.56 143.59,67.78 143.59,67.92 143.37,68.13 143.23,68.13 143.01,68.35 143.01,68.49 142.8,68.7 142.66,68.7 142.44,68.92 142.44,70.15 142.54,70.25 142.54,70.56 142.44,70.66 142.44,70.96 142.54,71.06 142.54,71.36 142.44,71.46 142.44,71.77 142.54,71.87 142.54,72.17 142.44,72.27 142.44,72.58 141.59,73.43 141.59,73.57 141.38,73.78 141.24,73.78 141.02,74 141.02,74.14 140.8,74.35 140.66,74.35 140.45,74.57 140.45,74.71 140.23,74.93 140.09,74.93 139.88,75.14 139.88,75.45 139.98,75.55 139.98,75.85 139.88,75.95 139.88,76.25 139.98,76.35 139.98,76.66 139.88,76.76 139.88,77.55 139.19,78.23 139.19,80.9 135.28,84.81 135.28,87.51 133.76,89.04 133.76,90.92 129.9,94.78 129.9,98.03 127.38,100.54 127.38,109.16 129.16,110.94 129.16,120.62 130.02,121.49 130.02,131.83 130.78,132.59 130.78,164.57 131.85,165.63 132.28,165.63 v1(132.59,165.33)
  BOTTOM w0.102: v1(132.59,165.33) 132.59,165.33 v2(131.88,165.33)
DMI_TX_CPU_N0_C: length 41.7
  TOP w0.102: C2.1 136.34,165.74 136.68,165.74 136.77,165.74 136.8,165.74 v1(137.14,165.39) ; CPU1.AE5 v6(164.5,178.5)
  L3 w0.102: v6(164.5,178.5) 164.1,178.9 163.92,178.9 162.13,180.69 162.13,181.45 160.39,183.18 155.41,183.18 154.36,182.14 154.36,181.15 150.47,177.27 148.26,177.27 144.55,173.56 144.55,170.42 140.38,166.24 138.86,166.24 138.43,165.81 137.56,165.81 v1(137.14,165.39)
DMI_TX_CPU_N1: length 148.4
  TOP w0.102: PCH1.J4 v6(153,48.2) ; C4.2 133.63,175.88 133.63,175.61 v1(133.2,175.18)
  L3 w0.102: v1(133.2,175.18) 133.58,174.8 133.58,173.26 130.73,170.42 130.73,169.25 128.96,167.47 128.96,135.29 127.33,133.66 127.33,117.36 126.29,116.31 126.29,110.85 125.43,109.99 125.43,99.87 128.07,97.23 128.07,93.69 130.71,91.05 130.71,83.94 132.66,81.98 132.66,79.19 139.93,71.92 139.93,55.45 142.67,52.7 145.51,52.7 149.52,48.69 153.02,48.69 153.12,48.6 153.12,48.32 v6(153,48.2)
  BOTTOM w0.102: v1(133.2,175.18) 133.42,175.4 v2(133.42,175.83)
DMI_TX_CPU_N1_C: length 51.1
  TOP w0.102: CPU1.AB5 v6(168.5,178.5) ; C4.1 133.54,177.36 133.54,178.19 v1(133.09,178.64) 132.71,179.01 v3(132.71,179.29)
  L3 w0.102: v1(133.09,178.64) 133.48,179.03 133.48,179.51 135.6,181.64 143.64,181.64 148.9,186.89 166.84,186.89 168.4,185.33 168.4,180.21 168.07,179.88 168.07,178.19 168.16,178.1 168.39,178.1 168.5,178.22 v6(168.5,178.5)
DMI_TX_CPU_N2: length 156
  TOP w0.102: v1(136.04,175.23) 136.03,175.23 135.67,175.59 135.67,175.89 C6.2 ; PCH1.L4 v6(153,46.6)
  L3 w0.102: v1(136.04,175.23) 135.69,175.59 135.69,176.1 135.25,176.53 132.12,176.53 131.57,175.98 131.57,174.66 130.6,173.69 129.58,173.69 127.81,171.92 127.81,160.24 128.14,159.91 128.14,136.05 126.52,134.42 126.52,117.88 125.35,116.71 125.35,111.08 124.61,110.35 124.61,99.51 127.13,96.99 127.13,91.26 129.59,88.8 129.59,83.68 131.57,81.7 131.57,79.01 139.12,71.47 139.12,55.06 142.31,51.87 145.08,51.87 149.65,47.29 152.95,47.29 153.2,47.04 153.2,46.8 v6(153,46.6)
DMI_TX_CPU_N2_C: length 46.2
  TOP w0.102: C6.1 135.67,177.44 135.67,178.3 v1(136.07,178.7) ; CPU1.AC7 v6(167.5,176.5)
  L3 w0.102: v6(167.5,176.5) 166.62,177.38 166.62,185.18 166.08,185.72 149.83,185.72 144.27,180.16 136.35,180.16 135.81,179.63 135.81,178.96 v1(136.07,178.7)
DMI_TX_CPU_N3: length 153.2
  TOP w0.102: v1(125.22,168.81) 125.58,169.16 128.08,169.16 128.72,168.53 130.91,168.53 ; 130.91,168.53 v3(130.91,168.12) ; 130.91,168.53 131.7,168.53 132.27,169.1 132.27,169.51 132.6,169.85 132.82,169.85 C8.2 ; PCH1.N4 v6(153,45)
  L3 w0.102: v1(125.22,168.81) 125.58,169.16 126.23,169.16 126.44,168.95 126.44,160.27 127.28,159.43 127.28,136.34 125.7,134.76 125.7,118.67 124.54,117.5 124.54,111.44 123.8,110.7 123.8,99.15 126.29,96.66 126.29,90.85 128.55,88.59 128.55,80.71 138.3,70.96 138.3,54.65 141.98,50.98 143.81,50.98 149.28,45.5 153.2,45.5 153.3,45.4 153.3,45.3 v6(153,45)
DMI_TX_CPU_N3_C: length 44.8
  TOP w0.102: v3(135.46,169.54) 135.46,169.95 ; 135.46,169.95 136.16,169.95 v1(136.53,169.59) ; 135.46,169.95 134.9,169.95 134.74,169.79 134.44,169.79 C8.1 ; CPU1.AD6 v6(165.5,177.5)
  L3 w0.089: 163.71,180.3 163.73,180.28 163.73,180.28 164.11,179.91 164.67,179.91 164.9,179.68 164.9,178.26 165.5,177.66 v6(165.5,177.5)
  L3 w0.102: 163.71,180.3 162.84,181.17 162.84,181.32 161,183.16 160.99,183.16 160.26,183.9 155.23,183.9 154.59,183.26 152.65,183.26 151.89,182.5 151.89,182.02 152.12,181.79 152.12,181.2 151.97,181.05 151.97,179.96 149.94,177.93 147.63,177.93 141.84,172.14 138.34,172.14 137.87,171.67 137.87,170.6 137.21,169.94 136.88,169.94 v1(136.53,169.59)
DMI_TX_CPU_P0: length 136.6
  TOP w0.102: 133.6,165.94 134.78,165.94 C1.2 ; 133.6,165.94 132.99,165.94 v1(132.59,166.34) ; 133.6,165.94 v3(133.6,166.34) ; PCH1.G5 v6(153.8,49.8)
  L3 w0.102: v1(132.59,166.34) 132.08,165.84 131.77,165.84 130.58,164.65 130.58,132.67 129.82,131.91 129.82,121.57 128.96,120.71 128.96,111.02 127.18,109.25 127.18,100.46 129.69,97.94 129.69,94.7 133.55,90.84 133.55,88.95 135.08,87.43 135.08,84.73 138.99,80.81 138.99,78.15 139.67,77.46 139.67,75.06 142.24,72.49 142.24,68.83 146.51,64.57 146.51,53.18 150.51,49.17 152.58,49.17 152.59,49.16 153.16,49.16 v6(153.8,49.8)
DMI_TX_CPU_P0_C: length 41.6
  TOP w0.102: CPU1.AE4 v6(164.5,179.5) ; C1.1 136.35,165.94 136.68,165.94 136.78,165.94 136.78,165.94 v1(137.14,166.31)
  L3 w0.102: v1(137.14,166.31) 137.45,166.01 137.47,166.01 137.48,166.01 138.35,166.01 138.78,166.45 140.29,166.45 144.35,170.5 144.35,173.64 148.18,177.47 150.39,177.47 154.15,181.24 154.15,182.22 155.32,183.39 160.48,183.39 162.33,181.53 162.33,180.77 164,179.1 164.1,179.1 v6(164.5,179.5)
DMI_TX_CPU_P1: length 147.9
  TOP w0.102: PCH1.J5 v6(153.8,48.2) ; v1(134.21,175.23) 133.83,175.62 133.83,175.88 C3.2
  L3 w0.102: v6(153.8,48.2) 153.11,48.9 149.61,48.9 145.59,52.91 142.76,52.91 140.13,55.53 140.13,72.01 132.87,79.27 132.87,80.6 132.97,80.7 132.97,81 132.87,81.1 132.87,82.07 130.91,84.02 130.91,91.14 128.27,93.78 128.27,97.32 125.63,99.96 125.63,109.91 126.49,110.77 126.49,116.23 127.53,117.27 127.53,133.58 129.16,135.2 129.16,167.39 130.94,169.16 130.94,170.33 133.78,173.18 133.78,174.8 v1(134.21,175.23)
DMI_TX_CPU_P1_C: length 50
  TOP w0.102: CPU1.AA5 v6(168.5,177.5) ; v1(134.1,178.63) 133.74,178.27 133.74,177.54 C3.1
  L3 w0.102: v6(168.5,177.5) 168.5,177.78 168.39,177.9 168.08,177.9 167.87,178.1 167.87,179.97 168.2,180.3 168.2,185.24 166.75,186.69 148.98,186.69 143.73,181.43 135.69,181.43 133.68,179.42 133.68,179.05 v1(134.1,178.63)
DMI_TX_CPU_P2: length 155.4
  TOP w0.102: C5.2 135.47,175.89 135.47,175.59 135.13,175.25 v1(135.13,175.23) ; PCH1.L5 v6(153.8,46.6)
  L3 w0.102: v6(153.8,46.6) 153.54,46.86 153.54,46.99 153.03,47.5 149.73,47.5 145.16,52.07 142.39,52.07 139.32,55.14 139.32,71.55 131.78,79.1 131.78,81.79 129.79,83.77 129.79,88.88 127.33,91.35 127.33,97.08 124.82,99.59 124.82,110.26 125.55,111 125.55,116.63 126.72,117.8 126.72,134.34 128.35,135.97 128.35,159.99 128.02,160.32 128.02,171.83 129.67,173.48 130.68,173.48 131.78,174.57 131.78,175.9 132.21,176.33 135.17,176.33 135.48,176.01 135.48,175.59 v1(135.13,175.23)
DMI_TX_CPU_P2_C: length 46.8
  TOP w0.102: v1(135.16,178.7) 135.47,178.39 135.47,177.44 C5.1 ; CPU1.AC6 v6(167.5,177.5)
  L3 w0.102: v1(135.16,178.7) 135.61,179.15 135.61,179.71 136.26,180.37 136.57,180.37 136.67,180.46 136.97,180.46 137.07,180.37 137.38,180.37 137.47,180.46 137.78,180.46 137.88,180.37 138.18,180.37 138.28,180.46 138.59,180.46 138.69,180.37 144.19,180.37 148.04,184.21 148.04,184.35 148.25,184.57 148.39,184.57 148.61,184.79 148.61,184.93 148.82,185.14 148.96,185.14 149.18,185.36 149.18,185.5 149.39,185.71 149.53,185.71 149.75,185.93 166.17,185.93 166.83,185.27 166.83,184.96 166.93,184.86 166.93,184.56 166.83,184.46 166.83,184.16 166.93,184.06 166.93,183.75 166.83,183.65 166.83,183.35 166.93,183.25 166.93,182.94 166.83,182.84 166.83,177.8 167.13,177.5 v6(167.5,177.5)
DMI_TX_CPU_P3: length 153.5
  TOP w0.102: PCH1.N5 v6(153.8,45) ; 127.25,169.37 125.58,169.37 v1(125.22,169.72) ; 127.25,169.37 128.17,169.37 128.8,168.73 131.61,168.73 132.06,169.18 132.06,169.6 132.52,170.05 132.84,170.05 133.11,170.32 C7.2 ; 127.25,169.37 v3(127.25,169.77)
  L3 w0.102: v1(125.22,169.72) 125.58,169.37 126.31,169.37 126.64,169.04 126.64,160.35 127.48,159.51 127.48,136.25 125.91,134.68 125.91,118.58 124.74,117.42 124.74,111.35 124,110.62 124,99.24 126.49,96.75 126.49,90.93 128.75,88.67 128.75,80.8 138.51,71.04 138.51,54.74 142.06,51.18 143.89,51.18 149.37,45.7 153.28,45.7 153.5,45.48 153.5,45.3 v6(153.8,45)
DMI_TX_CPU_P3_C: length 44
  TOP w0.102: v1(136.53,170.5) 136.18,170.15 134.82,170.15 134.65,169.99 134.44,169.99 C7.1 ; CPU1.AD5 v6(165.5,178.5)
  L3 w0.089: 163.85,180.44 163.87,180.43 163.87,180.42 164.19,180.1 164.75,180.1 165.09,179.76 165.09,178.91 v6(165.5,178.5)
  L3 w0.102: v1(136.53,170.5) 136.88,170.14 137.12,170.14 137.67,170.69 137.67,171.75 138.26,172.34 138.6,172.34 138.7,172.44 139,172.44 139.1,172.34 139.41,172.34 139.51,172.44 139.81,172.44 139.91,172.34 141.75,172.34 145.83,176.42 145.83,176.56 146.05,176.77 146.19,176.77 146.4,176.99 146.4,177.13 146.62,177.34 146.76,177.34 146.97,177.56 146.97,177.7 147.19,177.91 147.33,177.91 147.54,178.13 149.85,178.13 151.76,180.04 151.76,181.14 151.92,181.29 151.92,181.7 151.69,181.93 151.69,182.58 152.57,183.46 154.51,183.46 155.14,184.1 160.34,184.1 161.08,183.36 161.09,183.36 163.04,181.41 163.04,181.25 163.85,180.44
DP_AUX_ZVSS: length 13.1
  TOP w0.114: v1(193.47,173.02) 193.47,174.04 194.25,174.82 R25.2 ; CPU1.E12 v6(185.5,171.5)
  L3 w0.114: v1(193.47,173.02) 193.15,172.71 189.6,172.71 188.95,172.06 186.08,172.06 185.52,171.5 v6(185.5,171.5)
  BOTTOM w0.114: v2(192.66,173.23) 193.27,173.23 v1(193.47,173.02)
DP_STEREOSYNC_APU: length 26.2
  TOP w0.114: v6(179.51,168.4) 179.51,168.51 CPU1.K14 ; R32.2 198.87,168.82 v1(198.37,169.32)
  L6 w0.102: v1(198.37,169.32) 198.37,170.31 197.14,171.54 190.89,171.54 189.33,169.98 187.68,169.98 187.17,169.47 180.57,169.47 v6(179.51,168.4)
  BOTTOM w0.114: v1(198.37,169.32) 198.37,168.86 198.81,168.43 v2(198.81,168.43) 199,168.24 R33.1
DP_ZVSS: length 13.6
  TOP w0.114: CPU1.F12 v6(184.5,171.5) ; R24.2 194.89,173.69 194.89,173.61 v1(194.26,172.97)
  L3 w0.114: v1(194.26,172.97) 193.57,172.29 189.81,172.29 188.61,171.09 185.1,171.09 184.68,171.5 v6(184.5,171.5)
  BOTTOM w0.114: v2(194.56,173.86) 194.26,173.56 v1(194.26,172.97)
DPLVDS_PWMIN: length 385.7
  TOP w0.114: R2559.2 200.05,178.82 199.76,179.1 v1(199.76,180.29) 200.74,180.29 201.5,181.06 R2742.1 199.53,183.59 Q77.D ; LAUOC1.14 v1(129.75,8.03)
  L4 w0.114: v1(142.9,198.34) 144.43,196.81 144.43,191.85 137.87,185.29 129.3,185.29 118.14,174.13 118.14,159.03 117.71,158.6 v1(117.71,158.14) 118.04,158.14 118.72,157.45 118.72,147.62 117.37,146.28 117.37,138.63 116.54,137.79 116.54,132.77 115.87,132.11 115.87,112.85 113.89,110.87 113.89,101.42 106.43,93.95 106.43,88.37 104.26,86.21 104.26,82.45 105.16,81.56 105.16,80.95 100.93,76.72 100.93,68.89 102.32,67.49 102.32,65.99 108.13,60.19 108.42,60.19 108.93,59.68 108.93,59.21 108.94,59.21 108.94,58.32 112.5,54.77 112.5,51.05 110.93,49.49 110.93,48.35 110.74,48.16 110.74,47.02 110.01,46.28 109.37,46.28 106.08,42.99 106.08,42.87 105.16,41.94 105.16,40.84 101.1,36.79 101.1,36.46 99.08,34.44 95.51,34.44 94.56,33.48 94.56,21.17 94.75,20.98 94.75,20.57 98.35,16.98 98.35,15.21 105.87,7.69 109.78,7.69 110.93,6.54 113.54,6.54 113.68,6.67 121.44,6.67 122.11,7.34 129.06,7.34 v1(129.75,8.03)
  L6 w0.102: v1(199.76,180.29) 199.76,182 198.2,183.57 198.2,187.41 198.2,190.55 191.52,197.23 157.3,197.23 155.95,195.88 145.57,195.88 143.11,198.34 v1(142.9,198.34)
  BOTTOM w0.114: R2579.2 82.96,161.54 86.89,161.54 87.68,162.33 91.18,162.33 91.51,161.99 91.88,161.99 92.37,161.51 92.37,159.86 94.85,157.38 94.85,157.37 96.39,155.83 99.31,155.83 101.22,157.73 107.41,157.73 110.77,161.09 112.99,161.09 v5(113.45,161.55) 113.65,161.75 115.08,161.75 117.7,159.13 117.7,158.14 v1(117.71,158.14)
DPLVDS_PWMIN_CPU: length 32.8
  TOP w0.114: CPU1.H12 v6(182.5,171.5) ; Q77.S 199.18,180.74 R2744.1 199.16,178.51 R2559.1 199.16,170.79 v1(199.64,170.31)
  L3 w0.114: v6(182.5,171.5) 183.06,170.94 184.66,170.94 184.91,170.69 184.91,170.54 185.81,169.63 189.45,169.63 191.12,171.31 191.18,171.31 191.32,171.45 198.5,171.45 v1(199.64,170.31)
  BOTTOM w0.114: v2(198.89,170.01) 199.35,170.01 v1(199.64,170.31)
DQA0_0: length 27
  TOP w0.13: VRAMA1.A11 108.9,191.15 110.16,189.89 110.16,188.98 110.09,188.91 110.09,188.12 109.02,187.05 109.02,186.23 107.77,184.99 94.11,184.99 93.7,185.4 GPU1.U43
DQA0_1: length 26.5
  TOP w0.13: GPU1.U41 87.34,185.84 93.64,185.84 94.03,185.45 103.35,185.45 103.51,185.6 103.73,185.6 103.86,185.48 107.27,185.48 108.6,186.8 108.6,187.06 109.84,188.3 109.84,188.45 109.86,188.46 109.86,188.81 109.84,188.82 109.84,188.85 109.09,189.6 108.9,189.6 VRAMA1.A13
DQA0_2: length 28.3
  TOP w0.13: GPU1.U40 86.76,186.16 89.72,186.16 89.88,186.32 93.72,186.32 94.28,185.75 96.01,185.75 96.49,186.23 103.89,186.23 104.37,185.75 106.68,185.75 107.52,186.59 107.52,186.64 107.98,187.1 108,187.1 108.8,187.9 108.8,188.35 108.5,188.65 108.5,190.8 VRAMA1.B11
DQA0_3: length 23.4
  TOP w0.13: VRAMA1.B13 107.7,189.2 107.7,188.55 107.78,188.47 107.78,187.95 106.18,186.36 105.31,186.36 105.18,186.49 96.39,186.49 95.89,185.98 94.48,185.98 93.71,186.76 89.96,186.76 89.66,187.06 88.26,187.06 GPU1.R42
DQA0_4: length 20.1
  TOP w0.13: VRAMA1.E13 105.49,189.39 105.3,189.2 105.3,188.62 105.22,188.54 105.22,188.08 104.68,187.54 96.29,187.54 95.33,188.5 92.92,188.5 92.79,188.37 91.18,188.37 91.09,188.46 88.46,188.46 GPU1.P42
DQA0_5: length 18.1
  TOP w0.13: VRAMA1.F13 104.5,189.2 104.5,188.62 104.22,188.34 104.22,188.33 104.22,188.33 104.22,188.11 103.96,187.86 103.61,187.86 103.54,187.92 96.28,187.92 95.03,189.17 94.06,189.17 93.91,189.02 92.59,189.02 92.42,188.85 88.85,188.85 GPU1.M43
DQA0_6: length 20.5
  TOP w0.13: VRAMA1.F11 104.5,191.6 103.98,191.6 103.7,191.88 103.7,192.24 103.07,192.87 95.83,192.87 93.57,190.61 92.68,190.61 91.53,189.46 87.36,189.46 GPU1.M41
DQA0_7: length 22.5
  TOP w0.13: VRAMA1.E11 105.46,191.44 105.28,191.62 105.28,192.22 104.39,193.1 95.2,193.1 93.05,190.96 92.66,190.96 91.81,190.1 90.22,190.1 89.88,189.76 86.76,189.76 GPU1.M40
DQA0_8: length 22.4
  TOP w0.13: VRAMA1.E2 106.12,197.98 106.12,195.23 105.24,194.35 94.34,194.35 94.08,194.09 91.39,191.4 GPU1.J43
DQA0_9: length 20.9
  TOP w0.13: GPU1.J42 88.4,192 91.14,192 93.89,194.75 104.87,194.75 105.27,195.15 105.27,196.37 VRAMA1.E4
DQA0_10: length 18.9
  TOP w0.13: VRAMA1.F4 104.48,196.38 104.48,195.57 103.93,195.03 95.07,195.03 94.52,195.58 94.05,195.58 91.07,192.6 GPU1.H43
DQA0_11: length 23.3
  TOP w0.13: GPU1.H41 87.34,193.04 90.67,193.04 95.13,197.5 95.13,199.09 96.17,200.13 97.35,200.13 97.46,200.03 99.58,200.03 99.6,200.04 99.95,200.04 99.96,200.03 104.1,200.03 104.49,199.63 104.49,198.82 104.65,198.65 VRAMA1.F2
DQA0_12: length 26.1
  TOP w0.13: GPU1.F41 87.66,194.56 88.99,194.56 89.34,194.91 89.34,195.32 92.66,198.64 93.02,198.64 95.24,200.86 106.79,200.86 107.68,199.98 107.68,198.82 VRAMA1.B2
DQA0_13: length 26.8
  TOP w0.13: GPU1.E43 88.7,195.37 92.82,199.48 93.25,199.48 95.17,201.4 107.4,201.4 108.52,200.28 108.52,197.22 108.35,197.05 VRAMA1.B4
DQA0_14: length 28.3
  TOP w0.13: GPU1.C43 88.7,197.01 93.96,202.26 107.9,202.26 109.86,200.3 109.86,197.76 109.09,196.99 VRAMA1.A4
DQA0_15: length 27
  TOP w0.13: VRAMA1.A2 109.63,199.13 109.63,200.08 107.7,202.01 94.61,202.01 92.42,199.81 88.81,196.2 GPU1.D42
DQA0_16: length 17.9
  TOP w0.13: v6(84.65,186) 84.65,185.85 GPU1.U38 ; VRAMA1.N13 v6(98.9,189.2)
  L6 w0.089: 98.48,187.8 98.55,187.88 98.55,188.18 98.5,188.23 98.5,188.86 98.84,189.2 v6(98.9,189.2)
  L6 w0.11: v6(84.65,186) 85.07,185.58 86.12,185.58 86.28,185.74 93.73,185.74 95.79,187.8 98.48,187.8
DQA0_17: length 20.4
  TOP w0.13: GPU1.U37 83.85,185.85 v6(83.85,186) ; VRAMA1.M13 v6(100.5,189.2)
  L6 w0.11: v6(83.85,186) 84.59,185.26 93.97,185.26 96.05,187.34 99.44,187.34 100.18,188.08 100.18,188.87 v6(100.5,189.2)
DQA0_18: length 15
  TOP w0.13: v6(84.65,187.2) 84.65,187.05 GPU1.R38 ; v6(96.5,189.99) 96.51,189.99 VRAMA1.T13
  L6 w0.089: v6(96.5,189.99) 96.48,189.98 96.48,189.98 96.1,189.6 95.31,189.6
  L6 w0.11: v6(84.65,187.2) 85.07,186.78 88.84,186.78 89.08,187.02 89.6,187.02 89.86,186.76 92.6,186.76 94.79,188.95 94.79,189.08 95.31,189.6
DQA0_19: length 15.7
  TOP w0.13: GPU1.R36 83.05,187.05 v6(83.05,187.2) ; VRAMA1.U13 v6(95.69,189.19)
  L6 w0.11: v6(95.69,189.19) 92.68,186.17 86.29,186.17 86.02,186.44 83.81,186.44 v6(83.05,187.2)
DQA0_20: length 12.9
  TOP w0.13: VRAMA1.U11 95.68,191.62 v6(95.51,191.62) ; v6(85.55,188.4) 85.55,188.25 GPU1.P39
  L6 w0.11: v6(85.55,188.4) 86.09,188.94 91.25,188.94 94.01,191.7 95.43,191.7 v6(95.51,191.62)
DQA0_21: length 16.7
  TOP w0.13: VRAMA1.T11 v6(97.3,191.6) ; v6(83.85,188.4) 83.85,188.25 GPU1.P37
  L6 w0.11: v6(83.85,188.4) 84.61,189.16 85.72,189.16 85.92,189.36 91.08,189.36 93.95,192.24 96.66,192.24 v6(97.3,191.6)
DQA0_22: length 18.7
  TOP w0.13: v6(84.65,189.6) 84.65,189.45 GPU1.M38 ; VRAMA1.N11 v6(98.9,190.8)
  L6 w0.089: v6(98.9,190.8) 98.8,190.8 98.5,191.1 98.5,191.77 98.57,191.83 98.57,192.35 98.26,192.66
  L6 w0.11: 98.26,192.66 93.78,192.66 90.9,189.78 86.72,189.78 86.47,190.03 85.09,190.03 v6(84.65,189.6)
DQA0_23: length 21.3
  TOP w0.13: GPU1.M37 83.85,189.45 v6(83.85,189.6) ; VRAMA1.M11 v6(100.5,190.8)
  L6 w0.089: 99.85,192.86 100.22,192.49 100.22,191.88 100.1,191.77 100.1,191.19 100.49,190.8 v6(100.5,190.8)
  L6 w0.11: v6(83.85,189.6) 84.6,190.35 86.77,190.35 87.24,190.82 91.35,190.82 93.61,193.08 99.63,193.08 99.85,192.86
DQA0_24: length 17.4
  TOP w0.13: v6(83.05,190.8) 83.05,190.65 GPU1.L36 ; VRAMA1.U2 v6(95.7,198)
  L6 w0.11: v6(83.05,190.8) 83.47,191.22 83.6,191.35 84.05,191.35 84.23,191.53 84.23,192.18 84.5,192.45 85.45,192.45 85.95,192.95 90.13,192.95 93.96,196.78 94.84,197.66 95.36,197.66 v6(95.7,198)
DQA0_25: length 12.7
  TOP w0.13: v6(86.45,192) 86.45,191.85 GPU1.J40 ; VRAMA1.U4 v6(95.7,196.4)
  L6 w0.11: v6(86.45,192) 86.9,192.45 87.61,192.45 87.95,192.11 90.48,192.11 94.75,196.38 95.68,196.38 v6(95.7,196.4)
DQA0_26: length 14.5
  TOP w0.13: GPU1.J39 85.55,191.85 v6(85.55,192) ; v6(96.5,197.2) VRAMA1.T4
  L6 w0.089: v6(96.5,197.2) 96.1,196.8 94.77,196.8
  L6 w0.11: v6(85.55,192) 86.29,192.74 90.71,192.74 94.77,196.8
DQA0_27: length 17.2
  TOP w0.13: v6(83.76,192.02) 83.76,191.76 GPU1.J37 ; VRAMA1.T2 v6(96.5,198.8)
  L6 w0.11: v6(96.5,198.8) 96.15,198.45 94.94,198.45 89.88,193.39 88.89,193.39 88.67,193.61 85.38,193.61 85.1,193.33 85.1,193.07 84.81,192.77 84.51,192.77 v6(83.76,192.02)
DQA0_28: length 18.3
  TOP w0.13: v6(86.45,195.6) 86.45,195.45 GPU1.E40 ; v6(99.7,198.8) VRAMA1.M2
  L6 w0.089: v6(99.7,198.8) 99.7,198.81 99.3,199.21 99.3,199.72 99.35,199.77 99.35,200.18 99.33,200.21
  L6 w0.11: 99.33,200.21 98.64,200.89 95.78,200.89 95.74,200.94 93.98,200.94 90.1,197.06 88.33,197.06 87.57,196.3 87.15,196.3 v6(86.45,195.6)
DQA0_29: length 17
  TOP w0.13: VRAMA1.N2 v6(98.9,198) ; v6(87.35,195.6) 86.9,195.15 GPU1.E41
  L6 w0.089: v6(98.9,198) 98.5,198.4 98.5,200.21 98.25,200.46
  L6 w0.11: 98.25,200.46 94.09,200.46 90.15,196.52 88.27,196.52 v6(87.35,195.6)
DQA0_30: length 21.9
  TOP w0.13: VRAMA1.N4 v6(99.7,197.2) ; GPU1.D39 85.45,196.45 v6(85.6,196.45)
  L6 w0.089: 100.27,199.81 100.27,199.13 100.1,198.97 100.1,197.6 99.7,197.2 v6(99.7,197.2)
  L6 w0.11: v6(85.6,196.45) 86.28,197.13 86.28,197.58 86.55,197.85 87,197.85 87.13,197.72 89.92,197.72 93.5,201.29 95.68,201.29 95.87,201.1 98.97,201.1 100.27,199.81
DQA0_31: length 22.7
  TOP w0.13: v6(100.5,196.4) VRAMA1.M4 ; v6(85.6,197.35) 85.15,196.9 GPU1.C39
  L6 w0.089: 101.02,198.84 100.9,198.72 100.9,197.03 100.5,196.63 v6(100.5,196.4)
  L6 w0.11: v6(85.6,197.35) 86.98,198.73 90.15,198.73 93.03,201.61 95.72,201.61 96.02,201.32 99.08,201.32 100.8,199.59 100.8,199.32 101.02,199.1 101.02,198.84
DQA1_0: length 39.8
  TOP w0.13: GPU1.A41 93.2,205.2 93.2,208.03 98.35,213.18 98.35,213.66 98.35,213.66 98.35,214.59 98.35,214.59 98.35,218.24 98.09,218.5 98.09,225.12 95.27,227.94 92.35,227.94 91.59,227.18 91.58,227.18 VRAMA2.U4
DQA1_1: length 38
  TOP w0.13: GPU1.B40 86.2,198.91 92.7,205.41 92.7,208.24 97.85,213.39 97.85,224.48 97.3,225.03 97.3,225.05 94.85,227.5 93.5,227.5 93.26,227.26 VRAMA2.U2
DQA1_2: length 38.2
  TOP w0.13: VRAMA2.T4 91.7,226.5 93.86,226.5 93.98,226.62 94.1,226.62 94.11,226.62 94.45,226.62 94.46,226.62 94.93,226.62 95.91,225.64 95.91,225.5 97.54,223.88 97.54,221.84 97.35,221.66 97.35,213.6 92.2,208.45 92.2,205.61 85.29,198.7 GPU1.A39
DQA1_3: length 37.2
  TOP w0.13: GPU1.C38 84.54,197.64 84.54,198.83 85.01,199.3 85.17,199.3 91.7,205.83 91.7,208.66 96.72,213.68 96.72,221.75 96.61,221.86 96.61,222.76 96.73,222.88 96.73,223.61 94.58,225.76 94.11,225.76 94.02,225.68 93.32,225.68 VRAMA2.T2
DQA1_4: length 34.2
  TOP w0.13: GPU1.C36 83.06,197.36 83.06,200.79 89.15,206.88 89.15,209.22 89.15,209.22 89.15,209.7 92.25,212.8 93.52,212.8 94.95,214.22 94.95,222.8 94.55,223.19 94.03,223.19 93.91,223.32 93.28,223.32 VRAMA2.N2
DQA1_5: length 31.4
  TOP w0.13: GPU1.A36 82.6,201.04 88.54,206.98 88.54,209.81 90.58,211.85 90.58,212.06 91.71,213.2 93.57,213.2 94.69,214.33 94.69,221.7 94.56,221.83 94.56,221.89 94.31,222.15 94.25,222.15 93.87,222.52 93.28,222.52 VRAMA2.M2
DQA1_6: length 29.8
  TOP w0.13: VRAMA2.M4 90.91,222.51 90.31,222.51 90.07,222.26 89.96,222.26 89.58,221.88 89.58,218.92 89.75,218.75 89.75,211.88 88.05,210.18 88.05,207.19 82,201.14 82,198.4 GPU1.B35
DQA1_7: length 29.8
  TOP w0.13: VRAMA2.N4 90.98,223.38 90.9,223.3 89.91,223.3 89.35,222.74 89.35,212.33 87.4,210.39 87.4,209.07 87.5,208.97 87.5,207.35 81.4,201.25 GPU1.A35
DQA1_8: length 28.7
  TOP w0.13: VRAMA2.M11 86.08,222.52 86.08,222.03 86.43,221.68 86.85,221.68 87.44,221.09 87.44,213.5 85.6,211.66 85.6,211.1 84.4,209.91 84.4,208.08 80.78,204.45 80.78,203.69 79,201.91 GPU1.A32
DQA1_9: length 31.6
  TOP w0.13: VRAMA2.N11 86.1,223.3 86.72,223.3 87.04,222.98 87.67,222.35 87.67,212.84 85.03,210.2 85.03,208 81.27,204.23 81.27,203.85 79.46,202.04 79.46,197.36 GPU1.C32
DQA1_10: length 35.2
  TOP w0.13: VRAMA2.N13 84.44,224.04 87.17,224.04 87.9,223.32 87.9,212.71 85.7,210.52 85.7,207.96 81.75,204.01 81.75,203.75 79.76,201.76 79.76,196.76 GPU1.D32
DQA1_11: length 29.7
  TOP w0.13: VRAMA2.M13 83.76,223.24 83.12,223.24 82.45,222.58 82.45,212.35 83.56,211.23 83.56,207.94 80.29,204.67 80.29,203.53 80.23,203.47 78.5,201.74 78.5,198.5 GPU1.B30
DQA1_12: length 32.6
  TOP w0.13: VRAMA2.T13 83.86,225.86 83.72,225.72 82.9,225.72 82.89,225.72 82.55,225.72 82.54,225.72 82.4,225.72 81.62,224.94 81.55,224.94 80.98,224.36 80.98,223.77 81.45,223.3 81.45,222.39 81.02,221.96 81.02,209 77.77,205.76 77.77,204.16 77.71,204.1 77.02,203.41 77.02,198.22 GPU1.B29
DQA1_13: length 37.4
  TOP w0.13: GPU1.D27 76.12,196.72 76.12,202.99 77.22,204.1 77.22,205.46 77.29,205.52 77.29,205.98 80.68,209.38 80.68,222.64 80.8,222.76 80.8,222.99 80.37,223.42 80.37,224.66 82.32,226.62 83.04,226.62 83.16,226.5 85.3,226.5 85.38,226.42 VRAMA2.T11
DQA1_14: length 35.5
  TOP w0.13: GPU1.C27 75.84,197.34 75.84,203.2 76.74,204.1 76.74,205.66 76.8,205.72 76.8,206.2 80.09,209.49 80.09,225.24 82.33,227.48 83.53,227.48 83.72,227.28 83.72,227.28 VRAMA2.U13
DQA1_15: length 36.4
  TOP w0.13: GPU1.A27 75.4,203.24 76.25,204.1 76.25,205.86 76.31,205.92 76.31,206.42 79.65,209.76 79.65,226 81.65,228 84.6,228 85.44,227.16 85.44,227.16 VRAMA2.U11
DQA1_16: length 31.9
  TOP w0.13: GPU1.E38 84.25,195.55 v6(84.4,195.55) ; VRAMA2.E4 v6(91.7,217.7)
  L6 w0.1: 92.87,218.09 92.09,218.09 v6(91.7,217.7)
  L6 w0.11: v6(84.4,195.55) 84.81,195.96 84.81,198.65 93.33,207.16 93.33,208.25 95.19,210.11 95.19,217.51 94.37,218.33 93.11,218.33 93.08,218.3 92.87,218.09
DQA1_17: length 36.1
  TOP w0.13: GPU1.H36 v6(83.1,193.1) ; VRAMA2.F4 v6(90.9,218.5)
  L6 w0.1: v6(90.9,218.5) 91.31,218.91 92.11,218.91 92.2,219
  L6 w0.11: 92.2,219 92.83,219 93.13,218.7 94.3,218.7 95.4,217.6 95.4,209.72 93.83,208.15 93.83,207.07 85.12,198.36 85.12,195.69 84.43,195 84.42,195 83.69,194.27 v6(83.1,193.1)
DQA1_18: length 31.1
  TOP w0.13: v6(83.2,194.65) 82.75,194.2 GPU1.F36 ; VRAMA2.F2 v6(93.3,217.7)
  L6 w0.11: v6(83.2,194.65) 83.9,195.35 83.9,198.28 85.16,199.54 85.16,200.33 92.88,208.04 92.88,208.4 94.97,210.5 94.97,217.43 94.28,218.12 93.72,218.12 v6(93.3,217.7)
DQA1_19: length 31.5
  TOP w0.13: GPU1.G35 81.85,193.85 v6(82,193.85) ; VRAMA2.E2 v6(92.5,216.9)
  L6 w0.11: v6(82,193.85) 82.63,194.47 82.63,195.58 83.36,196.32 83.36,198.36 84.74,199.74 84.74,200.5 92.38,208.14 92.38,208.5 94.76,210.89 94.76,216.14 94.37,216.53 93.5,216.53 93.48,216.51 93.14,216.51 93.13,216.53 92.87,216.53 v6(92.5,216.9)
DQA1_20: length 24.3
  TOP w0.13: VRAMA2.A2 v6(92.5,213.7) ; v6(80.8,195.55) 80.35,195.1 GPU1.E33
  L6 w0.11: v6(92.5,213.7) 89.81,211.01 89.81,209.02 81.52,200.74 81.52,198.21 81.22,197.9 81.22,195.97 v6(80.8,195.55)
DQA1_21: length 26.4
  TOP w0.13: VRAMA2.B2 v6(93.3,214.5) ; v6(80.8,194.65) 80.35,194.2 GPU1.F33
  L6 w0.11: v6(93.3,214.5) 92.91,214.11 92.91,213.39 90.23,210.71 90.23,208.85 81.96,200.57 81.96,198.01 81.55,197.61 81.55,195.4 v6(80.8,194.65)
DQA1_22: length 25.1
  TOP w0.13: v6(90.86,213.71) 91.25,214.1 VRAMA2.A4 ; v6(79.6,194.65) 79.45,194.65 GPU1.F32
  L6 w0.11: v6(79.6,194.65) 80.04,195.09 80.04,198.17 80.61,198.75 80.61,199.51 80.67,199.57 80.67,201.07 88.97,209.37 88.97,211.82 v6(90.86,213.71)
DQA1_23: length 27
  TOP w0.13: v6(91.7,214.5) VRAMA2.B4 ; GPU1.G32 79.45,193.85 v6(79.6,193.85)
  L6 w0.11: v6(79.6,193.85) 80.35,194.6 80.35,197.76 81.07,198.48 81.07,200.87 89.39,209.2 89.39,211.41 91.29,213.31 91.29,214.09 v6(91.7,214.5)
DQA1_24: length 31.1
  TOP w0.13: v6(78.4,193.85) 78.25,193.85 GPU1.G30 ; VRAMA2.F11 v6(85.3,218.5)
  L6 w0.1: 86.5,218.1 86.49,218.11 85.69,218.11 v6(85.3,218.5)
  L6 w0.11: 86.5,218.1 86.98,217.62 86.98,209.38 78.74,201.14 78.74,198.65 77.99,197.9 77.99,194.26 v6(78.4,193.85)
DQA1_25: length 30.9
  TOP w0.13: GPU1.J29 76.75,191.8 v6(77.2,192.25) ; VRAMA2.E11 v6(85.3,216.9)
  L6 w0.11: v6(77.2,192.25) 77.68,192.73 77.68,198.13 78.32,198.77 78.32,201.31 86.77,209.76 86.77,216.04 86.31,216.5 85.7,216.5 v6(85.3,216.9)
DQA1_26: length 25.2
  TOP w0.13: GPU1.E29 76.75,195.1 v6(77.2,195.55) ; VRAMA2.B11 86.1,215.3 v6(86.14,215.3)
  L6 w0.11: v6(77.2,195.55) 77.35,195.7 77.35,198.35 77.9,198.91 77.9,201.49 86.56,210.14 86.56,214.89 v6(86.14,215.3)
DQA1_27: length 24.4
  TOP w0.13: v6(86.1,213.47) 86.1,213.7 VRAMA2.A11 ; GPU1.F29 77.05,194.65 v6(77.2,194.65)
  L6 w0.11: v6(77.2,194.65) 77.2,194.97 76.79,195.38 76.79,198.31 77.48,199 77.48,201.66 86.1,210.28 v6(86.1,213.47)
DQA1_28: length 24.8
  TOP w0.13: GPU1.F27 75.85,194.65 v6(76,194.65) ; VRAMA2.B13 v6(83.7,214.5)
  L6 w0.089: 84.11,213.33 84.11,214.1 v6(83.7,214.5)
  L6 w0.11: v6(76,194.65) 75.95,194.7 75.95,202.98 84.11,211.14 84.11,213.33
DQA1_29: length 25.8
  TOP w0.13: GPU1.D26 74.65,196.45 v6(74.8,196.45) ; VRAMA2.E13 v6(83.7,216.9)
  L6 w0.11: v6(74.8,196.45) 74.8,203.02 78.18,206.4 78.18,211.94 82.77,216.54 83.34,216.54 v6(83.7,216.9)
DQA1_30: length 23.2
  TOP w0.13: VRAMA2.A13 v6(83.7,213.7) ; GPU1.E26 74.65,195.55 v6(74.8,195.55)
  L6 w0.11: v6(74.8,195.55) 74.8,195.76 75.23,196.19 75.23,202.86 78.8,206.43 78.8,208.79 v6(83.7,213.7)
DQA1_31: length 30.6
  TOP w0.13: GPU1.G26 74.65,193.85 v6(74.8,193.85) ; VRAMA2.F13 v6(84.5,217.7)
  L6 w0.089: v6(84.5,217.7) 84.13,217.33 83.52,217.33 83.49,217.36 82.46,217.36 82.25,217.15
  L6 w0.11: 82.25,217.15 77.56,212.45 77.56,206.37 75.48,204.3 75.48,204.08 74.39,202.99 74.39,194.26 v6(74.8,193.85)
DQB0_0: length 30.9
  TOP w0.13: VRAMB1.M13 74.77,218.5 v6(74.8,218.5) ; GPU1.K26 74.65,191.45 v6(74.8,191.45)
  L6 w0.1: v6(74.8,218.5) 75.64,218.5
  L6 w0.11: 75.64,218.5 76.59,217.55 76.59,206.81 75.07,205.29 75.07,204.13 74.18,203.24 74.18,192.07 v6(74.8,191.45)
DQB0_1: length 25.1
  TOP w0.13: v6(74.8,216.9) 74.8,216.93 VRAMB1.N13 ; GPU1.E25 73.15,195.1 v6(73.6,195.55)
  L6 w0.11: v6(74.8,216.9) 75.07,216.9 75.36,216.61 75.84,216.61 76.18,216.27 76.18,206.99 74.65,205.47 74.65,204.06 73.69,203.1 73.69,197.12 73.19,196.62 73.19,195.96 v6(73.6,195.55)
DQB0_2: length 21.4
  TOP w0.13: VRAMB1.U13 74.8,213.73 v6(74.8,213.7) ; GPU1.F25 73.45,194.65 v6(73.6,194.65)
  L6 w0.11: v6(73.6,194.65) 72.98,195.27 72.98,197.05 73.41,197.48 73.41,203.14 74.24,203.97 74.24,205.65 74.8,206.21 v6(74.8,213.7)
DQB0_3: length 24.2
  TOP w0.13: v6(73.6,193.05) 73.45,193.05 GPU1.H25 ; v6(74.8,214.53) VRAMB1.T13
  L6 w0.089: 74.34,213 74.4,213.06 74.4,213.87 74.8,214.27
  L6 w0.11: 74.34,213 73.82,212.48 73.82,203.87 72.59,202.64 72.59,195.07 72.99,194.66 72.99,193.66 v6(73.6,193.05) ; 74.8,214.27 v6(74.8,214.53)
DQB0_4: length 23.3
  TOP w0.13: VRAMB1.U11 72.8,213.95 v6(72.36,213.51) ; v6(72.4,192.25) 72.25,192.25 GPU1.J24
  L6 w0.11: v6(72.36,213.51) 71.84,212.99 71.84,203.97 71.78,203.9 71.78,192.87 v6(72.4,192.25)
DQB0_5: length 21
  TOP w0.13: GPU1.D23 71.05,196.45 v6(71.2,196.45) ; v6(72.4,215.3) 72.43,215.3 VRAMB1.T11
  L6 w0.11: v6(72.4,215.3) 71.43,214.33 71.43,198.33 70.79,197.69 70.79,196.86 v6(71.2,196.45)
DQB0_6: length 24.5
  TOP w0.13: VRAMB1.N11 73.2,216.93 v6(73.2,216.9) ; GPU1.E23 71.05,195.55 v6(71.2,195.55)
  L6 w0.102: v6(73.2,216.9) 73.2,216.9 72.81,216.51 72.03,216.51
  L6 w0.11: v6(71.2,195.55) 70.58,196.17 70.58,197.98 71.01,198.41 71.01,215.49 72.03,216.51
DQB0_7: length 28.4
  TOP w0.13: VRAMB1.M11 73.17,218.5 v6(73.2,218.5) ; GPU1.G23 71.05,193.85 v6(71.2,193.85)
  L6 w0.102: 71.15,217.96 71.32,218.13 72.69,218.13 73.05,218.5 v6(73.2,218.5)
  L6 w0.11: v6(71.2,193.85) 70.37,194.68 70.37,203.69 70.6,203.92 70.6,217.41 71.15,217.96
DQB0_8: length 21.5
  TOP w0.13: GPU1.E21 68.95,195.55 v6(68.8,195.55) ; v6(66.81,214.51) 66.81,214.54 VRAMB1.T4
  L6 w0.11: v6(68.8,195.55) 68.8,196.61 68.41,197 68.41,203.6 68.82,204.01 68.82,211.72 67.2,213.34 67.2,213.88 66.81,214.27 v6(66.81,214.51)
DQB0_9: length 24.4
  TOP w0.13: v6(67.6,192.25) 67.75,192.25 GPU1.J20 ; VRAMB1.U4 67.61,213.72 v6(67.61,213.7)
  L6 w0.11: v6(67.61,213.7) 69.23,212.08 69.23,204.01 69.18,203.95 69.18,197.86 69.23,197.81 69.23,195.4 68.9,195.07 68.63,195.07 68.39,194.83 68.39,193.04 v6(67.6,192.25)
DQB0_10: length 22.6
  TOP w0.13: v6(66.02,213.62) 66.02,213.71 VRAMB1.U2 ; GPU1.G20 67.75,193.85 v6(67.6,193.85)
  L6 w0.11: v6(67.6,193.85) 68.18,194.43 68.18,194.92 68.22,194.96 68.22,194.97 68.26,195.01 68.26,195.84 68.22,195.88 68.22,196.17 68.2,196.19 68.2,203.74 68.4,203.95 68.4,211.23 v6(66.02,213.62)
DQB0_11: length 22.9
  TOP w0.13: v6(67.6,194.65) 67.75,194.65 GPU1.F20 ; v6(65.2,214.53) VRAMB1.T2
  L6 w0.11: v6(67.6,194.65) 68.05,195.1 68.05,195.75 67.99,195.81 67.99,203.83 67.99,209.87 64.79,213.07 64.79,213.87 65.2,214.28 v6(65.2,214.53)
DQB0_12: length 26.1
  TOP w0.13: GPU1.E19 66.55,195.55 v6(66.4,195.55) ; v6(66,216.9) 66,216.93 VRAMB1.N2
  L6 w0.089: 65.98,216.9 v6(66,216.9)
  L6 w0.11: 65.98,216.9 65.63,216.55 64.63,216.55 64.58,216.51 63.64,216.51 63.47,216.34 63.47,212.24 65.96,209.75 65.96,203.94 66.01,203.89 66.01,198.96 66.4,198.57 v6(66.4,195.55)
DQB0_13: length 27.1
  TOP w0.13: v6(66.4,194.65) 66.55,194.65 GPU1.F19 ; v6(65.2,217.7) 65.2,217.73 VRAMB1.M2
  L6 w0.11: v6(66.4,194.65) 65.99,195.06 65.99,196.17 66.03,196.22 66.03,198.63 65.8,198.87 65.8,203.73 65.55,203.97 65.55,209.6 63.26,211.88 63.26,216.72 63.88,217.33 64.83,217.33 v6(65.2,217.7)
DQB0_14: length 28.9
  TOP w0.13: GPU1.E18 65.35,195.55 v6(65.2,195.55) ; VRAMB1.N4 66.83,217.7 v6(66.8,217.7)
  L6 w0.089: 63.94,218.22 64.91,218.22 65.03,218.1 66.17,218.1 66.57,217.7 v6(66.8,217.7)
  L6 w0.11: 63.94,218.22 63.05,217.34 63.05,211.4 65.13,209.32 65.13,203.97 65.58,203.52 65.58,198.78 65.82,198.54 65.82,196.49 65.2,195.86 v6(65.2,195.55)
DQB0_15: length 29.4
  TOP w0.13: VRAMB1.M4 67.57,218.5 v6(67.6,218.5) ; GPU1.D18 65.35,196.45 v6(65.2,196.45)
  L6 w0.089: v6(67.6,218.5) 67.37,218.5 66.97,218.9 63.97,218.9
  L6 w0.11: 63.97,218.9 62.84,217.77 62.84,211.03 64.72,209.15 64.72,204.08 65.37,203.43 65.37,198.69 65.61,198.46 65.61,196.86 v6(65.2,196.45)
DQB0_16: length 29.2
  TOP w0.13: VRAMB1.E4 67.2,223.73 67.65,223.28 68.14,223.28 68.16,223.26 68.7,223.26 69.33,222.64 69.33,213.83 68,212.5 68,208.89 68.07,208.82 68.07,199.97 67.78,199.68 67.78,197.32 GPU1.C20
DQB0_17: length 29.7
  TOP w0.13: VRAMB1.E2 65.99,224.12 68.77,224.12 69.65,223.25 69.65,213.45 68.72,212.52 68.72,209.06 68.63,208.97 68.63,199.83 68.2,199.4 GPU1.A20
DQB0_18: length 29.3
  TOP w0.13: GPU1.D20 67.55,196.65 67.55,203.91 67.58,203.94 67.58,206.78 67.58,206.78 67.58,210.29 67.4,210.47 67.4,211.1 67.11,211.39 67.11,212.31 68.98,214.18 68.98,221.76 68.27,222.48 67.65,222.48 VRAMB1.F4
DQB0_19: length 28
  TOP w0.13: VRAMB1.F2 65.15,222.48 64.37,222.48 63.93,222.05 63.93,215.43 63.94,215.42 63.94,215.07 63.94,215.07 63.94,213.84 67.06,210.72 67.06,208.91 67.09,208.87 67.09,206.58 67.1,206.58 67.1,203.87 67.05,203.83 67.05,200.41 66.58,199.94 66.58,198.22 GPU1.B19
DQB0_20: length 31.3
  TOP w0.13: VRAMB1.B2 65.17,225.7 64.64,225.7 64.62,225.68 64.08,225.68 62.87,224.46 62.87,209.88 64.53,208.22 64.53,207.94 64.53,203.92 65.1,203.35 65.1,198.5 GPU1.B18
DQB0_21: length 32.9
  TOP w0.13: GPU1.A17 64.6,202.91 64.34,203.17 64.34,203.17 64.05,203.46 64.05,207.74 62.64,209.15 62.64,219.99 62.23,220.4 62.23,223.11 62.64,223.52 62.64,225.12 62.97,225.45 62.99,225.45 64.06,226.52 64.41,226.52 64.42,226.52 66.8,226.52 67.19,226.13 VRAMB1.B4
DQB0_22: length 34.5
  TOP w0.13: GPU1.C17 64.11,197.39 64.11,203.04 63.56,203.59 63.56,207.54 61.62,209.48 61.62,223.98 62.03,224.38 62.03,225.36 64.05,227.38 65.15,227.38 VRAMB1.A2
DQB0_23: length 38.2
  TOP w0.13: GPU1.D17 63.86,196.74 63.86,202.68 63.08,203.46 63.08,207.34 61.29,209.12 61.29,225.59 63.62,227.92 66.21,227.92 67.2,226.93 VRAMB1.A4
DQB0_24: length 33.5
  TOP w0.13: GPU1.A26 74.4,198.9 74.4,203.18 75.28,204.06 75.28,206.26 75.34,206.32 75.34,206.86 78.54,210.06 78.54,225.07 76.14,227.47 74.94,227.47 VRAMB1.A13
DQB0_25: length 37.1
  TOP w0.13: GPU1.B26 74.9,198.5 74.9,203.23 75.77,204.1 75.77,206.06 75.83,206.12 75.83,206.64 78.87,209.68 78.87,225.63 77.38,227.12 76.63,227.87 73.74,227.87 VRAMB1.A11
DQB0_26: length 36.2
  TOP w0.13: VRAMB1.B11 73.17,226.5 75.48,226.5 75.6,226.62 76.08,226.62 76.95,225.75 76.95,225.67 78.18,224.43 78.18,221.24 77.93,220.98 77.93,210.16 74.86,207.08 74.86,206.52 74.8,206.46 74.8,203.91 73.72,202.83 73.72,197.62 GPU1.C25
DQB0_27: length 32.3
  TOP w0.13: GPU1.B25 73.44,198.24 73.44,202.88 74.31,203.75 74.31,206.66 74.37,206.72 74.37,207.31 77.29,210.23 77.29,222.35 77.55,222.61 77.55,224.27 77.03,224.79 76.05,225.78 75.53,225.78 75.45,225.7 74.83,225.7 VRAMB1.B13
DQB0_28: length 28.4
  TOP w0.13: VRAMB1.E13 74.8,223.33 74.8,223.3 75.38,223.3 75.46,223.22 75.92,223.22 76.38,222.76 76.38,212.92 73.85,210.39 73.84,210.39 73.83,210.38 73.83,210.37 71.85,208.39 71.85,207.77 71.79,207.71 71.79,203.88 71.8,203.86 GPU1.A24
DQB0_29: length 25.8
  TOP w0.13: VRAMB1.F11 72.4,222.52 72.4,222.01 72.11,221.72 71.72,221.72 71.12,221.12 71.12,218.94 71.6,218.46 71.6,211.45 71.09,210.95 71.09,209.93 70.88,209.71 70.88,208.17 70.8,208.09 70.8,198.9 GPU1.A23
DQB0_30: length 28.5
  TOP w0.13: GPU1.B23 71.3,198.5 71.3,207.91 71.36,207.97 71.36,208.76 74.42,211.82 74.42,211.82 74.81,212.21 74.81,212.21 76.08,213.47 76.08,221.98 75.84,222.22 75.66,222.22 75.38,222.5 74.8,222.5 74.8,222.53 VRAMB1.F13
DQB0_31: length 29.8
  TOP w0.13: VRAMB1.E11 72.35,223.27 71.78,223.27 70.71,222.21 70.71,218.69 71.1,218.3 71.1,212 70.39,211.29 70.39,208.37 70.3,208.28 70.3,199.4 70.02,199.12 70.02,196.62 GPU1.D21
DQB1_0: length 33.2
  TOP w0.13: VRAMB2.F4 v6(53.9,218.5) ; v6(65.2,193.85) 65.35,193.85 GPU1.G18
  L6 w0.089: 57.31,218.74 57.15,218.9 54.43,218.9 54.03,218.5 v6(53.9,218.5)
  L6 w0.11: v6(65.2,193.85) 64.76,194.29 64.76,203.63 64.31,204.08 64.31,206.74 59.76,211.29 59.76,216.29 57.31,218.74
DQB1_1: length 32.5
  TOP w0.13: VRAMB2.E4 v6(54.7,217.7) ; GPU1.H18 65.35,193.05 v6(65.2,193.05)
  L6 w0.089: 57.2,218.21 56.9,218.21 56.78,218.1 55.1,218.1 v6(54.7,217.7)
  L6 w0.11: 57.2,218.21 59.34,216.07 59.34,209.34 63.89,204.79 63.89,204.08 64.44,203.53 64.44,193.81 v6(65.2,193.05)
DQB1_2: length 28.2
  TOP w0.13: GPU1.F17 64.15,194.65 v6(64,194.65) ; VRAMB2.F2 v6(56.3,217.7)
  L6 w0.089: 57.99,216.94 57.61,217.31 56.75,217.31 56.37,217.7 v6(56.3,217.7)
  L6 w0.11: 57.99,216.94 58.92,216.01 58.92,209.17 63.48,204.61 63.48,203.97 64.02,203.42 64.02,198.18 64,198.16 v6(64,194.65)
DQB1_3: length 29.2
  TOP w0.13: GPU1.G17 64.15,193.85 v6(64,193.85) ; VRAMB2.E2 v6(55.5,216.9)
  L6 w0.089: v6(55.5,216.9) 55.59,216.9 55.99,216.5 57.77,216.5 57.96,216.31
  L6 w0.11: v6(64,193.85) 63.59,194.26 63.59,198.81 63.81,199.03 63.81,203.22 63.06,203.97 63.06,204.33 62.67,204.72 58.5,208.89 58.5,215.77 57.96,216.31
DQB1_4: length 24.3
  TOP w0.13: v6(56.29,214.5) 56.28,214.52 56.27,214.52 55.9,214.89 VRAMB2.B2 ; v6(62.8,194.65) 62.95,194.65 GPU1.F15
  L6 w0.089: 55.91,212.57 55.91,214.11 v6(56.29,214.5)
  L6 w0.11: v6(62.8,194.65) 62.39,195.06 62.39,195.72 62.48,195.81 62.48,198.56 62.28,198.76 62.28,202.07 55.91,208.44 55.91,212.57
DQB1_5: length 25.1
  TOP w0.13: v6(62.8,193.05) 62.95,193.05 GPU1.H15 ; VRAMB2.A2 55.63,213.83 55.63,213.12 v6(55.48,212.98)
  L6 w0.11: v6(55.48,212.98) 55.48,208.16 61.92,201.72 61.92,198.35 62.26,198 62.26,196.06 62.18,195.98 62.18,193.67 v6(62.8,193.05)
DQB1_6: length 21.8
  TOP w0.13: v6(61.6,196.45) 61.75,196.45 GPU1.D14 ; VRAMB2.A4 54.28,214.1 v6(53.89,213.7)
  L6 w0.11: v6(53.89,213.7) 54.08,213.51 54.08,212.52 54.13,212.47 54.13,208.29 61.18,201.24 61.18,196.87 v6(61.6,196.45)
DQB1_7: length 23.9
  TOP w0.13: VRAMB2.B4 v6(54.7,214.5) ; v6(61.6,195.55) 61.75,195.55 GPU1.E14
  L6 w0.089: 54.58,212.32 54.3,212.6 54.3,214.17 54.63,214.5 v6(54.7,214.5)
  L6 w0.11: v6(61.6,195.55) 61.6,195.85 62.05,196.3 62.05,197.71 61.55,198.21 61.55,201.49 54.86,208.17 54.86,212.04 54.58,212.32
DQB1_8: length 33.2
  TOP w0.13: VRAMB2.F11 v6(48.3,218.5) ; GPU1.J12 60.55,192.25 v6(60.4,192.25)
  L6 w0.089: 50.01,217.73 49.64,218.1 49.27,218.1 48.7,218.1 48.3,218.5 v6(48.3,218.5)
  L6 w0.11: 50.01,217.73 50.01,217.73 51.94,215.8 51.94,207.82 59.38,200.39 59.38,199.14 59.99,198.54 59.99,192.66 v6(60.4,192.25)
DQB1_9: length 25.3
  TOP w0.13: GPU1.E11 59.35,195.55 59.23,195.55 v6(59.22,195.57) ; VRAMB2.B11 v6(49.1,215.3)
  L6 w0.11: v6(59.22,195.57) 59.22,197.94 58.6,198.56 58.6,199.97 51.08,207.49 51.08,213.32 v6(49.1,215.3)
DQB1_10: length 28.9
  TOP w0.13: v6(59.2,194.65) 59.35,194.65 GPU1.F11 ; VRAMB2.E11 v6(48.3,216.9)
  L6 w0.089: 49.44,216.5 48.7,216.5 v6(48.3,216.9)
  L6 w0.11: 49.44,216.5 51.51,214.43 51.51,207.65 58.98,200.18 58.98,198.92 59.63,198.27 59.63,195.08 v6(59.2,194.65)
DQB1_11: length 26.2
  TOP w0.13: v6(49.1,213.49) 48.7,213.89 VRAMB2.A11 ; GPU1.H11 59.65,192.6 v6(59.2,193.05)
  L6 w0.11: v6(49.1,213.49) 49.1,213.49 50.65,211.94 50.65,207.34 58.2,199.78 58.2,198.32 58.72,197.8 58.72,193.53 v6(59.2,193.05)
