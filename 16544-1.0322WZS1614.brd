# Allegro board 16544-1.0322WZS1614.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TP100  TPAD26-OP-GP  [TPAD26-OP]  153.87 165.43 90 bottom
TP101  TPAD26-OP-GP  [TPAD26-OP]  157 182.09 90 bottom
TP102  TPAD26-OP-GP  [TPAD26-OP]  139.78 151.38 90 bottom
TP103  TPAD26-OP-GP  [TPAD26-OP]  147.8 163.88 90 bottom
TP104  TPAD26-OP-GP  [TPAD26-OP]  154.05 169.14 90 bottom
TP105  -  [TPAD30]  114.25 140.39 0 top
TP106  -  [TPAD30]  115.54 140.39 0 top
TP107  TPAD26-OP-GP  [TPAD26-OP]  78.64 179.41 180 bottom
TP108  TPAD26-OP-GP  [TPAD26-OP]  78.51 178.13 180 bottom
TP109  TPAD26-OP-GP  [TPAD26-OP]  79.34 176.97 180 bottom
TP110  TPAD26-OP-GP  [TPAD26-OP]  78.66 175.87 180 bottom
TP111  -  [TPAD30]  99.09 203.3 180 top
TP112  TPAD26-OP-GP  [TPAD26-OP]  78.77 180.69 0 bottom
TP113  TPAD26-OP-GP  [TPAD26-OP]  153.37 161.21 180 bottom
TP114  -  [TPAD30]  192.69 57.41 0 top
TP115  -  [TPAD30]  194.16 57.36 0 top
TP117  -  [TPAD30]  101.35 23.62 0 top
TP118  -  [TPAD30]  8.21 200.32 0 top
TP119  -  [TPAD30]  127.61 127.48 270 top
TP120  TPAD26-OP-GP  [TPAD26-OP]  119.08 212.81 180 bottom
TP121  -  [TPAD30]  116.83 140.37 0 top
TP122  -  [TPAD30]  111.9 140.66 90 top
TP123  -  [TPAD30]  113.13 141 180 top
TP125  TPAD26-OP-GP  [TPAD26-OP]  22.54 164.26 180 bottom
TP126  -  [TPAD30]  49.87 210.74 0 top
TP127  -  [TPAD30]  39.27 165.79 0 top
TP128  TPAD26-OP-GP  [TPAD26-OP]  73.07 227.47 180 bottom
TP129  TPAD26-OP-GP  [TPAD26-OP]  48.39 227.71 180 bottom
TP130  -  [TPAD30]  72.31 210.85 0 top
TP131  -  [TPAD30]  60.87 157.3 0 top
TP132  TPAD26-OP-GP  [TPAD26-OP]  58.82 140.27 180 bottom
TP133  -  [TPAD30]  84.26 210.71 0 top
TP134  TPAD26-OP-GP  [TPAD26-OP]  21.75 202.07 180 bottom
TP135  -  [TPAD30]  112.14 192.97 0 top
TP136  TPAD26-OP-GP  [TPAD26-OP]  85.38 227.72 180 bottom
TP137  -  [TPAD30]  39.22 200.24 0 top
TP138  -  [TPAD30]  92.8 189.77 0 top
TP139  -  [TPAD30]  39.25 177.68 0 top
TP140  TPAD26-OP-GP  [TPAD26-OP]  21.78 177.42 180 bottom
TP141  TPAD26-OP-GP  [TPAD26-OP]  157.99 179.93 180 bottom
TP2503  TPAD26-OP-GP  [TPAD26-OP]  115.98 74.05 180 bottom
TP2504  TPAD26-OP-GP  [TPAD26-OP]  109.61 75.08 90 bottom
TP2505  TPAD26-OP-GP  [TPAD26-OP]  81.33 175.95 180 bottom
TP2506  TPAD26-OP-GP  [TPAD26-OP]  178.06 51.62 180 bottom
TR1  FILTER-4P-184-GP  [L125100-4P-4H28]  232.21 60.55 90 bottom
TR2  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  183.64 36.65 90 top
TR3  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  185.6 10.59 90 top
TYPEC1  ACES-CON40-11-GP-U  [50398-04071-001]  103 5 180 top
U1  2N7002K-2-GP  [SOT23DGS2D4H44]  164.47 59.94 0 top
U2  NCT7718W-GP  [MSOP8-1H44]  112.67 48.55 180 bottom
U3  NL17SZ08DFT2G-GP  [SC70-5H44]  112.78 78.49 90 top
U4  MX25U6473FM2I-10G-GP  [SOIC8-1H86]  136.57 94.25 90 top
U5  AP2138N-1D5TRG1-GP  [SOT23-2D8-312H58]  125.59 42.42 90 top
U6  ALC3266-CG-GP  [QFN56J7-G4D85H36]  201.68 42.16 180 top
U7  ALC1309-CGT-GP  [QFN56J7-G4D85H36]  212.6 24.64 270 top
U8  ALC1309-CGT-GP  [QFN56J7-G4D85H36]  195.76 25.6 270 top
U10  TPS2546RTER-GP  [QFN16-G1D8-UH32]  222.38 15.75 90 top
U11  G524B1T11U-GP  [SOT-23-5H58]  178.54 8.84 90 bottom
U12  TPS2546RTER-GP  [QFN16-G1D8-UH32]  98.3 42.04 270 top
U13  G524B1T11U-GP  [SOT-23-5H58]  177.39 7.14 0 top
U17  G2042RD1U-GP  [DFN8F3-G2416-1H32]  131.57 203.58 0 top
U18  SIR403EDP-T1-GE3-1-GP  [PPAK-5PH45]  30.58 120.77 270 top
U19  SIR403EDP-T1-GE3-1-GP  [PPAK-5PH45]  30.38 120.76 90 bottom
U20  MMBT3904DW-GP  [SOT-363H44]  205.12 146.33 0 top
U21  SN74AUP1G08DCKR-GP  [SC70-5H44]  215.65 133.1 180 top
U23  CY8C4125LQI-S432-GP  [QFN32G5-G3D6H24]  18.54 137.16 0 top
U24  INA199B1DCKR-GP  [SC70-6H44]  20.7 110.11 90 top
U26  HD3SS3212RKSR-GP-U  [QFN20G4525-G315115-UH40]  121.41 96.9 0 top
U28  MX25V4035FM1I-GP  [SOIC8H69]  118.45 162.9 270 top
U29  6P40089NTGI8-GP  [DFN6J1D4H32]  98.42 152.91 270 top
U33  AP22966DC8-7-GP  [SON14J3020-G2610H32]  138.13 14.45 270 top
U36  AOZ1334DI-01-GP  [DFN8F3-G2517H32]  126.24 198.25 90 top
U38  NC7SB3157P6X-2GP  [UMT6H44]  205.58 155.12 0 top
U39  AP22966DC8-7-GP  [SON14J3020-G2610H32]  143.06 40.47 270 top
U40  2N7002K-2-GP  [SOT23DGS2D4H44]  187.91 33.83 270 top
U41  MAX9892ELT-T-1-GP  [DFN6F2-2H32]  206.12 58.5 180 top
U42  MAX9892ELT-T-1-GP  [DFN6F2-2H32]  211.1 59.41 270 top
U43  2N7002K-2-GP  [SOT23DGS2D4H44]  114.76 86.41 180 top
U44  G524B1T11U-GP  [SOT-23-5H58]  185.29 15.72 90 top
U45  MX25U2033EM1I-12G-GP  [SOIC8H69]  127.94 69.63 0 top
U2505  PCF8563T-5-GP  [SOIC8H69]  113.78 74.07 270 top
U2506  PCF85063TP-1Z-GP  [DFN8G2030-G16-1H32]  112.84 74.61 270 bottom
UC1  SCD1U25V2KX-1-DL-GP  [C402H22]  224.92 20.45 180 top
UC2  SCD1U25V2KX-1-DL-GP  [C402H22]  96.06 37.82 0 top
VRAMA1  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  102.5 194 270 top
VRAMA2  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  88.5 220.5 180 top
VRAMB1  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  70 220.53 0 top
VRAMB2  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  51.5 220.5 180 top
VRAMC1  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  29.5 198.5 90 top
VRAMC2  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  29.5 180 270 top
VRAMD1  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  29.5 161.5 90 top
VRAMD2  MT51J256M32HF-60-A-GP  [BGA170D1214H48]  56 147.5 0 top
WEBCM1  JWT-CON15-11-GP  [A1251WV0-15PS-5E]  231 60.5 90 top
WLAN1  SKT-NGFF75P-92-GP  [40-42191-067011HF]  188 51 90 top
WOOFC1  ACES-CON6-76-GP  [50228-0067N-003]  200 4 0 top
X1  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  139.55 169.57 0 top
X2  XTAL-48MHZ-27-GP-U  [OSC-3225-4P-4H36]  139.04 176.79 270 top
X3  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  172.65 29.91 90 top
X99  XTAL-27MHZ-122-GP  [OSC-3225-4P-4H36]  103.89 152.87 270 top
X100  XTAL-32D768KHZ-91-GP  [SMD49-3215-0713H36]  105.32 75.8 180 top

## Library data of the parts
BT1 = AAA-BAT-034-P06-A-U: tolerance: 062.70001.0021
C1-C8 C195-C202 C521-C584 = C402H22: tolerance: 078.22423.05FD; signal model: 2pins
C17 C18 C209 C210 C640 C641 = C402H22: tolerance: 78.15034.1FLDL
C21 C926 PC115 PC134 = C402H22: tolerance: 78.15134.1FLDL
C22 C23 = C402H22: tolerance: 078.1R074.01FD
C24-C35 C58-C67 C101-C114 C135 C136 C139 C140 C142 C144 C145 C1074 C1081 PC120 PC123 PC124 PC140 = C402H22: tolerance: 078.22423.05FD
C36 C37 C68-C70 C97-C100 = C402H22: tolerance: 78.18134.1FLDL
C38-C57 C71-C96 C115-C134 = C402H22: tolerance: 078.47510.05FD
C138 C1073 = C402-TO0D2H28: tolerance: 078.10610.05FD
C141 C152-C155 C177-C180 C208 C229-C238 C247-C261 C297-C300 C327 C461 C466 C498 C601 C602 C608-C611 C617 C618 C630-C632 C634 C656-C662 C668-C675 C683-C686 C688-C692 C696-C722 C728-C736 C738 C739 C741-C743 C758-C764 C775-C781 C792-C798 C809-C815 C818 C821-C823 C848-C854 C865-C871 C882-C888 C899-C905 C908 C929 C970 C976 C989 C990 C996 C1005 C1108-C1115 C2511 PC128 PC129 PC169 PC177 PC179 PC186 PC232 PC243 PC244 PC269 PC272 PC276 PC307 PC308 PC327 PC328 PC357 PC358 PC365 PC374 PC384 PC417 PC511 = C402H22: tolerance: 78.10523.5FLDL
C143 C147 C150 C172 C174 C175 C663-C667 C676-C682 C687 C693-C695 C723-C726 PC1-PC9 PC11-PC14 PC16-PC42 PC44-PC61 PC63 PC64 = C603H40: tolerance: 78.22610.5BLDL
C148 C149 C173 C176 = C805H54: tolerance: 78.22610.51LLL
C151 C156-C161 C164 C166 C168 C169 C181-C185 C187 C189 C190 C192 C194 C212 C223-C228 C240-C246 C263 C264 C276 C278-C282 C284 C291 C321 C345 C368 C370 C372 C377 C380 C382 C384 C385 C402 C404 C407 C411 C414 C416 C418 C419 C423-C425 C427 C435 C451 C457 C462 C476-C478 C497 C499 C508 C511 C513 C514 C518 C592 C616 C637 C750-C757 C767-C774 C784-C791 C801-C808 C840-C847 C857-C864 C874-C881 C891-C898 C934 C948 C952 C963 C966 C971 C975 C977 C981 C983-C988 C997 C1001 C1009 C1017 C1042 C1043 C1122 C1143 C1144 C1152-C1160 C2515 C2520-C2524 C2526 PC92 PC94 PC103 PC122 PC126 PC127 PC130 PC143 PC145 PC151 PC157 PC166 PC182 PC196 PC209 PC216 PC223 PC228 PC233 PC239 PC277 PC281 PC283 PC285 PC286 PC289-PC291 PC293 PC296 PC297 PC373 PC380 PC388 PC426 PC457 PC484 PC487 PC499-PC505 PC507 UC1 UC2 = C402H22: tolerance: 78.10422.5FLDL
C162 C191 C283 C309 C311 C312 C315 C320 C323 C325 C379 C413 C639 C1010 PC222 PC234 PC372 = C603H36: tolerance: 78.22523.5BLDL
C163 C292 C314 C317 C322 C331 C450 C470 C512 C593 C619 C622 C638 C727 C765 C782 C799 C816 C830-C836 C855 C872 C889 C906 C2513 C2517 PC62 PC65 PC66 PC188 PC193 PC194 PC257 PC260 PC261 PC263 PC266 PC267 PC270 PC271 PC419 PC422 PC423 PC458 PC460 PC461 PC485 PC489 PC490 = C603H36: tolerance: 78.10610.5BLDL
C165 C188 C366 C367 C371 C375 C400 C401 C405 C406 C426 C428 C507 C931 C979 C991 C999 C1145 PC138 PC255 PC310 PC312 PC331 PC332 PC361 PC362 PC371 = C402H22: tolerance: 78.10224.2FLDL
C167 C193 C332 C335 PC274 PC275 PC409 = C603H36: tolerance: 78.47520.5BLDL
C170 = C402H22: tolerance: 78.8R064.1FLDL
C171 C295 C1121 = C402H22: tolerance: 78.22224.2FLDL
C186 = C603H38: tolerance: 78.10610.5BL
C203-C206 C495 C496 C501-C504 C911-C924 C953-C956 C1125-C1140 C1149 C1150 = C402H22: tolerance: 78.10422.5FLDL; signal model: 2pins
C207 C326 C340-C343 C2512 C2516 = C402H22: tolerance: 78.10134.1FLDL
C211 C213-C222 C239 C262 C454 C455 PC189 PC190 PC210-PC215 PC219 PC224-PC227 PC235-PC238 PC317-PC326 PC333-PC342 PC347-PC356 PC366 PC368-PC370 PC375-PC379 PC386 PC389-PC393 PC405-PC408 PC410 = C805H54: tolerance: 78.22610.51LDL
C275 C460 C463 C464 = C402H22: tolerance: 78.10520.5FL
C277 = C603H36: tolerance: 78.22523.5BL
C294 C1151 PC116 PC132 PC231 PC242 PC298-PC301 PC383 = C402H22: tolerance: 78.47124.2FLDL
C301 C318 C336 C434 C436 C468 C475 C500 C509 C961 C962 C964 C965 C1044 C1045 C1141 C1142 C2529-C2531 PC95 PC96 PC98-PC102 PC146-PC148 PC152-PC154 PC158-PC160 PC163-PC165 PC167 PC168 PC172-PC175 PC180 PC181 PC183-PC185 PC217 PC218 PC229 PC230 PC240 PC241 PC247-PC252 PC364 PC381 PC382 PC387 PC396 PC411-PC414 PC424 PC425 PC437-PC440 PC491-PC498 PC508 = C805H58: tolerance: 78.10622.51LDL
C310 C313 C316 C319 C324 C328-C330 C333 C334 C344 C365 C399 C456 C458 C1116 C1117 PC87 PC88 PC97 PC104 PC105 PC149 PC155 PC161 PC170 PC176 PC187 PC246 PC385 = C603H35: tolerance: 78.10424.2BLDL
C337 C1011 C2525 C2527 C2528 C2532-C2534 = C402H22: tolerance: 78.33034.1FLDL
C338 C347-C350 PC67 = C402H22: tolerance: 78.22034.1FLDL
C351 C352 = C603H35: tolerance: 78.27034.1BLDL
C353-C356 C387-C390 = C603H36: tolerance: 78.68124.2BLDL
C357-C360 C391-C394 = C603H36: tolerance: 78.33134.1BLDL
C361-C364 C395-C398 = C603H38: tolerance: 078.22424.05BD
C369 C373 C403 C408 = C805H58: tolerance: 078.22612.051D
C374 C376 C381 C383 C386 C409 C410 C415 C417 C420 C459 C467 C469 PC253 PC262 PC268 PC313 PC314 PC345 PC363 PC418 PC433 PC456 PC486 = C603H36: tolerance: 078.10524.05BD
C378 C412 PC112 PC113 PC208 = C805H54: tolerance: 78.47522.51LDL
C440 = C402H22: tolerance: 78.10523.L2L
C453 = C603H36: tolerance: 78.47523.5BL
C471-C474 = C402H22: tolerance: 78.10324.2FLDL; signal model: 2pins
C493 C494 PC131 = C402H22: tolerance: 78.10034.1FLDL
C510 C653 C925 C947 C1123 C2514 PC141 PC221 PC245 PC278 = C402H22: tolerance: 78.10324.2FLDL
C737 C740 = C402H22: tolerance: 78.12134.1FLDL
C837-C839 = C603H42: tolerance: 078.22613.05B1
C932 C974 C980 C982 C1000 PC106 PC107 PC110 PC111 PC399-PC401 = C805H50: tolerance: 78.10623.51LDL
C1004 C1016 C1146 = C402H22: tolerance: 78.10423.2FL
C1006 = C402H22: tolerance: 78.10423.2FLDL
C1020 PC220 = C402H22: tolerance: 78.22124.2FL
C1124 = C402H22: tolerance: 78.10491.4FLDL
C2509 = C402H22: tolerance: 78.3R974.1FL
C2510 = C402H22: tolerance: 78.4R774.1FL
CPU1 = SKT-BGA1331C564462H225: tolerance: 062.10015.0331
D1 D12 = D402H24: tolerance: 83.05325.AA0
D2 D11 D13 D14 = SOT23-2D4-312H48: tolerance: 75.00054.R7D
D3 D5 = SOD323AKH38: tolerance: 83.00355.D1F
D4 = SOT-23-9H44: tolerance: 75.00040.07D
D6 = SOD523AKH28: tolerance: 83.02015.0AF
D7 = SC70-2D2-312H44: tolerance: 075.00054.0G7D
D8 = DO214AAAK-1121H97: tolerance: 83.P6SMB.KAG
D9 = SOT23-2D4-312H48: tolerance: 75.00099.F7D
D15 D16 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
DCPWR1 = CP3508P1H00-NH-U: tolerance: 020.60107.0204
DIMM1 = 40-42274-26001RHF: tolerance: 062.10011.0B51
DIMM2 = 40-42261-26001RHF-U: tolerance: 062.10011.00P1
DISPC1 DISPC2 TYPEC1 = 50398-04071-001: tolerance: 20.F2037.040
DMIC1 = CI1108M1VR0-NH: tolerance: 020.F0096.0008
F2 F22 F23 = POLYSW-2114H30: tolerance: 069.50001.0031
F3 F21 = POLYSW-4633-UH43: tolerance: 69.50007.A31
FANC1 = P254-1104S0AP-R-W: tolerance: 020.60031.0104
G1 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA1401M40H102: tolerance: 071.R16ME.000U
H1 H3 = GEN8D5X8R5X4D5-8-F-A: tolerance: ZZ.00PAD.BV1
H2 = GEN315R178-8-F-A-1: tolerance: ZZ.00PAD.BR1
H4 H14 = GEN315R138-8-F-A-1: tolerance: ZZ.00PAD.BU1
H5-H12 = HOLE237R158: tolerance: ZZ.0HOLE.011
H15 H16 = HOLE237R95: tolerance: ZZ.00PAD.921
HDD1 = LE18077-Z55D-4F: tolerance: 020.80129.0007
HDT1 = ASP-137098-05-1-U2: tolerance: 20.F1722.020
HS1 = STF256R109H99: tolerance: 34.3NH01.001
IPCC1 = 5P1D241A4-15000D105: tolerance: 21.61794.105
JMP1 = 21S-92-03GB16: tolerance: 021.60308.0203
KBC1 = LQFP128H63: tolerance: 071.00985.000G
L1-L3 = L805H44: tolerance: 68.00335.121
L4 L5 = L20125H44: tolerance: 68.00335.001
L6 L7 L9 L30 L31 = L603H38: tolerance: 68.00230.231
L10-L15 = L603H26: tolerance: 68.00143.331
L16-L23 = L3216H52: tolerance: 68.00084.J81
L24 = L402H22: tolerance: 68.00084.541
L25 L26 = L125100-4P-1H24: tolerance: 68.11500.201; signal model: 4pins1
L27 L28 = L402H22: tolerance: 068.00006.0041
L29 L32 = L603H38: tolerance: 68.00335.141
L33 L34 = L402H24: tolerance: 68.00213.011
LAUOC1 = 51540-04001-W01: tolerance: 20.K0678.040
LPC1 = HL5507F: tolerance: 21.60964.207
OSDC1 = 51530-01001-W01: tolerance: 20.K0642.010
PC108 PC109 PC150 PC156 PC162 PC171 PC178 PC191 PC254 PC509 = C402H22: tolerance: 78.15224.2FLDL
PC114 = C402H22: tolerance: 78.68124.2FLDL
PC117 PC133 = C402H22: tolerance: 78.68034.1FLDL
PC118 PC139 = C402H22: tolerance: 78.22321.2FLDL
PC119 PC142 = C402H22: tolerance: 78.33124.2FLLL
PC121 = C402H22: tolerance: 78.22124.2FLLL
PC125 PC135 PC137 PC279 PC280 PC282 PC284 PC288 PC292 PC294 PC309 PC311 PC329 PC330 PC359 PC360 PC367 PC506 = C603H36: tolerance: 78.22422.2BLDL
PC144 = C402H22: tolerance: 78.82124.2FLLL
PC192 PC397 = C402H22: tolerance: 78.18034.1FLDL
PC195 PC510 = C402H22: tolerance: 078.47322.02FD
PC259 PC265 PC427 PC459 PC488 = C402H22: tolerance: 78.68034.1FL
PC287 PC295 = C402H22: tolerance: 78.47224.2FLDL
PC304 PC306 PC315 PC316 PC344 PC346 = C805H56: tolerance: 78.10622.LAL
PC428 PC432 = C402H22: tolerance: 78.10421.L0L
PC430 PC431 = C603H36: tolerance: 78.47422.5BLDL
PCH1 = BGA583D21H60: tolerance: 071.PROM2.M001
PD1 PD2 = SOD523AKH28: tolerance: 83.R2003.0EF
PG5-PG36 PG38-PG87 PG106-PG127 PG129 PG131-PG138 PG141-PG144 PG147-PG160 PG165-PG170 PG175-PG180 PG185-PG187 PG190-PG199 PG201-PG207 PG209-PG215 PG220-PG227 PG230-PG247 PR72 PR112 PR114 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG145 PG146 PR164 PR275 PR276 PR289 PR290 PR303 PR304 PR314 PR423 R183 R316 R2412-R2414 R2558 R2582 R2668 R2731 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PG161-PG164 PG171-PG174 PG181-PG184 PG188 PG189 PG228 PG229 = GAP-CLOSE-PWR: tolerance: ZZ.CLOSE.011
PL1 PL2 = L109100-2030H138: tolerance: 068.1R510.1061
PL3-PL7 = L112100-2135H158: tolerance: 068.R3610.1061
PL8 = L112100-2135H158: tolerance: 68.R561A.10A
PL10-PL12 PL21 = L686647-127318H119: tolerance: 68.1R01B.10K
PL13 = L686647-127318H119: tolerance: 68.6R81C.10E
PL14-PL20 = L112100-2030H158: tolerance: 068.R1510.1011
PL22 = L7066-1830-UH119: tolerance: 68.R4710.10M
PMBUS1 = A2003WV0-1X3PA-6T: tolerance: 21.61428.103
PQ2 PQ12 Q10 Q14 Q16 Q21 Q26 Q37 Q53 Q55 Q67 Q68 Q78 Q83 U1 U40 U43 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ3 PQ4 PU1 PU2 = PPAK-8PH48: tolerance: 084.04378.0037
PQ5 PQ6 PU4 PU5 = PPAK-8PH48: tolerance: 084.04504.0037
PQ9 PQ10 = SOT23CBE2D4H44: tolerance: 084.03906.0011
PQ11 PU52 Q15 Q25 Q72 Q76 Q81 = SOT-363H44: tolerance: 75.27002.F7C
PR1 PR10-PR17 PR24-PR31 PR61-PR64 PR78 PR84 PR122 PR123 PR126 PR131 PR132 PR135 PR140 PR141 PR144 PR150 PR153 PR159 PR162 PR166 PR207 PR216 PR230 PR234 PR333 PR335 PR338 PR341 PR344 PR346 PR374 PR394 R172 R181 R199 R368 R369 R403 R451 R455 R480-R483 R491 R494 R504 R511 R512 R522 R526 R1201 R2577 R2580 R2627 R2634 R2640-R2643 R2663 R2717 R2752 = R402H16: tolerance: 64.10025.6DL
PR2 PR3 = R402H16: tolerance: 63.8R234.1DL
PR4-PR9 PR18-PR23 = R402H16: tolerance: 64.40225.6DL
PR50 PR70 PR101 PR105 PR186 PR203 PR232 PR324 PR384 PR386-PR391 PR420 R171 R177 R178 R379 R495 R604 R1210 R2715 R2716 R2750 = R402H16: tolerance: 64.10035.6DL
PR53 PR54 PR167 PR188 PR193 PR199 PR318 PR421 R184 = R603H22: tolerance: 64.2R205.55L
PR55 PR56 PR169 PR422 = R805H24: tolerance: 64.2R205.16L
PR57 = R402H16: tolerance: 64.63425.6DL
PR58 = R402H16: tolerance: 64.66525.6DL
PR59 = R402H16: tolerance: 64.68015.6DL
PR60 = R402H16: tolerance: 64.15425.6DL
PR65 R29-R31 R173 R237 R2466 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR66 PR67 PR85-PR87 PR90 PR94 PR96 PR172 PR174 PR201 PR209 PR218 PR235-PR240 PR243 PR245-PR247 PR252-PR254 PR261-PR263 PR265-PR268 PR273 PR274 PR277-PR282 PR287 PR288 PR291-PR296 PR301 PR302 PR305-PR310 PR313 PR315-PR317 PR320 PR326 PR334 PR336 PR337 PR339 PR347-PR349 PR362 PR378 PR393 PR399 PR400 PR404 PR405 PR419 R15 R102-R104 R112 R114 R116 R161 R162 R164 R235 R258 R315 R332 R333 R335 R337 R338 R343 R345 R346 R349 R352 R353 R358 R396 R431-R435 R437 R438 R485 R496 R538 R861 R873 R1218-R1220 R1233 R2416 R2432 R2433 R2437 R2439 R2440 R2454 R2457 R2459 R2472 R2474 R2478 R2479 R2497 R2498 R2500 R2505 R2513 R2514 R2536 R2537 R2539 R2586 R2587 R2600 R2602 R2603 R2614-R2620 R2623 R2624 R2629 R2656 R2657 R2696 R2697 R2700 R2701 R2709-R2711 R2713 R2719 R2729 R2732 R2745 R2748 R2762 R2779 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR68 R260 = R402H16: tolerance: 64.82015.6DL
PR69 PR352 = R402H16: tolerance: 64.28015.6DL
PR71 PR110 PR115 = R402H14: tolerance: 63.10034.1DL
PR73 = R402H16: tolerance: 64.49905.6DL
PR74 PR81 = R402H16: tolerance: 64.41225.6DL
PR75 PR109 = R402H16: tolerance: 64.26115.6DL
PR76 PR111 = R402H16: tolerance: 64.11025.6DL
PR77 PR88 PR99 PR113 = NTC-402H22-U: tolerance: 69.60011.221
PR79 = R402H16: tolerance: 64.78705.6DL
PR80 PR117 R253 = R402H14: tolerance: 64.10005.6DL
PR82 PR97 PR376 = R402H16: tolerance: 64.27425.6DL
PR83 PR92 PR120 PR128 PR137 PR145 PR146 PR154 PR155 PR198 PR200 PR271 PR272 PR285 PR286 PR299 PR300 PR312 PR412 = R805H24: tolerance: 63.2R231.16L
PR89 PR98 = R402H16: tolerance: 64.13335.6DL
PR91 R69 R92 R93 R384 R452 R721 R725 R1225 R2476 R2682 = R402H16: tolerance: 63.33034.1DL
PR95 PR100 = R402H16: tolerance: 64.18225.LDL
PR102 PR104 PR191 PR196 PR210 PR323 PR325 PR345 PR355 PR413-PR418 R98-R100 R111 R113 R115 R160 R182 R204 R232 R244 R277 R286 R314 R324 R325 R342 R357 R374 R412 R436 R439 R1202 R1227-R1230 R2425 R2435 R2461 R2470 R2477 R2506 R2511 R2512 R2515-R2518 R2559 R2579 R2601 R2613 R2625 R2626 R2628 R2659 R2662 R2694 R2695 R2698 R2699 R2708 R2718 R2720-R2728 R2749 R2767-R2771 R2775 R2778 R2784 = R402H16: tolerance: 63.R0034.1DL
PR103 PR202 R2 R6 R32 R33 R84 R90 R107 R108 R117 R118 R442 R476 R484 R487 R489 R490 R634 R635 R638-R640 R642 R663 R665 R678 R679 R682-R684 R686 R707 R709 R2630 = R402H16: tolerance: 64.10015.6DL
PR106 = R402H16: tolerance: 64.16215.6DL
PR107 = R402H16: tolerance: 64.35715.6DL
PR108 = R402H16: tolerance: 64.32425.6DL
PR116 = R402H16: tolerance: 64.76805.6DL
PR118 PR127 PR136 PR147 PR156 = R805H24: tolerance: 63.1R031.16L
PR119 PR130 PR139 PR148 PR157 = R402H16: tolerance: 63.22334.1DL
PR121 PR129 PR138 PR149 PR158 = R1206H28: tolerance: 63.2R232.11L
PR124 PR133 PR142 PR151 PR160 R27 R28 R617 R626 = R402H14: tolerance: 64.10R05.6DL
PR125 PR134 PR143 PR152 PR161 = R805H24: tolerance: 64.36515.16L
PR163 PR424 = R402H16: tolerance: 64.5R105.6DL
PR165 = R402H16: tolerance: 64.17435.6DL
PR168 PR327 = R402H16: tolerance: 64.75035.6DL
PR170 = R402H16: tolerance: 64.15825.6DL
PR171 PR330 PR350 R194 R492 = R402H16: tolerance: 64.20025.6DL
PR184 = R402H16: tolerance: 64.95325.6DL
PR185 = R402H16: tolerance: 64.38315.6DL
PR187 = R402H16: tolerance: 64.30025.6DL
PR189 = R402H16: tolerance: 64.16925.6DL
PR190 PR195 PR208 PR354 PR360 PR398 R313 R323 R341 R356 = R402H16: tolerance: 64.22125.6DL
PR192 PR197 PR321 R81 R2669 = R402H16: tolerance: 64.10045.6DL
PR194 = R402H16: tolerance: 64.44225.6DL
PR204 = R402H16: tolerance: 64.52315.6DL
PR206 PR397 = R402H16: tolerance: 64.47525.6DL
PR212 PR361 PR363 PR392 PR395 = R402H15: tolerance: 64.10025.L0L
PR214 PR342 R559 = R402H16: tolerance: 64.R0005.6DL
PR215 = R402H16: tolerance: 64.39015.6DL
PR217 R1198 = R402H16: tolerance: 64.30015.6DL
PR219 PR220 = R402H16: tolerance: 64.33025.6DL
PR221 = R603H22: tolerance: 63.2R233.15L
PR223-PR225 R24 R233 = R402H16: tolerance: 64.20015.6DL
PR228 = R402H16: tolerance: 64.75R05.6DL
PR229 = R402H16: tolerance: 64.56R05.6DL
PR231 PR406 R251 R603 R2501 R2761 = R402H16: tolerance: 63.22234.1DL
PR233 = R402H16: tolerance: 64.52325.6DL
PR242 PR244 PR248 PR250 PR255 PR257 PR259 R1200 = R402H16: tolerance: 64.15015.6DL
PR249 PR258 = R402H16: tolerance: 64.18005.6DL
PR251 PR256 PR260 PR264 R614 R615 R623 R624 = R402H14: tolerance: 63.10134.1DL
PR319 = R402H16: tolerance: 64.28725.6DL
PR322 = R402H16: tolerance: 64.56225.6DL
PR328 = R402H16: tolerance: 64.26725.6DL
PR340 PR375 PR396 R8 R20-R22 R53 R54 R123 R125 R127 R132 R135 R138 R142 R145 R151 R179 R193 R243 R246 R248 R392 R457 R459 R523 R1217 R1231 R1232 R1235 R2411 R2431 R2692 R2693 R2756 R2758 R2764 R2766 = R402H16: tolerance: 63.10234.1DL
PR359 = R402H16: tolerance: 64.19625.6DL
PR377 = R402H16: tolerance: 64.21525.6DL
PR410 = R2512-27D4-4PH28: tolerance: 064.R0016.090D
PR425 = R402H16: tolerance: 64.21535.6DL
PT1 PT2 = CT7343H75: tolerance: 77.23371.20L
PT3 PT5 = SE361416H182: tolerance: 077.C2271.0061
PT6 PT14 PT25 PT27 PT28 PT41 = SE361414H241: tolerance: 79.47612.3GL
PT7 PT8 PT11 PT12 PT15-PT20 PT29 PT30 PT32 PT33 PT35 PT38 PT39 PT43 = ECAP-100D6D3H375: tolerance: 09.8271V.08L
PT21 = SE361416H237: tolerance: 79.5671V.30L
PT42 = ECAP-100D6D3H375: tolerance: 09.56710.A8L
PT44 = CT7343H83: tolerance: 79.33719.20C
PU3 = QFN20-G1D75H32: tolerance: 074.06575.0A43
PU6 = QFN48J6-G4D55H40: tolerance: 074.62773.0A73
PU7 PU8 PU11 PU12 PU15 PU16 PU19 PU20 PU24 PU25 PU57 = PPAK-8P-1-UH40: tolerance: 084.6R003.0037
PU9 PU10 PU13 PU14 PU17 PU18 PU22 PU23 PU27 PU28 PU58 = PPAK-8P-1-UH40: tolerance: 84.08059.037
PU21 PU26 = DFN8G2-G1710-U1H40: tolerance: 74.06208.A73
PU29 PU48 = QFN20-G1D75H32: tolerance: 074.08231.0073
PU32 = QFN22G4-G2PH42: tolerance: 074.02262.0043
PU33 PU34 = QFN20Z3-G1H36: tolerance: 074.08288.0043
PU35 = DFN12G4030-G360175H34: tolerance: 074.08246.0A43
PU37 PU51 PU53 PU55 PU56 = SOIC8-G3530H63: tolerance: 74.05930.B3D
PU38 = SOIC8-G3530H63: tolerance: 074.05337.0031
PU39 = QFN48J6-G4D55H40: tolerance: 074.69147.0A73
PU40-PU46 = QFN40G6-G3P-2H32: tolerance: 074.99140.0073
PU47 = QFN20Z3-G1D1H36: tolerance: 074.08286.0B43
Q1 Q71 Q77 Q85 = SOT23DGS2D4H48: tolerance: 84.05067.031
Q8 Q36 = SOT23CBE2D4H44: tolerance: 84.T3906.E11
Q9 Q34 = SOT23DGS2D4H48: tolerance: 84.02130.031
Q13 Q22 Q23 Q41-Q44 Q50 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
Q35 = SOT23CBE2D4H44: tolerance: 84.T3904.C11
Q54 = SOT23DGS2D8H50: tolerance: 84.03413.B31
Q75 Q86 = SOT-363H44: tolerance: 075.00138.0A7C
Q80 Q84 Q87 = SOT23DGS2D8H50: tolerance: 84.03409.031
Q82 Q88 = SOT23DGS2D4H44: tolerance: 084.03404.0031
R1 R3 = R402H16: tolerance: 64.19605.6DL
R4 R5 R86 R475 R718 R719 R1213-R1215 = R402H16: tolerance: 64.20005.6DL
R10 R11 = R402H16: tolerance: 64.39R25.6DL
R12 R13 R611 R613 R619 R620 = R402H16: tolerance: 64.40R25.6DL
R14 R2499 = R402H16: tolerance: 64.47005.6DL
R16 R26 R134 R239 R339 R354 R375 R380 R386 R415 R584 R2438 R2680 R2707 R2739 R2743 R2751 R2757 R2765 R2780 R2785 R2786 = R402H16: tolerance: 63.10434.1DL
R17 R23 R34-R37 R39 R40 R43 R44 R52 R55 R56 R70 R79 R80 R82 R83 R121 R124 R128 R130 R131 R153 R163 R336 R347 R351 R359 R367 R385 R388-R390 R393 R399 R414 R416 R421 R430 R440 R443 R456 R458 R464 R722-R724 R2481-R2485 R2491 R2492 R2495 R2589 R2598 R2599 R2604 R2631-R2633 R2661 R2684-R2689 R2706 R2712 R2714 R2733 R2742 R2744 R2746 R2747 R2753-R2755 R2759 R2760 R2763 R2772 R2776 R2777 R2781-R2783 = R402H16: tolerance: 63.10334.1DL
R18 R19 = R402H16: tolerance: 63.30134.1DL
R25 R720 = R402H16: tolerance: 64.15005.6DL
R38 R1129 = R402H16: tolerance: 63.82234.1DL
R45 R2523 = R402H16: tolerance: 63.20634.1DL
R57-R59 = R402H16: tolerance: 63.15334.1DL
R61 R64 R65 R94-R96 R2664-R2666 R2691 = R402H16: tolerance: 63.33034.1DL; signal model: 2pins
R85 = R402H16: tolerance: 64.11825.6DL
R109 R110 R119 R120 = R402H16: tolerance: 64.24005.6DL
R122 R126 R129 R133 R136 R139-R141 R143 R146 R148 R150 R155-R158 R175 = R402H16: tolerance: 63.20434.1DL
R137 R144 = R402H16: tolerance: 63.20234.1DL
R147 R149 R257 = R402H16: tolerance: 63.20334.1DL
R152 R169 = R402H16: tolerance: 64.12125.6DL
R154 R159 R254 R453 R602 R1226 R2671 = R402H16: tolerance: 63.47234.1DL
R170 = R402H16: tolerance: 63.10534.1DL
R191 = R402H16: tolerance: 63.33434.1DL
R228 R1223 R1224 = NTC-603H38: tolerance: 69.60035.041
R230 R391 R417 R454 R2419 R2469 R2522 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
R231 = R402H16: tolerance: 64.18725.6DL
R247 = R402H16: tolerance: 63.10634.1DL
R269 R273 R326 R365 R366 R377 R378 R870 R871 R2581 R2605 R2606 R2667 R2730 R2773 R2774 = R603H22: tolerance: 63.00000.00L
R271 R274 = R603H22: tolerance: 64.10015.55L
R272 R381 = R603H22: tolerance: 63.10333.15L
R275 R278 = R603H22: tolerance: 64.22R05.55L; signal model: 2pins
R282 R291 R294 R2585 R2588 = R603H22: tolerance: 64.10035.55L
R283 R284 = R603H22: tolerance: 64.22015.55L
R289 R290 = R402H16: tolerance: 63.2R234.1DL
R293 = R603H22: tolerance: 64.20035.55L
R297 R298 R301 R302 = R603H22: tolerance: 64.33R05.55L
R304 R305 = R603H22: tolerance: 64.22025.55L
R309-R312 R319-R322 R872 R2738 = R603H22: tolerance: 63.10033.15L
R340 R355 = R402H16: tolerance: 64.51025.6DL
R350 R360 R387 R1197 R2660 = R402H16: tolerance: 64.15025.6DL
R372 R1222 = R402H16: tolerance: 64.24925.6DL
R382 = R603H22: tolerance: 64.56025.55L
R383 = R402H16: tolerance: 63.15234.1DL
R400 = R1206H28: tolerance: 63.10032.11L
R406 R407 R419 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
R478 R479 R2621 R2622 R2636 R2638 = R402H16: tolerance: 64.47015.6DL
R486 R505-R510 R515-R518 R520 R521 R524 R525 R527 R528 R531-R536 R541-R553 R560 R562 R618 R627 R2702 R2740 R2741 = R402H16: tolerance: 63.51234.1DL
R513 R514 = R402H16: tolerance: 64.33R05.6DL
R519 = R402H16: tolerance: 64.51115.6DL
R561 = R402H16: tolerance: 64.33R05.6DL; signal model: 2pins
R563 R2646-R2649 R2676-R2679 = R402H16: tolerance: 63.R0034.1DL; signal model: 2pins
R586 = R805H24: tolerance: 63.R0031.16L
R610 R612 R621 R622 R636 R637 R641 R664 R680 R681 R685 R708 = R402H16: tolerance: 64.12005.6DL
R616 R625 = R402H16: tolerance: 64.49R95.6DL
R628-R633 R661 R662 R672-R677 R705 R706 = R402H16: tolerance: 64.60R45.6DL
R643-R645 R666 R687 R688 R691 R710 = R402H16: tolerance: 64.23715.6DL
R646-R648 R667 R689 R690 R692 R711 = R402H16: tolerance: 64.54915.6DL
R1195 = R402H16: tolerance: 64.39225.6DL
R1196 = R402H16: tolerance: 64.82515.6DL
R2534 = R402H16: tolerance: 64.16225.6DL
R2594-R2596 R2737 = R805H24: tolerance: 64.R2005.36L
R2635 = R402H16: tolerance: 64.49915.6DL
R2637 R2639 = R402H16: tolerance: 63.47334.1DL
R2644 R2645 R2650-R2653 R2672-R2675 R2734 R2735 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: 2pins
R2670 = R402H16: tolerance: 64.10055.6DL
R2690 = R603H22: tolerance: 63.00000.00L; signal model: 2pins
RN1 RN2413 RN2416 = SMD-ARES4H18: tolerance: 66.10236.04L
RN2 = ARES8-CN24H20: tolerance: 66.10236.08L
RN3-RN5 RN7 RN15 RN2415 = ARES2H16: tolerance: 66.22236.04L
RN6 RN16 RN17 RN44 RN45 RN2402 RN2404 RN2405 RN2407 RN2408 RN2412 RN2414 = ARES2H18: tolerance: 66.10336.04L
RN8-RN10 RN12 RN19 RN46 RN2406 = SMD-ARES4H18: tolerance: 66.47236.04L
RN42 RN43 = SMD-ARES4H18: tolerance: 66.33036.04L; signal model: 4pins2
RN48 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN2410 RN2411 = SMD-ARES4H18: tolerance: 66.33036.04L
RPWRC1 = WTB1030PDSHF: tolerance: 020.F0919.0030
RUSBC1 = 111H30-100000-G4-R: tolerance: 020.F0827.0030
SATAP1 = CI2505P1V0B-R0-NH: tolerance: 020.60060.0105
SDRDC1 = 50450-01071-001: tolerance: 020.F0311.0010
SPK1 = 50288-00641-001: tolerance: 020.F0241.0006
SPR1 SPR2 = SPR1337H524: tolerance: 34.4B312.002
SRCON1 = G6179HT0321-001: tolerance: 62.10089.011
SSDC1 = 40-42269-067B12HF: tolerance: 062.10003.0711
SUSBC1 = WTB1024PDSHF: tolerance: 020.F0919.0024
TC2 = CT3528H79: tolerance: 77.21071.07L
TC4 = CT3528H83: tolerance: 77.21571.111
TC5 TC6 = CT7343H87: tolerance: 077.54771.0011
TOUCH1 = A1002WV0-5PS-5E-1: tolerance: 020.F0101.0005
TP1-TP10 TP13-TP17 TP22-TP28 TP31 TP32 TP34 TP39-TP46 TP55-TP64 TP97-TP104 TP107-TP110 TP112 TP113 TP120 TP125 TP128 TP129 TP132 TP134 TP136 TP140 TP141 TP2503-TP2506 = TPAD26-OP: tolerance: ZZ.00PAD.0K1
TP12 TP18-TP21 TP29 TP30 TP33 TP38 TP47-TP52 TP65 TP67-TP96 TP105 TP106 TP111 TP114 TP115 TP117-TP119 TP121-TP123 TP126 TP127 TP130 TP131 TP133 TP135 TP137-TP139 = TPAD30: tolerance: ZZ.PAD30.XXX
TR1 = L125100-4P-4H28: tolerance: 068.01012.2011; signal model: Graser_TR1
TR2 = L125100-4P-1H37: tolerance: 68.01012.201; signal model: Graser_TR2
TR3 = L125100-4P-1H37: tolerance: 68.01012.201; signal model: Graser_TR3
U2 = MSOP8-1H44: tolerance: 74.07718.0B9
U3 = SC70-5H44: tolerance: 73.7SZ08.DAH
U4 = SOIC8-1H86: tolerance: 072.25647.0001
U5 = SOT23-2D8-312H58: tolerance: 74.02138.03B
U6 = QFN56J7-G4D85H36: tolerance: 071.03266.0003
U7 U8 = QFN56J7-G4D85H36: tolerance: 074.01309.0013
U10 = QFN16-G1D8-UH32: tolerance: 74.02546.073; signal model: Graser_U10
U11 U13 U44 = SOT-23-5H58: tolerance: 074.00524.0B9F
U12 = QFN16-G1D8-UH32: tolerance: 74.02546.073; signal model: Graser_U12
U17 = DFN8F3-G2416-1H32: tolerance: 074.02042.0093
U18 U19 = PPAK-5PH45: tolerance: 084.00403.0037
U20 = SOT-363H44: tolerance: 84.M3904.B1F
U21 = SC70-5H44: tolerance: 73.01G08.DHH
U23 = QFN32G5-G3D6H24: tolerance: 071.84125.0A03
U24 = SC70-6H44: tolerance: 074.0199B.007P
U26 = QFN20G4525-G315115-UH40: tolerance: 071.33212.0B03
U28 = SOIC8H69: tolerance: 072.25403.000D
U29 = DFN6J1D4H32: tolerance: 071.40089.0003
U33 U39 = SON14J3020-G2610H32: tolerance: 074.22966.0093
U36 = DFN8F3-G2517H32: tolerance: 074.01334.0093
U38 = UMT6H44: tolerance: 73.03157.D0H
U41 U42 = DFN6F2-2H32: tolerance: 073.09892.0B03
U45 = SOIC8H69: tolerance: 072.25203.000D
U2505 = SOIC8H69: tolerance: 071.08563.000A
U2506 = DFN8G2030-G16-1H32: tolerance: 071.85063.0003
VRAMA1 VRAMA2 VRAMB1 VRAMB2 VRAMC1 VRAMC2 VRAMD1 VRAMD2 = BGA170D1214H48: tolerance: KN.8GB04.007
WEBCM1 = A1251WV0-15PS-5E: tolerance: 020.F0918.0015
WLAN1 = 40-42191-067011HF: tolerance: 062.10007.0391
WOOFC1 = 50228-0067N-003: tolerance: 020.F0420.0006
X1 = SMD49-12H34: tolerance: 082.30003.0301
X2 = OSC-3225-4P-4H36: tolerance: 82.30026.281
X3 = OSC-3225-4P-4H36: tolerance: 82.30020.G71
X99 = OSC-3225-4P-4H36: tolerance: 82.30034.921
X100 = SMD49-3215-0713H36: tolerance: 082.30003.0221

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0402-PAD-1
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0603-PAD
  custom 0.216x0.216 smd: 1(0,0.851) 2(0,-0.673)
0R0805-PAD
  rect 1.397x1.562 smd: 1(0,0.965)
  rect 1.397x1.569 smd: 2(0,-0.965)
5P1D241A4-15000D105
  round 1.27 hole 0.889: 1(-4,0) 2(-2,0) 3(0,0) 4(2,0) 5(4,0)
21S-92-03GB16
  round 1.422 hole 1.016: 1(-2.54,-1.27) 2(-2.54,1.27) 3(0,-1.27) 4(0,1.27) 5(2.54,-1.27) 6(2.54,1.27)
40-42191-067011HF
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(10.35,4.5) 77(-10.35,4.5)
40-42261-26001RHF-U
  round 0.254 hole 1.118 unplated: (-34.4,0)
  round 0.254 hole 1.6 unplated: (34.4,0)
  custom 0.089x0.089 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(-33.8,-12) 262(33.8,-12)
40-42269-067B12HF
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 12(-6.5,-1.725) 13(-6.25,4.725) 14(-6,-1.725) 15(-5.75,4.725) 16(-5.5,-1.725) 17(-5.25,4.725) 18(-5,-1.725) 19(-4.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.505) 77(10.35,4.505)
40-42274-26001RHF
  round 0.254 hole 1.118 unplated: (-34.4,0)
  round 0.254 hole 1.6 unplated: (34.4,0)
  custom 0.089x0.089 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 2.007x3.505 smd: 261(-37.75,-8) 262(37.75,-12)
111H30-100000-G4-R
  rect 0.305x1.295 smd: 1(-7.25,-1.95) 2(-6.75,-1.95) 3(-6.25,-1.95) 4(-5.75,-1.95) 5(-5.25,-1.95) 6(-4.75,-1.95) 7(-4.25,-1.95) 8(-3.75,-1.95) 9(-3.25,-1.95) 10(-2.75,-1.95) 11(-2.25,-1.95) 12(-1.75,-1.95) 13(-1.25,-1.95) 14(-0.75,-1.95) 15(-0.25,-1.95) 16(0.25,-1.95) 17(0.75,-1.95) 18(1.25,-1.95) 19(1.75,-1.95) 20(2.25,-1.95) 21(2.75,-1.95) 22(3.25,-1.95) 23(3.75,-1.95) 24(4.25,-1.95) 25(4.75,-1.95) 26(5.25,-1.95) 27(5.75,-1.95) 28(6.25,-1.95) 29(6.75,-1.95) 30(7.25,-1.95)
  rect 1.194x2.692 smd: 31(-9.65,0) 35(9.65,0)
  rect 2.311x1.295 smd: 32(-6.4,1.95) 33(0,1.95) 34(6.4,1.95)
50228-0067N-003
  rect 0.61x1.549 smd: 1(-2.5,2.525) 2(-1.5,2.525) 3(-0.5,2.525) 4(0.5,2.525) 5(1.5,2.525) 6(2.5,2.525)
  rect 1.194x1.803 smd: 7(-3.8,0) 8(3.8,0)
50288-00641-001
  rect 0.711x3.505 smd: 1(3.75,2) 2(2.25,2) 3(0.75,2) 4(-0.75,2) 5(-2.25,2) 6(-3.75,2)
  rect 1.499x2.311 smd: 7(5.8,0) 8(-5.8,0)
50398-04071-001
  rect 0.305x1.295 smd: 1(-9.75,-1.95) 2(-9.25,-1.95) 3(-8.75,-1.95) 4(-8.25,-1.95) 5(-7.75,-1.95) 6(-7.25,-1.95) 7(-6.75,-1.95) 8(-6.25,-1.95) 9(-5.75,-1.95) 10(-5.25,-1.95) 11(-4.75,-1.95) 12(-4.25,-1.95) 13(-3.75,-1.95) 14(-3.25,-1.95) 15(-2.75,-1.95) 16(-2.25,-1.95) 17(-1.75,-1.95) 18(-1.25,-1.95) 19(-0.75,-1.95) 20(-0.25,-1.95) 21(0.25,-1.95) 22(0.75,-1.95) 23(1.25,-1.95) 24(1.75,-1.95) 25(2.25,-1.95) 26(2.75,-1.95) 27(3.25,-1.95) 28(3.75,-1.95) 29(4.25,-1.95) 30(4.75,-1.95) 31(5.25,-1.95) 32(5.75,-1.95) 33(6.25,-1.95) 34(6.75,-1.95) 35(7.25,-1.95) 36(7.75,-1.95) 37(8.25,-1.95) 38(8.75,-1.95) 39(9.25,-1.95) 40(9.75,-1.95)
  rect 1.194x3.2 smd: 41(-12.15,0) 45(12.15,0)
  rect 2.311x1.295 smd: 42(-8.9,1.95) 43(0,1.95) 44(8.9,1.95)
50450-01071-001
  rect 0.508x0.991 smd: 1(-3.6,1.45) 2(-2.8,1.45) 3(-2,1.45) 4(-1.2,1.45) 5(-0.4,1.45) 6(0.4,1.45) 7(1.2,1.45) 8(2,1.45) 9(2.8,1.45) 10(3.6,1.45)
  rect 1.194x1.702 smd: 11(-4.9,0) 12(4.9,0)
51530-01001-W01
  rect 0.305x0.838 smd: 1(-2.25,3.175) 2(-1.75,3.175) 3(-1.25,3.175) 4(-0.75,3.175) 5(-0.25,3.175) 6(0.25,3.175) 7(0.75,3.175) 8(1.25,3.175) 9(1.75,3.175) 10(2.25,3.175)
  rect 0.813x2.007 smd: 11(-3.95,0) 12(3.95,0)
51540-04001-W01
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.813x2.007 smd: 41(-11.45,0) 42(11.45,0)
A1002WV0-5PS-5E-1
  rect 0.61x1.549 smd: 1(2,2.525) 2(1,2.525) 3(0,2.525) 4(-1,2.525) 5(-2,2.525)
  rect 1.194x1.803 smd: 6(3.3,0) 7(-3.3,0)
A1251WV0-15PS-5E
  rect 0.813x1.6 smd: 1(-8.75,2.9) 2(-7.5,2.9) 3(-6.25,2.9) 4(-5,2.9) 5(-3.75,2.9) 6(-2.5,2.9) 7(-1.25,2.9) 8(0,2.9) 9(1.25,2.9) 10(2.5,2.9) 11(3.75,2.9) 12(5,2.9) 13(6.25,2.9) 14(7.5,2.9) 15(8.75,2.9)
  rect 2.108x2.997 smd: 16(-11.3,0) 17(11.3,0)
A2003WV0-1X3PA-6T
  round 1.27 hole 0.889: 1(-2,0) 2(0,0) 3(2,0)
AAA-BAT-034-P06-A-U
  round 0.254 hole 1.067 unplated: (-7.5,0)
  round 0.254 hole 1.372 unplated: (0,0)
  rect 3.048x3.404 smd: 1(6.225,0)
  rect 4.496x2.388 smd: 2(-14.95,0)
ARES2H16
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES2H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES8-CN24H20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ASP-137098-05-1-U2
  rect 0.737x2.794 smd: 1(-5.715,-2.035) 2(-5.715,2.035) 3(-4.445,-2.035) 4(-4.445,2.035) 5(-3.175,-2.035) 6(-3.175,2.035) 7(-1.905,-2.035) 8(-1.905,2.035) 9(-0.635,-2.035) 10(-0.635,2.035) 11(0.635,-2.035) 12(0.635,2.035) 13(1.905,-2.035) 14(1.905,2.035) 15(3.175,-2.035) 16(3.175,2.035) 17(4.445,-2.035) 18(4.445,2.035) 19(5.715,-2.035) 20(5.715,2.035)
BGA170D1214H48
  round 0.406 smd: A1(-5.2,6.4) A2(-4.4,6.4) A3(-3.6,6.4) A12(3.6,6.4) A13(4.4,6.4) A14(5.2,6.4) B1(-5.2,5.6) B2(-4.4,5.6) B3(-3.6,5.6) B12(3.6,5.6) B13(4.4,5.6) B14(5.2,5.6) C1(-5.2,4.8) C2(-4.4,4.8) C3(-3.6,4.8) C12(3.6,4.8) C13(4.4,4.8) C14(5.2,4.8) R1(-5.2,-4.8) R2(-4.4,-4.8) R3(-3.6,-4.8) R12(3.6,-4.8) R13(4.4,-4.8) R14(5.2,-4.8) T1(-5.2,-5.6) T2(-4.4,-5.6) T3(-3.6,-5.6) T12(3.6,-5.6) T13(4.4,-5.6) T14(5.2,-5.6) U1(-5.2,-6.4) U2(-4.4,-6.4) U3(-3.6,-6.4) U12(3.6,-6.4) U13(4.4,-6.4) U14(5.2,-6.4)
  round 0.356 smd: A4(-2.8,6.4) A5(-2,6.4) A10(2,6.4) A11(2.8,6.4) B4(-2.8,5.6) B5(-2,5.6) B10(2,5.6) B11(2.8,5.6) C4(-2.8,4.8) C5(-2,4.8) C10(2,4.8) C11(2.8,4.8) D1(-5.2,4) D2(-4.4,4) D3(-3.6,4) D4(-2.8,4) D5(-2,4) D10(2,4) D11(2.8,4) D12(3.6,4) D13(4.4,4) D14(5.2,4) E1(-5.2,3.2) E2(-4.4,3.2) E3(-3.6,3.2) E4(-2.8,3.2) E5(-2,3.2) E10(2,3.2) E11(2.8,3.2) E12(3.6,3.2) E13(4.4,3.2) E14(5.2,3.2) F1(-5.2,2.4) F2(-4.4,2.4) F3(-3.6,2.4) F4(-2.8,2.4) F5(-2,2.4) F10(2,2.4) F11(2.8,2.4) F12(3.6,2.4) F13(4.4,2.4) F14(5.2,2.4) G1(-5.2,1.6) G2(-4.4,1.6) G3(-3.6,1.6) G4(-2.8,1.6) G5(-2,1.6) G10(2,1.6) G11(2.8,1.6) G12(3.6,1.6) G13(4.4,1.6) G14(5.2,1.6) H1(-5.2,0.8) H2(-4.4,0.8) H3(-3.6,0.8) H4(-2.8,0.8) H5(-2,0.8) H10(2,0.8) H11(2.8,0.8) H12(3.6,0.8) H13(4.4,0.8) H14(5.2,0.8) J1(-5.2,0) J2(-4.4,0) J3(-3.6,0) J4(-2.8,0) J5(-2,0) J10(2,0) J11(2.8,0) J12(3.6,0) J13(4.4,0) J14(5.2,0) K1(-5.2,-0.8) K2(-4.4,-0.8) K3(-3.6,-0.8) K4(-2.8,-0.8) K5(-2,-0.8) K10(2,-0.8) K11(2.8,-0.8) K12(3.6,-0.8) K13(4.4,-0.8) K14(5.2,-0.8) L1(-5.2,-1.6) L2(-4.4,-1.6) L3(-3.6,-1.6) L4(-2.8,-1.6) L5(-2,-1.6) L10(2,-1.6) L11(2.8,-1.6) L12(3.6,-1.6) L13(4.4,-1.6) L14(5.2,-1.6) M1(-5.2,-2.4) M2(-4.4,-2.4) M3(-3.6,-2.4) M4(-2.8,-2.4) M5(-2,-2.4) M10(2,-2.4) M11(2.8,-2.4) M12(3.6,-2.4) M13(4.4,-2.4) M14(5.2,-2.4) N1(-5.2,-3.2) N2(-4.4,-3.2) N3(-3.6,-3.2) N4(-2.8,-3.2) N5(-2,-3.2) N10(2,-3.2) N11(2.8,-3.2) N12(3.6,-3.2) N13(4.4,-3.2) N14(5.2,-3.2) P1(-5.2,-4) P2(-4.4,-4) P3(-3.6,-4) P4(-2.8,-4) P5(-2,-4) P10(2,-4) P11(2.8,-4) P12(3.6,-4) P13(4.4,-4) P14(5.2,-4) R4(-2.8,-4.8) R5(-2,-4.8) R10(2,-4.8) R11(2.8,-4.8) T4(-2.8,-5.6) T5(-2,-5.6) T10(2,-5.6) T11(2.8,-5.6) U4(-2.8,-6.4) U5(-2,-6.4) U10(2,-6.4) U11(2.8,-6.4)
BGA583D21H60
  round 0.406 smd: A1(-10,10) A2(-9.2,10) A3(-8.4,10) A24(8.4,10) A25(9.2,10) A26(10,10) AD1(-10,-8.4) AD2(-9.2,-8.4) AD3(-8.4,-8.4) AD24(8.4,-8.4) AD25(9.2,-8.4) AD26(10,-8.4) AE1(-10,-9.2) AE2(-9.2,-9.2) AE3(-8.4,-9.2) AE24(8.4,-9.2) AE25(9.2,-9.2) AE26(10,-9.2) AF1(-10,-10) AF2(-9.2,-10) AF3(-8.4,-10) AF24(8.4,-10) AF25(9.2,-10) AF26(10,-10) B1(-10,9.2) B2(-9.2,9.2) B3(-8.4,9.2) B24(8.4,9.2) B25(9.2,9.2) B26(10,9.2) C1(-10,8.4) C2(-9.2,8.4) C3(-8.4,8.4) C24(8.4,8.4) C25(9.2,8.4) C26(10,8.4)
  round 0.356 smd: A4(-7.6,10) A5(-6.8,10) A6(-6,10) A7(-5.2,10) A8(-4.4,10) A9(-3.6,10) A10(-2.8,10) A11(-2,10) A12(-1.2,10) A13(-0.4,10) A14(0.4,10) A15(1.2,10) A16(2,10) A17(2.8,10) A18(3.6,10) A19(4.4,10) A20(5.2,10) A21(6,10) A22(6.8,10) A23(7.6,10) AA1(-10,-6) AA2(-9.2,-6) AA3(-8.4,-6) AA4(-7.6,-6) AA5(-6.8,-6) AA6(-6,-6) AA7(-5.2,-6) AA8(-4.4,-6) AA9(-3.6,-6) AA10(-2.8,-6) AA11(-2,-6) AA12(-1.2,-6) AA13(-0.4,-6) AA14(0.4,-6) AA15(1.2,-6) AA16(2,-6) AA17(2.8,-6) AA18(3.6,-6) AA19(4.4,-6) AA20(5.2,-6) AA21(6,-6) AA22(6.8,-6) AA23(7.6,-6) AA24(8.4,-6) AA25(9.2,-6) AA26(10,-6) AB1(-10,-6.8) AB2(-9.2,-6.8) AB3(-8.4,-6.8) AB4(-7.6,-6.8) AB5(-6.8,-6.8) AB6(-6,-6.8) AB7(-5.2,-6.8) AB8(-4.4,-6.8) AB9(-3.6,-6.8) AB10(-2.8,-6.8) AB11(-2,-6.8) AB12(-1.2,-6.8) AB13(-0.4,-6.8) AB14(0.4,-6.8) AB15(1.2,-6.8) AB16(2,-6.8) AB17(2.8,-6.8) AB18(3.6,-6.8) AB19(4.4,-6.8) AB20(5.2,-6.8) AB21(6,-6.8) AB22(6.8,-6.8) AB23(7.6,-6.8) AB24(8.4,-6.8) AB25(9.2,-6.8) AB26(10,-6.8) AC1(-10,-7.6) AC2(-9.2,-7.6) AC3(-8.4,-7.6) AC4(-7.6,-7.6) AC5(-6.8,-7.6) AC6(-6,-7.6) AC7(-5.2,-7.6) AC8(-4.4,-7.6) AC9(-3.6,-7.6) AC10(-2.8,-7.6) AC11(-2,-7.6) AC12(-1.2,-7.6) AC13(-0.4,-7.6) AC14(0.4,-7.6) AC15(1.2,-7.6) AC16(2,-7.6) AC17(2.8,-7.6) AC18(3.6,-7.6) AC19(4.4,-7.6) AC20(5.2,-7.6) AC21(6,-7.6) AC22(6.8,-7.6) AC23(7.6,-7.6) AC24(8.4,-7.6) AC25(9.2,-7.6) AC26(10,-7.6) AD4(-7.6,-8.4) AD5(-6.8,-8.4) AD6(-6,-8.4) AD7(-5.2,-8.4) AD8(-4.4,-8.4) AD9(-3.6,-8.4) AD10(-2.8,-8.4) AD11(-2,-8.4) AD12(-1.2,-8.4) AD13(-0.4,-8.4) AD14(0.4,-8.4) AD15(1.2,-8.4) AD16(2,-8.4) AD17(2.8,-8.4) AD18(3.6,-8.4) AD19(4.4,-8.4) AD20(5.2,-8.4) AD21(6,-8.4) AD22(6.8,-8.4) AD23(7.6,-8.4) AE4(-7.6,-9.2) AE5(-6.8,-9.2) AE6(-6,-9.2) AE7(-5.2,-9.2) AE8(-4.4,-9.2) AE9(-3.6,-9.2) AE10(-2.8,-9.2) AE11(-2,-9.2) AE12(-1.2,-9.2) AE13(-0.4,-9.2) AE14(0.4,-9.2) AE15(1.2,-9.2) AE16(2,-9.2) AE17(2.8,-9.2) AE18(3.6,-9.2) AE19(4.4,-9.2) AE20(5.2,-9.2) AE21(6,-9.2) AE22(6.8,-9.2) AE23(7.6,-9.2) AF4(-7.6,-10) AF5(-6.8,-10) AF6(-6,-10) AF7(-5.2,-10) AF8(-4.4,-10) AF9(-3.6,-10) AF10(-2.8,-10) AF11(-2,-10) AF12(-1.2,-10) AF13(-0.4,-10) AF14(0.4,-10) AF15(1.2,-10) AF16(2,-10) AF17(2.8,-10) AF18(3.6,-10) AF19(4.4,-10) AF20(5.2,-10) AF21(6,-10) AF22(6.8,-10) AF23(7.6,-10) B4(-7.6,9.2) B5(-6.8,9.2) B6(-6,9.2) B7(-5.2,9.2) B8(-4.4,9.2) B9(-3.6,9.2) B10(-2.8,9.2) B11(-2,9.2) B12(-1.2,9.2) B13(-0.4,9.2) B14(0.4,9.2) B15(1.2,9.2) B16(2,9.2) B17(2.8,9.2) B18(3.6,9.2) B19(4.4,9.2) B20(5.2,9.2) B21(6,9.2) B22(6.8,9.2) B23(7.6,9.2) C4(-7.6,8.4) C5(-6.8,8.4) C6(-6,8.4) C7(-5.2,8.4) C8(-4.4,8.4) C9(-3.6,8.4) C10(-2.8,8.4) C11(-2,8.4) C12(-1.2,8.4) C13(-0.4,8.4) C14(0.4,8.4) C15(1.2,8.4) C16(2,8.4) C17(2.8,8.4) C18(3.6,8.4) C19(4.4,8.4) C20(5.2,8.4) C21(6,8.4) C22(6.8,8.4) C23(7.6,8.4) D1(-10,7.6) D2(-9.2,7.6) D3(-8.4,7.6) D4(-7.6,7.6) D5(-6.8,7.6) D6(-6,7.6) D7(-5.2,7.6) D8(-4.4,7.6) D9(-3.6,7.6) D10(-2.8,7.6) D11(-2,7.6) D12(-1.2,7.6) D13(-0.4,7.6) D14(0.4,7.6) D15(1.2,7.6) D16(2,7.6) D17(2.8,7.6) D18(3.6,7.6) D19(4.4,7.6) D20(5.2,7.6) D21(6,7.6) D22(6.8,7.6) D23(7.6,7.6) D24(8.4,7.6) D25(9.2,7.6) D26(10,7.6) E1(-10,6.8) E2(-9.2,6.8) E3(-8.4,6.8) E4(-7.6,6.8) E5(-6.8,6.8) E6(-6,6.8) E7(-5.2,6.8) E8(-4.4,6.8) E9(-3.6,6.8) E10(-2.8,6.8) E11(-2,6.8) E12(-1.2,6.8) E13(-0.4,6.8) E14(0.4,6.8) E15(1.2,6.8) E16(2,6.8) E17(2.8,6.8) E18(3.6,6.8) E19(4.4,6.8) E20(5.2,6.8) E22(6.8,6.8) E23(7.6,6.8) E24(8.4,6.8) E25(9.2,6.8) E26(10,6.8) F1(-10,6) F2(-9.2,6) F3(-8.4,6) F4(-7.6,6) F5(-6.8,6) F6(-6,6) F8(-4.4,6) F9(-3.6,6) F10(-2.8,6) F11(-2,6) F12(-1.2,6) F13(-0.4,6) F14(0.4,6) F15(1.2,6) F16(2,6) F17(2.8,6) F18(3.6,6) F19(4.4,6) F22(6.8,6) F23(7.6,6) F24(8.4,6) F25(9.2,6) F26(10,6) G1(-10,5.2) G2(-9.2,5.2) G3(-8.4,5.2) G4(-7.6,5.2) G5(-6.8,5.2) G6(-6,5.2) G9(-3.6,5.2) G22(6.8,5.2) G23(7.6,5.2) G24(8.4,5.2) G25(9.2,5.2) G26(10,5.2) H1(-10,4.4) H2(-9.2,4.4) H3(-8.4,4.4) H4(-7.6,4.4) H5(-6.8,4.4) H6(-6,4.4) H15(1.2,4.4) H17(2.8,4.4) H22(6.8,4.4) H23(7.6,4.4) H24(8.4,4.4) H25(9.2,4.4) H26(10,4.4) J1(-10,3.6) J2(-9.2,3.6) J3(-8.4,3.6) J4(-7.6,3.6) J5(-6.8,3.6) J6(-6,3.6) J11(-2,3.6) J22(6.8,3.6) J23(7.6,3.6) J24(8.4,3.6) J25(9.2,3.6) J26(10,3.6) K1(-10,2.8) K2(-9.2,2.8) K3(-8.4,2.8) K4(-7.6,2.8) K5(-6.8,2.8) K6(-6,2.8) K8(-4.4,2.8) K9(-3.6,2.8) K10(-2.8,2.8) K11(-2,2.8) K12(-1.2,2.8) K13(-0.4,2.8) K14(0.4,2.8) K15(1.2,2.8) K16(2,2.8) K17(2.8,2.8) K22(6.8,2.8) K23(7.6,2.8) K24(8.4,2.8) K25(9.2,2.8) K26(10,2.8) L1(-10,2) L2(-9.2,2) L3(-8.4,2) L4(-7.6,2) L5(-6.8,2) L6(-6,2) L8(-4.4,2) L9(-3.6,2) L10(-2.8,2) L11(-2,2) L12(-1.2,2) L13(-0.4,2) L14(0.4,2) L15(1.2,2) L16(2,2) L17(2.8,2) L18(3.6,2) L21(6,2) L22(6.8,2) L23(7.6,2) L24(8.4,2) L25(9.2,2) L26(10,2) M1(-10,1.2) M2(-9.2,1.2) M3(-8.4,1.2) M4(-7.6,1.2) M5(-6.8,1.2) M6(-6,1.2) M7(-5.2,1.2) M8(-4.4,1.2) M9(-3.6,1.2) M10(-2.8,1.2) M11(-2,1.2) M12(-1.2,1.2) M13(-0.4,1.2) M14(0.4,1.2) M15(1.2,1.2) M16(2,1.2) M17(2.8,1.2) M19(4.4,1.2) M21(6,1.2) M22(6.8,1.2) M23(7.6,1.2) M24(8.4,1.2) M25(9.2,1.2) M26(10,1.2) N1(-10,0.4) N2(-9.2,0.4) N3(-8.4,0.4) N4(-7.6,0.4) N5(-6.8,0.4) N6(-6,0.4) N8(-4.4,0.4) N9(-3.6,0.4) N10(-2.8,0.4) N11(-2,0.4) N12(-1.2,0.4) N13(-0.4,0.4) N14(0.4,0.4) N15(1.2,0.4) N16(2,0.4) N17(2.8,0.4) N19(4.4,0.4) N21(6,0.4) N22(6.8,0.4) N23(7.6,0.4) N24(8.4,0.4) N25(9.2,0.4) N26(10,0.4) P1(-10,-0.4) P2(-9.2,-0.4) P3(-8.4,-0.4) P4(-7.6,-0.4) P5(-6.8,-0.4) P6(-6,-0.4) P7(-5.2,-0.4) P8(-4.4,-0.4) P9(-3.6,-0.4) P10(-2.8,-0.4) P11(-2,-0.4) P12(-1.2,-0.4) P13(-0.4,-0.4) P14(0.4,-0.4) P15(1.2,-0.4) P16(2,-0.4) P17(2.8,-0.4) P19(4.4,-0.4) P21(6,-0.4) P22(6.8,-0.4) P23(7.6,-0.4) P24(8.4,-0.4) P25(9.2,-0.4) P26(10,-0.4) R1(-10,-1.2) R2(-9.2,-1.2) R3(-8.4,-1.2) R4(-7.6,-1.2) R5(-6.8,-1.2) R6(-6,-1.2) R7(-5.2,-1.2) R8(-4.4,-1.2) R9(-3.6,-1.2) R10(-2.8,-1.2) R11(-2,-1.2) R12(-1.2,-1.2) R13(-0.4,-1.2) R14(0.4,-1.2) R15(1.2,-1.2) R16(2,-1.2) R17(2.8,-1.2) R19(4.4,-1.2) R21(6,-1.2) R22(6.8,-1.2) R23(7.6,-1.2) R24(8.4,-1.2) R25(9.2,-1.2) R26(10,-1.2) T1(-10,-2) T2(-9.2,-2) T3(-8.4,-2) T4(-7.6,-2) T5(-6.8,-2) T6(-6,-2) T7(-5.2,-2) T8(-4.4,-2) T9(-3.6,-2) T10(-2.8,-2) T11(-2,-2) T12(-1.2,-2) T13(-0.4,-2) T14(0.4,-2) T15(1.2,-2) T16(2,-2) T17(2.8,-2) T21(6,-2) T22(6.8,-2) T23(7.6,-2) T24(8.4,-2) T25(9.2,-2) T26(10,-2) U1(-10,-2.8) U2(-9.2,-2.8) U3(-8.4,-2.8) U4(-7.6,-2.8) U5(-6.8,-2.8) U6(-6,-2.8) U7(-5.2,-2.8) U8(-4.4,-2.8) U9(-3.6,-2.8) U10(-2.8,-2.8) U11(-2,-2.8) U12(-1.2,-2.8) U13(-0.4,-2.8) U14(0.4,-2.8) U15(1.2,-2.8) U16(2,-2.8) U17(2.8,-2.8) U21(6,-2.8) U22(6.8,-2.8) U23(7.6,-2.8) U24(8.4,-2.8) U25(9.2,-2.8) U26(10,-2.8) V1(-10,-3.6) V2(-9.2,-3.6) V3(-8.4,-3.6) V4(-7.6,-3.6) V5(-6.8,-3.6) V6(-6,-3.6) V7(-5.2,-3.6) V8(-4.4,-3.6) V9(-3.6,-3.6) V10(-2.8,-3.6) V11(-2,-3.6) V12(-1.2,-3.6) V13(-0.4,-3.6) V14(0.4,-3.6) V15(1.2,-3.6) V16(2,-3.6) V17(2.8,-3.6) V20(5.2,-3.6) V21(6,-3.6) V22(6.8,-3.6) V23(7.6,-3.6) V24(8.4,-3.6) V25(9.2,-3.6) V26(10,-3.6) W1(-10,-4.4) W2(-9.2,-4.4) W3(-8.4,-4.4) W4(-7.6,-4.4) W5(-6.8,-4.4) W6(-6,-4.4) W11(-2,-4.4) W13(-0.4,-4.4) W15(1.2,-4.4) W16(2,-4.4) W21(6,-4.4) W22(6.8,-4.4) W23(7.6,-4.4) W24(8.4,-4.4) W25(9.2,-4.4) W26(10,-4.4) Y1(-10,-5.2) Y2(-9.2,-5.2) Y3(-8.4,-5.2) Y4(-7.6,-5.2) Y5(-6.8,-5.2) Y6(-6,-5.2) Y20(5.2,-5.2) Y21(6,-5.2) Y22(6.8,-5.2) Y23(7.6,-5.2) Y24(8.4,-5.2) Y25(9.2,-5.2) Y26(10,-5.2)
