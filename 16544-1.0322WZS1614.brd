# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ2: length 92
  TOP w0.102: CPU1.B24 188.4,158.6 189.25,158.6
  TOP w0.114: v6(211.95,94.71) 211.52,94.71 210.62,93.81 DIMM2.20 ; v6(193.31,158.52) 189.33,158.52 189.25,158.6
  L6 w0.102: v6(193.31,158.52) 201.89,149.95 201.89,144.01 207.13,138.77 207.13,134.78 206.83,134.48 206.83,134.33 207.1,134.07 207.1,133.92 206.95,133.78 206.81,133.78 206.54,134.05 206.4,134.05 205.98,133.63 205.98,133.36 206.08,133.26 206.93,133.26 207.03,133.16 207.03,132.95 206.93,132.85 206.08,132.85 205.98,132.75 205.98,132.55 206.08,132.44 206.93,132.44 207.03,132.34 207.03,132.14 206.93,132.04 206.08,132.04 205.98,131.94 205.98,131.73 206.08,131.63 206.93,131.63 207.03,131.53 207.03,131.33 206.93,131.23 206.08,131.23 205.98,131.12 205.98,130.92 206.08,130.82 206.93,130.82 207.03,130.72 207.03,130.51 206.93,130.41 206.08,130.41 205.98,130.31 205.98,124.51 213.42,117.08 213.42,102.05 211.4,100.03 211.4,95.01 211.7,94.71 v6(211.95,94.71)
M_B_DQ3: length 92.2
  TOP w0.102: CPU1.C24 187.4,159.4 189.44,159.4 189.46,159.42 189.84,159.42 v6(190.27,158.99)
  TOP w0.114: DIMM2.21 210.37,99.19 210.77,98.79 210.77,98.02 v6(211.94,96.84)
  L6 w0.102: v6(211.94,96.84) 212.46,97.37 212.46,100.01 214.26,101.81 214.26,106.08 214.36,106.18 214.72,106.18 214.82,106.28 214.82,106.48 214.72,106.58 214.36,106.58 214.26,106.69 214.26,106.89 214.36,106.99 214.72,106.99 214.82,107.09 214.82,107.29 214.72,107.4 214.36,107.4 214.26,107.5 214.26,107.7 214.36,107.8 214.72,107.8 214.82,107.9 214.82,108.11 214.72,108.21 214.36,108.21 214.26,108.31 214.26,108.56 214.86,109.16 214.86,113.57 214.76,113.67 214.28,113.67 214.18,113.77 214.18,113.98 214.28,114.08 214.76,114.08 214.86,114.18 214.86,114.38 214.76,114.48 214.28,114.48 214.18,114.59 214.18,114.79 214.28,114.89 214.76,114.89 214.86,114.99 214.86,115.19 214.76,115.3 214.28,115.3 214.18,115.4 214.18,115.6 214.28,115.7 214.76,115.7 214.86,115.8 214.86,116.06 214.75,116.17 214.33,116.17 214.23,116.27 214.23,117.12 207.83,123.52 207.83,124.25 207.73,124.35 207.08,124.35 206.98,124.45 206.98,124.66 207.08,124.76 207.73,124.76 207.83,124.86 207.83,138.96 203.12,143.67 203.12,143.82 203.43,144.12 203.43,144.26 203.28,144.41 203.14,144.41 202.83,144.1 202.69,144.1 202.52,144.28 202.52,150.28 193.2,159.59 190.87,159.59 v6(190.27,158.99)
M_B_DQ4: length 91.7
  TOP w0.114: CPU1.A20 189.09,163.09 189.58,163.09 v6(189.75,163.25) ; v6(216.1,93.01) 215.24,93.01 214.62,92.39 DIMM2.4
  L6 w0.102: v6(216.1,93.01) 215.24,93.86 215.24,99.67 218.68,103.11 218.68,115.42 209.96,124.14 209.96,140.23 209.6,140.59 209.22,140.59 209.12,140.69 209.12,140.89 209.22,140.99 209.6,140.99 209.7,141.09 209.7,141.3 209.6,141.4 209.2,141.4 209.1,141.5 209.1,141.71 209.2,141.81 209.6,141.81 209.71,141.91 209.71,142.11 209.6,142.21 209.15,142.21 209.05,142.32 209.05,142.52 209.15,142.62 209.6,142.62 209.71,142.72 209.71,143 204.57,148.14 204.57,150.95 193.52,162 191.5,162 190.73,162.77 190.22,162.77 v6(189.75,163.25)
M_B_DQ5: length 92.1
  TOP w0.102: 189.33,162.66 189.28,162.61 187.39,162.61 CPU1.C20
  TOP w0.114: v6(191.08,163.22) 190.52,162.66 189.33,162.66 ; v6(216.8,98.66) 215.34,98.66 214.87,99.12 DIMM2.3
  L6 w0.102: v6(191.08,163.22) 191.78,162.52 193.43,162.52 204.89,151.07 204.89,148.38 205.77,147.5 205.91,147.5 206.17,147.76 206.32,147.76 206.46,147.61 206.46,147.47 206.2,147.21 206.2,147.07 206.35,146.92 206.49,146.92 206.75,147.18 206.89,147.18 207.04,147.04 207.04,146.9 206.78,146.64 206.78,146.49 206.92,146.35 207.06,146.35 207.32,146.61 207.47,146.61 207.61,146.46 207.61,146.32 207.35,146.06 207.35,145.92 207.5,145.77 207.64,145.77 207.9,146.03 208.04,146.03 208.19,145.89 208.19,145.74 207.93,145.49 207.93,145.34 208.07,145.2 208.21,145.2 208.47,145.46 208.62,145.46 208.76,145.31 208.76,145.17 208.5,144.91 208.5,144.77 208.65,144.62 208.79,144.62 209.05,144.88 209.19,144.88 209.34,144.74 209.34,144.59 209.08,144.33 209.08,144.19 209.22,144.05 209.36,144.05 209.62,144.31 209.77,144.31 209.91,144.16 209.91,144.02 209.65,143.76 209.65,143.62 210.27,143 210.27,124.26 218.99,115.54 218.99,102.87 216.33,100.22 216.33,99.12 v6(216.8,98.66)
M_B_DQ6: length 91.8
  TOP w0.114: DIMM2.16 211.62,93.13 v6(211.73,93.24) ; v6(192.2,158.98) 191.18,160 CPU1.A23
  L6 w0.102: v6(211.73,93.24) 211.73,93.46 211.03,94.16 211.03,100.17 213.04,102.17 213.04,117.03 205.64,124.42 205.64,133.09 205.52,133.21 204.55,133.21 204.45,133.32 204.45,133.52 204.55,133.62 205.52,133.62 206.82,134.92 206.82,138.56 205.23,140.15 205.09,140.15 204.68,139.73 204.53,139.73 204.39,139.88 204.39,140.02 204.8,140.43 204.8,140.58 204.66,140.72 204.51,140.72 204.1,140.31 203.96,140.31 203.81,140.45 203.81,140.59 204.23,141.01 204.23,141.15 204.08,141.3 203.94,141.3 203.53,140.88 203.38,140.88 203.24,141.03 203.24,141.17 203.65,141.58 203.65,141.73 203.51,141.87 203.36,141.87 202.95,141.46 202.81,141.46 202.66,141.6 202.66,141.74 203.08,142.16 203.08,142.3 202.93,142.45 202.79,142.45 202.38,142.03 202.23,142.03 202.09,142.18 202.09,142.32 202.5,142.73 202.5,142.88 202.36,143.02 202.21,143.02 201.8,142.61 201.66,142.61 201.51,142.75 201.51,142.89 201.93,143.31 201.93,143.45 201.57,143.81 201.57,149.62 v6(192.2,158.98)
M_B_DQ7: length 91.8
  TOP w0.102: CPU1.C23 187.01,160 187.39,159.62 189.37,159.62 189.37,159.62 190.29,159.62 v6(190.91,159)
  TOP w0.114: DIMM2.17 211.37,98.75 v6(211.86,98.26)
  L6 w0.102: v6(211.86,98.26) 211.86,99.95 213.82,101.91 213.82,117.11 206.4,124.52 206.4,124.97 206.54,125.1 207.28,125.1 207.38,125.2 207.38,125.41 207.28,125.51 206.4,125.51 206.3,125.61 206.3,125.81 206.41,125.91 207.28,125.91 207.38,126.02 207.38,126.22 207.28,126.32 206.4,126.32 206.3,126.42 206.3,126.62 206.41,126.73 207.28,126.73 207.38,126.83 207.38,127.03 207.28,127.13 206.4,127.13 206.3,127.23 206.3,127.43 206.41,127.54 207.28,127.54 207.38,127.64 207.38,127.84 207.28,127.95 206.4,127.95 206.3,128.05 206.3,128.24 206.41,128.35 207.28,128.35 207.38,128.45 207.38,128.66 207.28,128.76 206.4,128.76 206.3,128.86 206.3,129.06 206.41,129.16 207.28,129.16 207.38,129.27 207.38,129.47 207.28,129.57 206.4,129.57 206.3,129.67 206.3,129.87 206.4,129.97 207.35,129.97 207.45,130.07 207.45,138.91 202.21,144.15 202.21,150.15 193.76,158.6 193.76,158.65 193.02,159.39 191.29,159.39 v6(190.91,159)
M_B_DQ8: length 80.3
  TOP w0.114: v6(192.04,157.51) 192.04,157.25 191.79,157 CPU1.A26 ; v6(209.34,94.64) 208.45,93.75 208.45,92.82 208.62,92.64 DIMM2.28
  L6 w0.102: v6(192.04,157.51) 200.59,148.96 200.59,135.63 204.67,131.54 204.67,124.06 211.57,117.16 211.57,107.09 211.67,106.99 211.98,106.99 212.08,106.89 212.08,106.69 211.98,106.58 211.68,106.58 211.57,106.48 211.57,106.28 211.67,106.18 211.98,106.18 212.08,106.08 212.08,105.87 211.98,105.77 211.68,105.77 211.57,105.66 211.57,101.89 210.27,100.59 210.27,95.46 209.45,94.64 v6(209.34,94.64)
M_B_DQ9: length 79.6
  TOP w0.114: DIMM2.29 208.37,98.48 208.49,98.36 v6(209.27,98.36) ; CPU1.C26 187.41,156.59 189.45,156.59 189.54,156.68 191.5,156.68 v6(191.96,156.23)
  L6 w0.102: v6(209.27,98.36) 209.27,100.87 210.72,102.32 210.72,114.32 210.62,114.42 210.08,114.42 209.98,114.52 209.98,114.72 210.08,114.82 210.62,114.82 210.72,114.93 210.72,115.13 210.62,115.23 210.08,115.23 209.98,115.33 209.98,115.54 210.08,115.64 210.62,115.64 210.72,115.74 210.72,115.94 210.62,116.04 210.08,116.04 209.98,116.14 209.98,117.88 203.46,124.41 203.46,129.19 203.56,129.29 203.95,129.29 204.05,129.39 204.05,129.6 203.95,129.7 203.56,129.7 203.46,129.8 203.46,130 203.56,130.1 203.95,130.1 204.05,130.21 204.05,130.41 203.95,130.51 203.56,130.51 203.46,130.61 203.46,130.81 203.56,130.92 203.95,130.92 204.05,131.02 204.05,131.22 203.95,131.32 203.56,131.32 203.46,131.42 203.46,131.89 199.98,135.37 199.98,148.26 192.01,156.23 v6(191.96,156.23)
M_B_DQ10: length 79.5
  TOP w0.114: v6(206.62,97.03) 206.17,97.03 205.37,97.83 205.37,99.9 DIMM2.41 ; CPU1.A29 190.17,154 191.59,152.58 v6(192.65,152.58)
  L6 w0.102: v6(206.62,97.03) 206.18,97.03 205.97,97.23 205.97,99.07 206.07,99.17 206.89,99.17 206.99,99.28 206.99,99.48 206.89,99.58 206.07,99.58 205.97,99.68 205.97,99.88 206.07,99.99 206.89,99.99 206.99,100.09 206.99,100.29 206.89,100.39 206.07,100.39 205.97,100.49 205.97,100.7 206.07,100.8 206.89,100.8 206.99,100.9 206.99,101.1 206.89,101.21 206.07,101.21 205.97,101.31 205.97,101.51 206.07,101.61 206.89,101.61 206.99,101.71 206.99,101.92 206.89,102.02 206.46,102.02 206.36,102.12 206.36,102.42 207.8,103.86 207.8,115.22 207.8,117.33 200.78,124.34 200.78,130.82 199.21,132.39 199.21,132.53 199.47,132.79 199.47,132.94 199.33,133.08 199.18,133.08 198.92,132.82 198.78,132.82 198.64,132.96 198.64,133.11 198.9,133.37 198.9,133.51 198.75,133.66 198.61,133.66 198.35,133.39 198.2,133.39 197.99,133.6 197.99,147.24 v6(192.65,152.58)
M_B_DQ11: length 79.4
  TOP w0.102: CPU1.C29 187.44,154 187.82,153.62 188.16,153.62 188.61,154.07 188.61,154.15 188.84,154.38 189.82,154.38 189.98,154.22 190.26,154.22 190.58,153.9 v6(191.29,153.9)
  TOP w0.114: DIMM2.42 205.12,93.24 v6(205.18,93.29)
  L6 w0.102: v6(191.29,153.9) 191.29,152.86 197.31,146.84 197.31,133.43 200.17,130.57 200.17,124.09 206.36,117.9 206.36,114.35 206.46,114.25 207.02,114.25 207.12,114.14 207.12,113.94 207.02,113.84 206.46,113.84 206.36,113.74 206.36,113.53 206.46,113.43 207.02,113.43 207.12,113.33 207.12,107.06 206.76,106.7 206.76,106.55 207.09,106.22 207.09,106.08 206.95,105.94 206.8,105.94 206.47,106.27 206.33,106.27 206.18,106.12 206.18,105.98 206.78,105.38 206.78,105.24 206.63,105.1 206.49,105.1 205.9,105.69 205.75,105.69 205.62,105.56 205.62,102.63 205.21,102.22 205.21,94.4 205.53,94.08 205.53,93.85 205.18,93.49 v6(205.18,93.29)
M_B_DQ12: length 79.9
  TOP w0.114: DIMM2.24 209.62,92.92 v6(209.33,93.21) ; CPU1.A25 v6(189.5,157.5)
  L6 w0.102: v6(189.5,157.5) 190.04,158.04 192.1,158.04 200.91,149.23 200.91,135.73 204.97,131.67 204.97,124.19 211.94,117.22 211.94,114.59 212.66,113.87 212.66,102.38 210.65,100.38 210.65,94.52 v6(209.33,93.21)
M_B_DQ13: length 80
  TOP w0.102: CPU1.B25 188.46,158 188.84,158.38 189.16,158.38 189.58,157.96 190.32,157.96 v6(190.77,157.51)
  TOP w0.114: DIMM2.25 209.37,98.88 209.73,98.52 209.73,97.33 v6(209.35,96.95)
  L6 w0.102: v6(209.35,96.95) 209.81,97.4 209.81,100.78 211.13,102.1 211.13,116.27 210.98,116.42 210.63,116.42 210.53,116.52 210.53,116.72 210.63,116.82 210.98,116.82 211.13,116.97 211.13,117.17 203.81,124.49 203.81,127.02 203.91,127.12 204.26,127.12 204.36,127.23 204.36,127.43 204.26,127.53 203.91,127.53 203.81,127.63 203.81,127.84 203.91,127.94 204.26,127.94 204.36,128.04 204.36,128.24 204.26,128.34 203.91,128.34 203.81,128.45 203.81,128.65 203.91,128.75 204.26,128.75 204.36,128.85 204.36,131.42 200.28,135.5 200.28,148.68 192.26,156.7 191.58,156.7 v6(190.77,157.51)
M_B_DQ14: length 79.7
  TOP w0.114: v6(191.75,153.47) 191.75,154.09 190.67,155.17 189.17,155.17 CPU1.A28 ; DIMM2.38 206.12,92.61 206.7,93.19 v6(206.7,93.47)
  L6 w0.102: v6(206.7,93.47) 205.59,94.58 205.59,102.12 206.54,103.07 206.54,103.21 206.01,103.74 206.01,103.88 206.15,104.03 206.3,104.03 206.83,103.5 206.97,103.5 207.48,104.01 207.48,114.66 207.38,114.76 206.78,114.76 206.68,114.86 206.68,115.06 206.78,115.16 207.38,115.16 207.48,115.27 207.48,115.47 207.38,115.57 206.78,115.57 206.68,115.67 206.68,115.88 206.78,115.98 207.38,115.98 207.48,116.08 207.48,116.28 207.38,116.38 206.78,116.38 206.67,116.49 206.67,116.7 206.77,116.8 207.36,116.8 207.46,116.9 207.46,117.11 207.36,117.21 206.77,117.21 206.67,117.31 206.67,118.02 200.47,124.22 200.47,130.69 197.67,133.5 197.67,146.95 191.75,152.86 v6(191.75,153.47)
M_B_DQ15: length 79.7
  TOP w0.102: CPU1.B28 188,154.95 188.34,154.61 189.33,154.61 189.62,154.89 190.06,154.89 v6(190.21,154.75)
  TOP w0.114: DIMM2.37 206.37,99.9 206.37,98.7 v6(206.63,98.45)
  L6 w0.102: v6(206.63,98.45) 207.38,99.2 207.38,102.91 208.14,103.67 208.14,117.41 201.12,124.43 201.12,124.59 201.23,124.69 201.74,124.69 201.84,124.79 201.84,124.99 201.74,125.1 201.23,125.1 201.12,125.2 201.12,125.4 201.23,125.5 201.74,125.5 201.84,125.6 201.84,125.81 201.74,125.91 201.23,125.91 201.12,126.02 201.12,126.21 201.23,126.32 201.74,126.32 201.84,126.42 201.84,126.62 201.74,126.72 201.23,126.72 201.12,126.83 201.12,127.03 201.23,127.13 201.74,127.13 201.84,127.23 201.84,127.43 201.74,127.53 201.23,127.53 201.12,127.64 201.12,127.84 201.23,127.94 201.74,127.94 201.84,128.04 201.84,128.25 201.74,128.35 201.23,128.35 201.12,128.45 201.12,128.65 201.23,128.75 201.74,128.75 201.84,128.86 201.84,129.06 201.74,129.16 201.23,129.16 201.12,129.27 201.12,129.46 201.23,129.57 201.74,129.57 201.84,129.67 201.84,129.87 201.74,129.97 201.23,129.97 201.12,130.08 201.12,130.28 201.23,130.38 201.74,130.38 201.84,130.48 201.84,130.68 201.74,130.79 201.3,130.79 200.37,131.71 200.37,131.86 200.64,132.12 200.64,132.26 200.49,132.41 200.35,132.41 200.08,132.14 199.94,132.14 199.8,132.29 199.8,132.43 200.06,132.69 200.06,132.84 198.35,134.55 198.35,147.52 190.99,154.88 190.34,154.88 v6(190.21,154.75)
M_B_DQ16: length 70.5
  TOP w0.114: CPU1.A31 189.79,152 v6(189.83,152.04) ; DIMM2.50 203.12,92.63 203.64,93.15 v6(203.78,93.15)
  L6 w0.102: v6(189.83,152.04) 191.01,152.04 196.66,146.39 196.66,133.12 199.51,130.26 199.51,123.87 206.02,117.36 206.02,113.33 206.79,112.56 206.79,107.26 205.23,105.69 205.23,102.9 204.83,102.5 204.83,95.15 204.35,94.67 204.35,93.71 v6(203.78,93.15)
M_B_DQ17: length 70.5
  TOP w0.114: v6(203.79,97.02) 203.35,97.47 203.35,98.93 203.38,98.96 DIMM2.49 ; CPU1.B31 v6(188.5,151.5)
  L6 w0.102: v6(188.5,151.5) 189.93,151.5 192.13,149.29 192.15,149.29 195.74,145.7 195.74,132.74 198.6,129.88 198.6,123.49 203.94,118.15 203.94,117.41 203.94,117.21 204.04,117.11 204.53,117.11 204.63,117.01 204.63,116.8 204.53,116.7 204.04,116.7 203.94,116.6 203.94,116.4 204.04,116.3 204.87,116.3 204.97,116.19 204.97,115.99 204.87,115.89 204.04,115.89 203.94,115.79 203.94,115.58 204.04,115.48 204.87,115.48 204.97,115.38 204.97,107.58 204.97,106.79 203,104.82 203,97.81 v6(203.79,97.02)
M_B_DQ18: length 70.5
  TOP w0.114: DIMM2.62 200.12,92.79 v6(200.77,93.43) ; CPU1.B34 188.48,148.52 v6(188.56,148.52)
  L6 w0.102: v6(200.77,93.43) 198.96,93.43 198.86,93.53 198.86,93.74 198.96,93.84 199.74,93.84 199.84,93.94 199.84,94.14 199.74,94.24 198.99,94.24 198.89,94.34 198.89,94.55 198.99,94.65 199.74,94.65 199.84,94.75 199.84,94.95 199.74,95.06 199.22,95.06 199.12,95.16 199.12,95.36 199.22,95.46 199.74,95.46 199.84,95.56 199.84,102.14 200.58,102.88 200.58,106.34 201.96,107.71 201.96,113.92 201.38,114.5 201.38,117.42 195.76,123.04 195.76,128.58 193.1,131.23 193.1,145.1 190.25,147.96 189.13,147.96 v6(188.56,148.52)
M_B_DQ19: length 70.8
  TOP w0.114: v6(198.68,95.53) 198.96,95.53 199.87,96.45 DIMM2.63 ; CPU1.C35 187.05,148 187.5,147.55 v6(187.5,147.53)
  L6 w0.102: v6(187.5,147.53) 187.61,147.64 190.22,147.64 190.74,147.12 190.74,147.03 192.78,144.99 192.78,131.12 195.45,128.46 195.45,122.91 200.98,117.38 200.98,107.43 199.48,105.93 199.48,105.79 199.58,105.68 200.09,105.68 200.19,105.58 200.19,105.38 200.09,105.28 199.59,105.28 199.47,105.16 199.47,104.97 199.58,104.87 200.09,104.87 200.19,104.77 200.19,104.57 200.09,104.46 199.59,104.46 199.47,104.35 199.47,104.16 199.58,104.06 200.09,104.06 200.19,103.96 200.19,103.75 200.09,103.65 199.59,103.65 199.47,103.54 199.47,103.35 199.58,103.25 200.09,103.25 200.19,103.14 200.19,102.94 200.09,102.84 199.59,102.84 199.47,102.72 199.47,96.32 v6(198.68,95.53)
M_B_DQ20: length 71.5
  TOP w0.114: v6(203.85,95.6) 204.34,95.1 204.34,92.79 204.12,92.57 DIMM2.46 ; v6(191.59,150.89) 191.59,151.87 190.04,153.42 188.42,153.42 CPU1.B30
  L6 w0.102: v6(203.85,95.6) 203.85,95.72 204.45,96.32 204.45,102.58 204.87,103 204.87,105.76 205.72,106.62 205.72,117.23 199.21,123.74 199.21,130.13 196.35,132.99 196.35,146.12 v6(191.59,150.89)
M_B_DQ21: length 70.7
  TOP w0.114: v6(190.42,151.61) 190.42,152.08 190.01,152.49 187.6,152.49 187.09,153 CPU1.C30 ; DIMM2.45 204.38,98.99 v6(203.82,98.44)
  L6 w0.102: v6(203.82,98.44) 203.82,98.79 203.46,99.15 203.46,99.46 203.56,99.56 203.99,99.56 204.09,99.66 204.09,99.86 203.99,99.97 203.56,99.97 203.46,100.07 203.46,100.27 203.56,100.37 203.99,100.37 204.09,100.47 204.09,100.68 203.99,100.78 203.56,100.78 203.46,100.88 203.46,101.08 203.56,101.19 203.99,101.19 204.09,101.29 204.09,101.49 203.99,101.59 203.56,101.59 203.46,101.69 203.46,102.02 204.56,103.13 204.56,104.88 204.46,104.98 204.21,104.98 204.11,105.08 204.11,105.29 204.21,105.39 204.46,105.39 204.56,105.49 204.56,105.89 205.35,106.68 205.35,107.73 205.35,116.47 205.35,117.17 204.94,117.58 204.8,117.58 204.65,117.43 204.51,117.43 204.37,117.58 204.37,117.72 204.51,117.87 204.51,118.01 198.9,123.62 198.9,130.01 196.05,132.86 196.05,145.97 191.67,150.35 191.36,150.35 190.42,151.29 v6(190.42,151.61)
M_B_DQ22: length 70.3
  TOP w0.114: v6(200.71,94.85) 201.23,94.33 201.23,93 201.12,92.9 DIMM2.58 ; CPU1.B33 188.4,149.6 189.7,149.6 v6(190.81,148.49)
  L6 w0.102: v6(200.71,94.85) 200.71,94.92 200.18,95.45 200.18,99.51 200.28,99.61 200.78,99.61 200.88,99.72 200.88,99.92 200.78,100.02 200.26,100.02 200.16,100.12 200.16,100.32 200.26,100.43 200.78,100.43 200.88,100.53 200.88,100.73 200.78,100.83 200.26,100.83 200.16,100.93 200.16,101.14 200.26,101.24 200.78,101.24 200.88,101.34 200.88,101.54 200.78,101.65 200.26,101.65 200.16,101.75 200.16,101.95 200.26,102.05 200.78,102.05 200.91,102.18 200.91,106.09 202.32,107.5 202.32,114.04 201.76,114.6 201.76,117.47 196.07,123.15 196.07,128.71 193.41,131.38 193.41,145.23 190.81,147.83 v6(190.81,148.49)
M_B_DQ23: length 70.1
  TOP w0.114: v6(200.68,98.46) 200.87,98.66 DIMM2.59 ; CPU1.A34 v6(189.5,148.5)
  L6 w0.102: v6(200.68,98.46) 201.23,99.02 201.23,105.77 202.7,107.23 202.7,114.21 202.14,114.76 202.14,117.68 196.38,123.45 196.38,123.8 196.48,123.91 196.89,123.91 196.99,124.01 196.99,124.21 196.89,124.31 196.48,124.31 196.38,124.41 196.38,124.62 196.48,124.72 196.89,124.72 196.99,124.82 196.99,125.02 196.89,125.12 196.48,125.12 196.38,125.23 196.38,125.43 196.48,125.53 196.89,125.53 196.99,125.63 196.99,125.84 196.89,125.94 196.48,125.94 196.38,126.04 196.38,126.24 196.48,126.34 196.89,126.34 196.99,126.45 196.99,126.65 196.89,126.75 196.48,126.75 196.38,126.85 196.38,127.06 196.48,127.16 196.89,127.16 196.99,127.26 196.99,127.46 196.89,127.56 196.48,127.56 196.38,127.66 196.38,127.87 196.48,127.97 196.89,127.97 196.99,128.07 196.99,128.27 196.89,128.38 196.48,128.38 196.38,128.48 196.38,128.86 196.01,129.22 196.01,129.37 196.34,129.69 196.34,129.83 196.19,129.98 196.05,129.98 195.73,129.65 195.58,129.65 195.44,129.8 195.44,129.94 195.74,130.24 195.74,130.39 195.6,130.53 195.45,130.53 195.15,130.23 195.01,130.23 194.86,130.37 194.86,130.52 195.18,130.83 195.18,130.97 195.03,131.12 194.89,131.12 194.58,130.8 194.43,130.8 194.29,130.95 194.29,131.09 194.58,131.38 194.58,131.52 194.43,131.67 194.29,131.67 194,131.38 193.86,131.38 193.73,131.51 193.73,145.34 191.43,147.64 191.43,148.45 190.98,148.9 189.9,148.9 v6(189.5,148.5)
M_B_DQ24: length 64.4
  TOP w0.114: DIMM2.70 198.12,92.97 198.22,93.07 v6(198.22,93.2) ; v6(189.86,145.23) 189.44,145.65 189.44,146.18 189.18,146.44 188.56,146.44 CPU1.B36
  L6 w0.102: v6(198.22,93.2) 198.22,93.45 197.82,93.85 197.82,98.11 197.82,107.52 198.84,108.54 198.84,114.12 198.94,114.22 199.33,114.22 199.43,114.32 199.43,114.52 199.33,114.62 198.94,114.62 198.84,114.73 198.84,114.93 198.94,115.03 199.33,115.03 199.43,115.13 199.43,115.34 199.33,115.44 198.94,115.44 198.84,115.54 198.84,115.74 198.94,115.84 199.33,115.84 199.43,115.95 199.43,116.15 199.33,116.25 198.94,116.25 198.84,116.35 198.84,117.36 193.9,122.29 193.9,127.37 191.13,130.15 191.13,140.12 190.37,140.88 190.37,141.41 190.27,141.51 189.97,141.51 189.87,141.61 189.87,141.81 189.97,141.91 190.27,141.91 190.37,142.02 190.37,144.72 v6(189.86,145.23)
M_B_DQ25: length 64.7
  TOP w0.114: DIMM2.71 197.87,97.49 198.42,96.95 v6(198.67,96.95) ; v6(186.48,147.48) 185.48,147.48 CPU1.E36
  L6 w0.102: v6(186.48,147.48) 186.84,147.12 187.78,147.12 188.09,147.44 190.14,147.44 190.54,147.03 190.54,146.75 192.04,145.25 192.04,130.55 194.82,127.78 194.82,122.67 200.61,116.88 200.61,107.74 199.13,106.26 199.13,97.54 198.67,97.08 v6(198.67,96.95)
M_B_DQ26: length 64.5
  TOP w0.114: v6(194.24,97.61) 194.24,97.69 194.87,98.32 DIMM2.83 ; CPU1.C39 186.25,143.25 186.25,142.32 185.91,141.99 v6(185.14,141.99)
  L6 w0.102: v6(194.24,97.61) 194.67,98.04 194.67,107.8 195.01,108.14 195.01,117.49 189.4,123.1 189.4,128.1 187.68,129.82 187.68,132.97 186.28,134.38 186.28,135.41 186.18,135.51 185.57,135.51 185.47,135.61 185.47,135.82 185.57,135.92 186.18,135.92 186.28,136.02 186.28,136.75 186.38,136.85 187.03,136.85 187.13,136.95 187.13,137.15 187.03,137.25 186.38,137.25 186.28,137.36 186.28,137.56 186.38,137.66 187.03,137.66 187.13,137.76 187.13,137.97 187.03,138.07 186.38,138.07 186.28,138.17 186.28,138.37 186.38,138.47 187.03,138.47 187.13,138.58 187.13,138.78 187.03,138.88 186.38,138.88 186.28,138.98 186.28,139.18 186.38,139.29 187.03,139.29 187.13,139.39 187.13,139.59 187.03,139.69 185.72,139.69 185.62,139.79 185.62,140 185.72,140.1 187.03,140.1 187.13,140.2 187.13,140.4 187.03,140.51 186.62,140.51 v6(185.14,141.99)
M_B_DQ27: length 64.6
  TOP w0.114: CPU1.D38 186,144.99 185.53,144.52 185.53,143.75 v6(185.14,143.36) ; v6(194.42,93.9) 194.42,93.07 194.62,92.86 DIMM2.84
  L6 w0.102: v6(185.14,143.36) 186.09,142.41 186.09,142.26 185.77,141.94 185.77,141.8 185.91,141.65 186.06,141.65 186.83,142.42 186.97,142.42 187.11,142.28 187.11,142.14 186.35,141.37 186.35,141.22 186.49,141.08 186.63,141.08 186.95,141.4 187.1,141.4 187.53,140.96 187.53,136.64 187.43,136.54 186.68,136.54 186.58,136.44 186.58,136.24 186.68,136.14 187.43,136.14 187.53,136.04 187.53,135.83 187.43,135.73 186.71,135.73 186.61,135.63 186.61,134.48 187.99,133.09 187.99,129.97 189.71,128.26 189.71,123.23 195.32,117.62 195.32,107.94 195.09,107.71 195.09,96.26 194.87,96.05 194.87,94.35 v6(194.42,93.9)
M_B_DQ28: length 64.6
  TOP w0.114: v6(189.88,146.83) 189.88,147.59 189.48,148 CPU1.A35 ; DIMM2.66 199.12,92.66 199.24,92.78 199.24,93.78 v6(198.39,94.62)
  L6 w0.102: v6(198.39,94.62) 198.39,95.09 198.15,95.34 198.15,106.47 198.51,106.83 198.51,106.98 198.35,107.14 198.35,107.28 198.5,107.42 198.64,107.42 198.8,107.26 198.94,107.26 199.09,107.41 199.09,107.55 198.93,107.71 198.93,107.85 199.07,108 199.21,108 199.37,107.84 199.52,107.84 199.85,108.17 199.85,116.78 194.21,122.42 194.21,127.52 191.43,130.29 191.43,140.28 190.73,140.99 190.73,141.27 190.83,141.37 191.29,141.37 191.39,141.47 191.39,141.68 191.29,141.78 190.83,141.78 190.73,141.88 190.73,145.61 189.88,146.45 v6(189.88,146.83)
M_B_DQ29: length 64.5
  TOP w0.114: DIMM2.67 198.87,98.68 v6(198.64,98.45) ; v6(187.5,146.49) 187.5,146.56 187.06,147 CPU1.C36
  L6 w0.102: v6(187.5,146.49) 188.25,147.23 188.97,147.23 189.07,147.13 189.07,146.56 189.17,146.45 189.38,146.45 189.48,146.56 189.48,147.13 189.58,147.23 190.05,147.23 190.34,146.95 190.34,146.41 190.95,145.79 190.95,144.77 191.06,144.67 191.64,144.67 191.74,144.57 191.74,144.37 191.64,144.27 191.06,144.27 190.95,144.16 190.95,143.96 191.06,143.86 191.64,143.86 191.74,143.76 191.74,143.55 191.64,143.45 191.06,143.45 190.95,143.35 190.95,143.15 191.06,143.05 191.64,143.05 191.74,142.95 191.74,142.74 191.64,142.64 191.06,142.64 190.95,142.54 190.95,142.34 191.06,142.23 191.64,142.23 191.74,142.13 191.74,130.43 194.51,127.65 194.51,122.54 200.23,116.83 200.23,108 198.64,106.42 v6(198.64,98.45)
M_B_DQ30: length 64.6
  TOP w0.114: v6(188.04,143.43) 188,143.47 CPU1.B38 ; v6(196.35,98.27) 195.87,98.74 DIMM2.79
  L6 w0.102: v6(188.04,143.43) 188.72,142.76 188.72,141.98 188.72,141.98 188.72,140.44 189.82,139.34 189.82,137.19 189.72,137.09 188.91,137.09 188.81,136.98 188.81,136.78 188.91,136.68 189.72,136.68 189.82,136.58 189.82,136.37 189.72,136.27 188.91,136.27 188.81,136.17 188.81,135.97 188.91,135.87 189.72,135.87 189.82,135.76 189.82,135.56 189.72,135.46 188.91,135.46 188.81,135.36 188.81,135.15 188.91,135.05 189.72,135.05 189.82,134.95 189.82,129.48 191.59,127.71 191.59,126.8 191.7,126.7 191.91,126.7 192.01,126.6 192.01,126.39 191.91,126.29 191.58,126.29 191.48,126.19 191.48,125.99 191.58,125.88 191.91,125.88 192.01,125.78 192.01,125.58 191.91,125.48 191.57,125.48 191.47,125.38 191.47,125.17 191.57,125.07 191.91,125.07 192.01,124.97 192.01,124.77 191.91,124.67 190.81,124.67 190.71,124.56 190.71,124.36 190.81,124.26 191.91,124.26 192.01,124.16 192.01,123.95 191.91,123.85 191.03,123.85 190.93,123.75 190.93,123.55 191.03,123.45 191.91,123.45 192.01,123.34 192.01,122.22 196.35,117.88 196.35,114.08 196.45,113.98 196.66,113.98 196.76,113.88 196.76,113.68 196.66,113.57 196.45,113.57 196.35,113.47 196.35,113.27 196.45,113.17 196.66,113.17 196.76,113.07 196.76,112.86 196.66,112.76 196.45,112.76 196.35,112.66 v6(196.35,98.27)
M_B_DQ31: length 64.7
  TOP w0.114: v6(188.01,140.89) 187.92,140.89 187.3,141.5 187.3,143.68 187.43,143.81 187.43,144.57 CPU1.C38 ; v6(195.33,95.45) 195.26,95.38 195.26,92.88 195.62,92.52 195.62,91.97 DIMM2.80
  L6 w0.102: v6(188.01,140.89) 188.01,135.52 187.84,135.35 187.1,135.35 187,135.25 187,135.05 187.1,134.95 187.96,134.95 188.06,134.85 188.06,134.64 187.96,134.54 187.52,134.54 187.42,134.44 187.42,134.24 187.52,134.13 188.89,134.13 189.15,133.88 189.15,130.46 189.05,130.36 188.47,130.36 188.36,130.25 188.36,130.05 188.47,129.95 189.05,129.95 189.15,129.85 189.15,129.25 190.04,128.35 190.04,127.74 190.14,127.64 190.72,127.64 190.82,127.54 190.82,127.34 190.72,127.24 190.14,127.24 190.04,127.13 190.04,126.93 190.14,126.83 190.72,126.83 190.82,126.73 190.82,126.52 190.72,126.42 190.14,126.42 190.04,126.32 190.04,123.33 195.7,117.66 195.7,107.78 195.54,107.61 195.54,96.13 195.33,95.93 v6(195.33,95.45)
M_B_DQ32: length 62.9
  TOP w0.114: DIMM2.174 170.12,92.54 169.75,92.91 169.27,92.91 168.91,93.27 168.91,94.59 169.56,95.23 v6(169.57,95.23) ; CPU1.AK39 160,143.12 160,142.92 v6(160.32,142.6)
  L6 w0.102: v6(160.32,142.6) 160.85,142.07 161.41,142.07 161.51,141.96 161.51,141.76 161.41,141.66 160.85,141.66 160.75,141.56 160.75,141.35 160.85,141.25 161.41,141.25 161.51,141.15 161.51,140.95 161.41,140.85 160.85,140.85 160.75,140.74 160.75,140.54 160.85,140.44 161.41,140.44 161.54,140.31 161.54,140.11 161.43,140.01 160.86,140.01 160.76,139.9 160.76,139.7 160.86,139.6 161.41,139.6 161.51,139.5 161.51,138.09 162.5,137.1 162.5,124.18 170.63,116.05 170.63,114.63 171.26,114.01 171.26,96.92 v6(169.57,95.23)
M_B_DQ33: length 62.9
  TOP w0.114: v6(159.54,146.53) 159.53,146.53 CPU1.AL37 ; DIMM2.173 170.37,98.56 v6(170.26,98.45)
  L6 w0.102: v6(170.26,98.45) 170.26,98.82 170.65,99.21 170.65,102.53 170.54,102.64 170.13,102.64 170.03,102.74 170.03,102.94 170.13,103.04 170.54,103.04 170.65,103.15 170.65,103.38 170.55,103.48 170.1,103.48 170,103.58 170,103.79 170.1,103.89 170.55,103.89 170.65,103.99 170.65,104.19 170.55,104.3 170.1,104.3 170,104.4 170,104.6 170.1,104.7 170.55,104.7 170.65,104.8 170.65,105.01 170.55,105.11 170.1,105.11 170,105.21 170,105.41 170.1,105.51 170.55,105.51 170.65,105.62 170.65,105.82 170.55,105.92 170.1,105.92 170,106.02 170,106.23 170.1,106.33 170.55,106.33 170.65,106.43 170.65,106.63 170.55,106.73 170.1,106.73 170,106.84 170,107.04 170.1,107.14 170.55,107.14 170.65,107.24 170.65,107.45 170.55,107.55 170.1,107.55 170,107.65 170,107.85 170.1,107.95 170.55,107.95 170.65,108.05 170.65,113.75 170.02,114.38 170.02,115.67 161.69,123.99 161.69,135.3 160.84,136.16 160.84,138.59 159.43,140 159.43,140.97 159.53,141.07 159.53,142.69 159.53,142.77 159.92,143.15 159.92,146.15 v6(159.54,146.53)
M_B_DQ34: length 62.5
  TOP w0.114: DIMM2.187 166.87,98.69 166.91,98.66 166.91,98.21 v6(166.45,97.75) ; CPU1.AN36 v6(156.5,147.5)
  L6 w0.102: v6(156.5,147.5) 156.97,147.03 156.97,146.23 157.22,145.98 157.22,139.05 158.41,137.85 158.41,123.96 166.94,115.43 166.94,102.45 167.04,102.35 167.47,102.35 167.57,102.25 167.57,102.04 167.47,101.94 167.04,101.94 166.94,101.84 166.94,101.64 167.04,101.54 167.47,101.54 167.57,101.43 167.57,101.23 167.47,101.13 167.04,101.13 166.94,101.03 166.94,100.82 167.04,100.72 167.47,100.72 167.57,100.62 167.57,100.42 167.47,100.32 167.04,100.32 166.94,100.21 166.94,100.01 167.04,99.91 167.47,99.91 167.57,99.81 167.57,99.6 167.47,99.5 167.04,99.5 166.94,99.4 166.94,99.2 167.04,99.1 167.47,99.1 167.57,99 167.57,98.79 167.47,98.69 167.04,98.69 166.94,98.59 166.94,98.24 v6(166.45,97.75)
M_B_DQ35: length 62.9
  TOP w0.114: CPU1.AN39 v6(156.5,144.5) ; DIMM2.186 167.12,93.2 v6(166.48,93.85)
  L6 w0.102: v6(156.5,144.5) 156.5,138.79 157.77,137.52 157.77,123.68 166.26,115.19 166.26,102.08 165.69,101.51 165.69,96.08 165.22,95.62 165.22,93.63 165.32,93.53 165.53,93.53 165.63,93.63 165.63,95.39 165.73,95.49 165.93,95.49 166.03,95.39 166.03,94.29 v6(166.48,93.85)
M_B_DQ36: length 62.4
  TOP w0.114: v6(159.51,144.46) 159.53,144.48 159.57,144.48 160,144.91 CPU1.AK38 ; DIMM2.170 171.12,92.71 170.07,93.76 v6(169.65,93.76)
  L6 w0.102: v6(159.51,144.46) 159.51,143.07 159.27,142.83 159.27,141.62 159.12,141.47 159.12,139.84 160.37,138.59 160.37,131.37 161.31,130.44 161.31,123.91 169.67,115.55 169.67,101.89 169.79,101.77 170.21,101.77 170.31,101.67 170.31,101.47 170.21,101.36 169.79,101.36 169.68,101.26 169.68,101.06 169.79,100.96 170.21,100.96 170.31,100.86 170.31,100.65 170.21,100.55 169.79,100.55 169.68,100.45 169.68,100.25 169.79,100.14 170.21,100.14 170.31,100.04 170.31,99.84 170.21,99.74 169.79,99.74 169.67,99.62 169.67,96.09 169.11,95.54 169.11,94.3 v6(169.65,93.76)
M_B_DQ37: length 62.7
  TOP w0.114: v6(159.5,147.45) 159.5,147.41 159.91,147 CPU1.AK36 ; DIMM2.169 171.37,97.36 170.99,96.98 170.29,96.98 170.28,96.98 v6(170.24,96.98)
  L6 w0.102: v6(170.24,96.98) 170.95,97.69 170.95,113.88 170.33,114.5 170.33,115.86 162.08,124.11 162.08,135.86 161.93,136 161.47,136 161.37,136.11 161.37,136.31 161.47,136.41 162.06,136.41 162.16,136.51 162.16,136.71 162.06,136.82 161.28,136.82 161.18,136.92 161.18,137.12 161.28,137.22 161.49,137.22 161.59,137.32 161.59,137.53 161.49,137.63 161.28,137.63 161.18,137.73 161.18,138.7 159.73,140.14 159.73,142.61 160.12,142.99 160.12,146.83 v6(159.5,147.45)
M_B_DQ38: length 62.5
  TOP w0.114: DIMM2.183 167.87,98.28 167.03,97.43 167.03,96.84 v6(166.5,96.31) ; CPU1.AM39 158,143.43 v6(157.87,143.3)
  L6 w0.102: v6(166.5,96.31) 166.93,96.75 166.93,97.6 167.88,98.54 167.88,102.66 167.78,102.77 167.41,102.77 167.31,102.87 167.31,103.07 167.41,103.17 167.78,103.17 167.88,103.27 167.88,103.48 167.78,103.58 167.41,103.58 167.31,103.68 167.31,103.88 167.41,103.99 167.78,103.99 167.88,104.09 167.88,104.29 167.78,104.39 167.41,104.39 167.31,104.49 167.31,104.7 167.41,104.8 167.78,104.8 167.88,104.9 167.88,105.1 167.78,105.2 167.41,105.2 167.31,105.31 167.31,105.51 167.41,105.61 167.78,105.61 167.88,105.71 167.88,105.92 167.78,106.02 167.41,106.02 167.31,106.12 167.31,113.95 167.41,114.05 167.86,114.05 167.96,114.15 167.96,114.35 167.86,114.45 167.41,114.45 167.31,114.56 167.31,114.76 167.41,114.86 167.67,114.86 167.77,114.96 167.77,115.17 167.67,115.27 167.41,115.27 167.31,115.37 167.31,115.64 159.6,123.34 159.6,129.72 158.74,130.58 158.74,137.96 157.52,139.17 157.52,141.37 157.49,141.41 157.49,142.92 v6(157.87,143.3)
M_B_DQ39: length 63
  TOP w0.114: CPU1.AN38 156.55,145.45 v6(156.55,145.47) ; v6(166.52,95.27) 167.5,94.28 167.5,94.13 168.05,93.58 168.05,92.95 168.12,92.88 DIMM2.182
  L6 w0.102: v6(166.52,95.27) 166.52,95.64 165.99,96.17 165.99,98.88 166.09,98.98 166.51,98.98 166.61,99.09 166.61,99.29 166.51,99.39 166.09,99.39 165.99,99.49 165.99,99.7 166.09,99.8 166.51,99.8 166.61,99.9 166.61,100.1 166.51,100.2 166.09,100.2 165.99,100.31 165.99,100.51 166.09,100.61 166.51,100.61 166.61,100.71 166.61,100.91 166.51,101.02 166.09,101.02 165.99,101.12 165.99,101.32 166.09,101.42 166.51,101.42 166.6,101.51 166.6,115.32 158.11,123.81 158.11,137.73 156.91,138.93 156.91,145.11 v6(156.55,145.47)
M_B_DQ40: length 61.1
  TOP w0.114: v6(164.31,98.46) 164.87,99.03 DIMM2.195 ; CPU1.AR36 v6(155.5,146.5)
  L6 w0.102: v6(164.31,98.46) 164.31,104.27 164.41,104.37 165.15,104.37 165.25,104.47 165.25,104.68 165.15,104.78 164.41,104.78 164.31,104.88 164.31,105.08 164.41,105.18 165.15,105.18 165.25,105.29 165.25,105.49 165.15,105.59 164.41,105.59 164.31,105.69 164.31,105.9 164.41,106 165.15,106 165.25,106.1 165.25,106.3 165.15,106.4 164.41,106.4 164.31,106.5 164.31,106.71 164.41,106.81 165.15,106.81 165.25,106.91 165.25,107.11 165.15,107.22 164.41,107.22 164.31,107.32 164.31,115.23 156.43,123.11 156.43,135.49 155.03,136.88 155.03,144.98 154.85,145.16 154.85,145.85 v6(155.5,146.5)
M_B_DQ41: length 60.9
  TOP w0.102: v6(154.15,142.68) 154.24,142.77 154.24,143.68 154.39,143.84 154.39,145.39 CPU1.AR37
  TOP w0.114: v6(164.34,93.17) 164.87,93.17 164.9,93.13 164.92,93.13 165.12,92.93 DIMM2.194
  L6 w0.102: v6(154.15,142.68) 153.72,142.24 153.72,141.01 153.88,140.85 153.88,137.08 155.82,135.14 155.82,122.72 163.55,114.99 163.55,94.75 163.45,94.65 163.11,94.65 163.01,94.55 163.01,94.35 163.11,94.25 163.72,94.25 163.82,94.14 163.82,93.69 v6(164.34,93.17)
M_B_DQ42: length 61.6
  TOP w0.114: DIMM2.207 161.87,98.56 v6(161.61,98.3) ; CPU1.AU37 152.62,146 152.18,145.56 151.53,145.56 150.23,144.26 v6(150.23,143.59)
  L6 w0.102: v6(161.61,98.3) 161.61,100.94 161.71,101.05 162.06,101.05 162.16,101.15 162.16,101.35 162.06,101.45 161.71,101.45 161.61,101.55 161.61,101.76 161.71,101.86 162.06,101.86 162.16,101.96 162.16,102.16 162.06,102.26 161.71,102.26 161.61,102.37 161.61,104.26 161.71,104.36 161.99,104.36 162.09,104.47 162.09,104.67 161.99,104.77 161.71,104.77 161.61,104.87 161.61,105.08 161.71,105.18 162.04,105.18 162.14,105.28 162.14,105.48 162.04,105.58 161.71,105.58 161.61,105.68 161.61,105.89 161.71,105.99 162.03,105.99 162.13,106.09 162.13,106.29 162.03,106.4 161.71,106.4 161.61,106.5 161.61,106.7 161.71,106.8 162.03,106.8 162.13,106.9 162.13,107.11 162.03,107.21 161.71,107.21 161.61,107.31 161.61,107.51 161.71,107.62 162.04,107.62 162.14,107.72 162.14,107.92 162.04,108.02 161.71,108.02 161.61,108.12 161.61,115.07 154.49,122.19 154.49,134.56 152.14,136.91 152.14,141.68 v6(150.23,143.59)
M_B_DQ43: length 61.5
  TOP w0.114: v6(149.78,145.45) 151.08,145.45 151.62,146 CPU1.AV37 ; v6(159.9,95.35) 159.9,95.33 161.05,94.18 161.05,93.09 161.62,92.52 DIMM2.208
  L6 w0.102: v6(149.78,145.45) 149.78,141.19 150.48,140.49 150.48,137.25 153.52,134.21 153.52,121.84 160.33,115.02 160.33,95.78 v6(159.9,95.35)
M_B_DQ44: length 61.4
  TOP w0.114: CPU1.AP37 156.5,146.5 v6(156.52,146.5) ; DIMM2.191 165.87,98.18 164.43,96.74 v6(164.32,96.74)
  L6 w0.102: v6(164.32,96.74) 164.81,97.23 164.81,102.08 165.64,102.9 165.64,107.42 165.53,107.52 164.75,107.52 164.65,107.62 164.65,107.83 164.75,107.93 165.53,107.93 165.64,108.03 165.64,114.44 156.73,123.34 156.73,135.62 155.35,137 155.35,144.73 156.06,145.43 156.06,146.04 v6(156.52,146.5)
M_B_DQ45: length 61.5
  TOP w0.102: v6(154.12,141.28) 154.62,141.78 154.62,144.16 155,144.54 155.43,144.54 155.88,145 CPU1.AP38
  TOP w0.114: DIMM2.190 166.12,92.79 v6(164.31,94.6)
  L6 w0.102: v6(164.31,94.6) 163.86,95.06 163.86,115.11 156.12,122.85 156.12,135.3 154.22,137.2 154.22,138.6 154.32,138.7 154.6,138.7 154.7,138.81 154.7,139.01 154.6,139.11 154.32,139.11 154.22,139.21 154.22,139.42 154.32,139.52 154.6,139.52 154.7,139.62 154.7,139.82 154.6,139.92 154.32,139.92 154.22,140.03 154.22,140.23 154.32,140.33 154.6,140.33 154.7,140.43 154.7,140.63 154.6,140.74 154.32,140.74 154.12,140.94 v6(154.12,141.28)
M_B_DQ46: length 61.2
  TOP w0.114: v6(150.23,142.95) 150.56,142.95 152.44,144.84 152.44,145.04 152.84,145.44 153.04,145.44 153.59,145.99 153.59,146.59 CPU1.AT36 ; DIMM2.203 162.87,98.13 v6(161.57,96.82)
  L6 w0.102: v6(150.23,142.95) 151.7,141.48 151.7,141.3 151.6,141.2 151.28,141.2 151.18,141.1 151.18,140.9 151.28,140.79 151.6,140.79 151.7,140.69 151.7,136.91 154.18,134.44 154.18,122.07 161.13,115.12 161.13,97.26 v6(161.57,96.82)
M_B_DQ47: length 60.6
  TOP w0.114: v6(162.06,93.27) 162.14,93.27 162.62,92.78 DIMM2.204 ; v6(150.23,142.18) 153,144.95 CPU1.AU38
  L6 w0.102: v6(150.23,142.18) 150.86,141.56 150.86,140.4 150.96,140.3 151.27,140.3 151.37,140.19 151.37,139.99 151.27,139.89 150.96,139.89 150.86,139.79 150.86,137.31 153.84,134.33 153.84,121.96 160.75,115.05 160.75,94.15 161.63,93.27 v6(162.06,93.27)
M_B_DQ48: length 69.8
  TOP w0.114: v6(149.42,148.3) 149.58,148.14 150.86,148.14 CPU1.AW35 ; v6(159.64,93.13) 159.62,93.12 DIMM2.216
  L6 w0.102: v6(159.64,93.13) 159.64,93.43 158.96,94.11 158.96,95.7 158.85,95.81 158.39,95.81 158.29,95.91 158.29,96.11 158.39,96.21 158.59,96.21 158.69,96.31 158.69,96.52 158.59,96.62 158.39,96.62 158.27,96.74 158.27,99.12 158.17,99.22 157.68,99.22 157.58,99.32 157.58,99.53 157.68,99.63 158.17,99.63 158.27,99.73 158.27,99.93 158.17,100.04 157.68,100.04 157.58,100.14 157.58,100.34 157.68,100.44 158.17,100.44 158.27,100.54 158.27,100.75 158.17,100.85 157.68,100.85 157.58,100.95 157.58,101.15 157.68,101.25 158.17,101.25 158.27,101.36 158.27,101.56 158.17,101.66 157.68,101.66 157.58,101.76 157.58,102.99 157.68,103.09 158.01,103.09 158.11,103.19 158.11,103.39 158.01,103.5 157.68,103.5 157.58,103.6 157.58,115.48 151.77,121.28 151.77,131.98 150.96,132.8 150.96,134.3 147.49,137.77 147.49,146.93 148.22,147.66 148.78,147.66 v6(149.42,148.3)
M_B_DQ49: length 70.3
  TOP w0.114: DIMM2.215 159.87,98.96 159.32,98.41 159.32,97.04 159.55,96.82 v6(159.8,96.82) ; CPU1.AU35 152.59,148 152.21,148.39 151.84,148.39 151.51,148.05 151.51,147.96 151.16,147.61 150.8,147.61 150.68,147.73 149.07,147.73 148.37,147.03 v6(148.37,146.94)
  L6 w0.102: v6(148.37,146.94) 148.51,146.8 148.51,145.88 148.26,145.63 148.26,138.03 152.38,133.91 152.38,121.59 158.96,115.01 158.96,114.86 158.86,114.76 158.42,114.76 158.32,114.66 158.32,114.46 158.42,114.36 158.86,114.36 158.96,114.25 158.96,102.21 159.06,102.11 159.27,102.11 159.37,102.01 159.37,101.81 159.27,101.71 159.06,101.71 158.96,101.6 158.96,101.4 159.06,101.3 159.42,101.3 159.53,101.2 159.53,100.99 159.42,100.89 159.06,100.89 158.96,100.79 158.96,100.59 159.09,100.45 159.42,100.45 159.52,100.35 159.52,100.18 159.42,100.08 159.06,100.08 158.96,99.98 158.96,99.78 159.06,99.67 159.43,99.67 159.54,99.57 159.54,99.37 159.43,99.27 159.06,99.27 158.96,99.17 158.96,98.96 159.06,98.86 159.38,98.86 159.49,98.76 159.49,98.56 159.38,98.45 159.06,98.45 158.96,98.35 158.96,98.15 159.06,98.05 159.3,98.05 159.4,97.95 159.4,97.74 159.3,97.64 159.06,97.64 158.96,97.54 158.96,97.34 159.06,97.24 159.27,97.24 159.68,96.82 v6(159.8,96.82)
M_B_DQ50: length 70.1
  TOP w0.114: DIMM2.228 156.62,92.85 156.93,93.15 v6(157.23,93.15) ; CPU1.AW32 149.94,151 v6(149.78,151.16)
  L6 w0.102: v6(157.23,93.15) 156.9,93.15 154.7,95.35 154.7,100.09 154.08,100.71 154.08,115.1 149.24,119.94 149.24,124.94 148.22,125.96 148.22,133.19 144.93,136.48 144.93,148.51 147.95,151.52 149.42,151.52 v6(149.78,151.16)
M_B_DQ51: length 70.3
  TOP w0.102: v6(148.4,151.1) 148.89,150.62 152.62,150.62 CPU1.AU32
  TOP w0.114: DIMM2.229 156.37,96.91 v6(155.38,95.92)
  L6 w0.102: v6(148.4,151.1) 147.96,151.1 145.24,148.38 145.24,136.68 148.55,133.37 148.55,126.11 149.54,125.11 149.54,120.09 154.46,115.18 154.46,100.87 155.08,100.24 155.08,96.22 v6(155.38,95.92)
M_B_DQ52: length 69.8
  TOP w0.102: DIMM2.211 160.87,98.97 160.17,98.27 v6(159.87,98.27)
  TOP w0.114: v6(150.33,146.98) 150.72,146.59 151.75,146.59 152,146.84 CPU1.AV36
  L6 w0.102: v6(159.87,98.27) 159.87,101.95 159.28,102.54 159.28,103.4 159.38,103.5 159.88,103.5 159.98,103.6 159.98,103.8 159.88,103.9 159.38,103.9 159.28,104.01 159.28,104.93 159.38,105.03 159.79,105.03 159.89,105.14 159.89,105.34 159.79,105.44 159.38,105.44 159.27,105.54 159.27,105.75 159.38,105.85 159.79,105.85 159.89,105.95 159.89,106.15 159.79,106.25 159.38,106.25 159.27,106.36 159.27,106.56 159.38,106.66 159.79,106.66 159.89,106.76 159.89,106.97 159.79,107.07 159.38,107.07 159.27,107.17 159.27,107.37 159.38,107.47 159.79,107.47 159.89,107.57 159.89,107.78 159.79,107.88 159.38,107.88 159.27,107.98 159.27,115.18 152.8,121.65 152.8,133.92 148.59,138.14 148.59,138.39 148.69,138.5 148.97,138.5 149.08,138.6 149.08,138.8 148.97,138.9 148.69,138.9 148.59,139 148.59,139.21 148.69,139.31 148.98,139.31 149.08,139.41 149.08,139.61 148.98,139.72 148.69,139.72 148.59,139.82 148.59,140.02 148.69,140.12 148.97,140.12 149.07,140.22 149.07,140.43 148.97,140.53 148.69,140.53 148.59,140.63 148.59,140.83 148.69,140.93 148.99,140.93 149.09,141.04 149.09,141.24 148.99,141.34 148.69,141.34 148.59,141.44 148.59,141.65 148.69,141.75 148.99,141.75 149.09,141.85 149.09,142.05 148.99,142.15 148.69,142.15 148.59,142.26 148.59,142.46 148.69,142.56 148.99,142.56 149.09,142.66 149.09,142.87 148.99,142.97 148.69,142.97 148.59,143.07 148.59,143.27 148.69,143.37 148.99,143.37 149.09,143.47 149.09,143.68 148.99,143.78 148.69,143.78 148.59,143.88 148.59,144.08 148.69,144.19 148.99,144.19 149.09,144.29 149.09,144.49 148.99,144.59 148.69,144.59 148.59,144.69 148.59,144.9 148.69,145 148.99,145 149.32,145.32 149.32,145.93 150.33,146.94 v6(150.33,146.98)
M_B_DQ53: length 69.9
  TOP w0.114: v6(149.07,147.15) 149.15,147.15 149.51,147.52 150.48,147.52 CPU1.AW36 ; v6(159.82,94.6) 159.83,94.6 160.66,93.77 160.66,92.71 160.62,92.67 DIMM2.212
  L6 w0.102: v6(149.07,147.15) 148.87,147.35 148.2,147.35 147.96,147.11 147.96,146.77 148.31,146.43 148.31,146.08 147.92,145.69 147.92,137.85 151.29,134.48 151.29,133.9 151.39,133.8 151.91,133.8 152.01,133.7 152.01,133.49 151.91,133.39 151.39,133.39 151.29,133.29 151.29,133.09 151.39,132.99 151.91,132.99 152.08,132.82 152.08,121.41 157.96,115.53 157.96,114.23 158.6,113.6 158.6,107.83 158.5,107.73 158.1,107.73 158,107.63 158,107.42 158.1,107.32 158.5,107.32 158.6,107.22 158.6,107.02 158.5,106.91 158.1,106.91 158,106.81 158,106.61 158.1,106.51 158.5,106.51 158.6,106.41 158.6,106.2 158.5,106.1 158.1,106.1 158,106 158,105.8 158.1,105.69 158.5,105.69 158.6,105.59 158.6,105.39 158.5,105.29 158.1,105.29 158,105.19 158,104.98 158.1,104.88 158.5,104.88 158.6,104.78 158.6,97.23 159.27,96.55 159.27,95.29 159.82,94.74 v6(159.82,94.6)
M_B_DQ54: length 69.6
  TOP w0.114: DIMM2.224 157.62,92.73 157.86,92.97 157.86,94.11 v6(157.4,94.58) ; CPU1.AW33 149.69,150 v6(149.16,149.47)
  L6 w0.102: v6(157.4,94.58) 155.46,96.51 155.46,114.63 149.85,120.24 149.85,126.22 149.66,126.41 149.52,126.41 149.2,126.09 149.06,126.09 148.91,126.23 148.91,126.38 149.23,126.7 149.23,126.84 148.85,127.22 148.85,133.52 145.54,136.83 145.54,148.25 147.45,150.16 148.47,150.16 v6(149.16,149.47)
M_B_DQ55: length 70.2
  TOP w0.102: 149.14,150.16 149.38,150.4 151.6,150.4 CPU1.AV33
  TOP w0.114: v6(157.38,95.29) 156.89,95.78 156.89,98.45 157.37,98.94 DIMM2.225 ; 149.14,150.16 v6(148.45,149.47)
  L6 w0.102: v6(148.45,149.47) 148.04,149.88 147.6,149.88 145.85,148.13 145.85,136.99 149.18,133.66 149.18,127.36 150.15,126.39 150.15,120.46 155.79,114.82 155.79,96.88 v6(157.38,95.29)
M_B_DQ56: length 78.7
  TOP w0.114: DIMM2.237 154.37,98.7 v6(154.14,98.46) ; v6(150.15,152.94) 150.27,153.06 150.94,153.06 CPU1.AW30
  L6 w0.102: v6(150.15,152.94) 150.15,152.86 149.27,151.98 147.49,151.98 144.24,148.73 144.24,136.2 144.69,135.76 144.69,135.61 144.28,135.21 144.28,135.06 144.42,134.92 144.57,134.92 144.97,135.33 145.12,135.33 145.26,135.18 145.26,135.04 144.86,134.63 144.86,134.49 145,134.34 145.14,134.34 145.55,134.75 145.69,134.75 147.55,132.89 147.55,124.95 147.66,124.85 148.4,124.85 148.5,124.75 148.5,124.55 148.4,124.45 147.66,124.45 147.55,124.35 147.55,124.14 147.66,124.04 148.4,124.04 148.5,123.94 148.5,123.74 148.4,123.63 147.66,123.63 147.55,123.53 147.55,123.33 147.66,123.23 148.4,123.23 148.5,123.13 148.5,122.92 148.4,122.82 147.66,122.82 147.55,122.72 147.55,122.52 147.66,122.41 148.4,122.41 148.5,122.31 148.5,122.11 148.4,122.01 147.66,122.01 147.55,121.91 147.55,121.7 147.66,121.6 148.4,121.6 148.5,121.5 148.5,121.3 148.4,121.2 147.66,121.2 147.55,121.09 147.55,120.89 147.66,120.79 148.4,120.79 148.5,120.69 148.5,120.48 148.4,120.38 147.66,120.38 147.55,120.28 147.55,119.59 149.13,118.01 149.28,118.01 149.61,118.34 149.76,118.34 149.9,118.2 149.9,118.06 149.57,117.72 149.57,117.58 149.7,117.44 150.55,117.44 153.7,114.29 153.7,100.55 154.14,100.11 v6(154.14,98.46)
M_B_DQ57: length 79.1
  TOP w0.102: CPU1.AV30 151.48,153.52 149.65,153.52 148.99,154.18 148.64,154.18 v6(148.48,154.33)
  TOP w0.114: DIMM2.236 154.62,93 v6(154.13,93.5)
  L6 w0.102: v6(148.48,154.33) 148.07,154.33 143.02,149.29 143.02,132.79 146.33,129.48 146.33,118.69 149.9,115.13 150.44,115.13 151.62,113.94 151.62,99.88 152.36,99.15 152.36,95.27 152.36,95.12 151.69,94.45 151.69,94.31 151.84,94.16 151.98,94.16 152.86,95.05 153.01,95.05 153.15,94.9 153.15,94.76 152.27,93.88 152.27,93.73 152.41,93.59 152.55,93.59 153.22,94.26 153.37,94.26 v6(154.13,93.5)
M_B_DQ58: length 78.7
  TOP w0.114: DIMM2.249 151.37,98.65 150.1,97.37 149.62,97.37 149.61,97.36 v6(149.59,97.36) ; CPU1.AW27 150.51,156.49 149.57,156.49 v6(149.04,157.02)
  L6 w0.102: v6(149.04,157.02) 148.55,156.53 146.66,156.53 144.99,154.86 143.92,154.86 142.04,152.98 140.47,152.98 140.04,152.55 140.04,146.34 141.12,145.26 141.12,131.99 144.43,128.68 144.43,115.76 146.22,113.97 146.22,110.46 146.32,110.36 146.66,110.36 146.76,110.26 146.76,110.06 146.66,109.96 146.32,109.96 146.22,109.86 146.22,109.65 146.32,109.55 146.66,109.55 146.76,109.45 146.76,109.25 146.66,109.14 146.32,109.14 146.22,109.04 146.22,108.84 146.32,108.74 146.66,108.74 146.76,108.64 146.76,108.43 146.66,108.33 146.32,108.33 146.22,108.23 146.22,107.54 148.46,105.3 148.46,99.96 148.95,99.47 148.95,97.68 149.27,97.36 v6(149.59,97.36)
M_B_DQ59: length 79.1
  TOP w0.114: DIMM2.250 151.12,93 150.42,93.7 150.42,94.13 v6(149.58,94.97) ; v6(150.36,157) CPU1.AW26
  L6 w0.102: v6(149.58,94.97) 149.58,95.16 148.57,96.18 148.57,99.19 148.16,99.6 148.16,105.15 145.9,107.41 145.9,113.86 144.12,115.63 144.12,128.55 140.81,131.86 140.81,145.1 139.74,146.18 139.74,152.69 140.36,153.32 141.95,153.32 143.86,155.23 144.73,155.23 146.93,157.44 149.93,157.44 v6(150.36,157)
M_B_DQ60: length 79.7
  TOP w0.102: 147.57,153.12 148.48,152.2 150.4,152.2 150.58,152.38 151.62,152.38 CPU1.AV31
  TOP w0.114: v6(154,94.91) 154.85,94.91 155.62,94.14 DIMM2.232 ; 147.57,153.12 v6(147.57,153.17)
  L6 w0.102: v6(147.57,153.17) 147.35,153.17 143.33,149.15 143.33,133.86 143.71,133.48 143.71,133.33 143.4,133.02 143.4,132.88 143.55,132.74 143.69,132.74 144,133.05 144.14,133.05 144.29,132.9 144.29,132.76 143.98,132.45 143.98,132.31 144.12,132.16 144.27,132.16 144.57,132.47 144.72,132.47 144.86,132.33 144.86,132.18 144.55,131.87 144.55,131.73 144.7,131.59 144.84,131.59 145.15,131.9 145.29,131.9 145.44,131.75 145.44,131.61 145.13,131.3 145.13,131.16 145.27,131.01 145.42,131.01 145.72,131.32 145.87,131.32 146.01,131.18 146.01,131.03 145.7,130.72 145.7,130.58 145.85,130.44 145.99,130.44 146.3,130.75 146.44,130.75 146.64,130.55 146.64,118.86 149.98,115.52 150.68,115.52 151.97,114.23 151.97,100.08 152.79,99.26 152.79,96.12 v6(154,94.91)
M_B_DQ61: length 79.4
  TOP w0.102: v6(148.86,152.81) 148.86,152.73 149.19,152.4 150.31,152.4 150.49,152.58 151.98,152.58 152.56,152 CPU1.AU31
  TOP w0.114: DIMM2.233 155.37,98.14 154.28,97.04 v6(153.95,97.04)
  L6 w0.102: v6(148.86,152.81) 148.37,152.81 147.92,152.35 147.4,152.35 143.94,148.89 143.94,134.92 144.24,134.61 144.24,134.47 143.99,134.22 143.99,134.07 144.13,133.93 144.28,133.93 144.53,134.18 144.67,134.18 144.82,134.04 144.82,133.89 144.57,133.64 144.57,133.5 144.71,133.35 144.85,133.35 145.62,134.12 145.76,134.12 145.91,133.98 145.91,133.83 145.14,133.07 145.14,132.92 145.28,132.78 145.43,132.78 146.2,133.55 146.34,133.55 146.49,133.41 146.49,133.26 145.72,132.49 145.72,132.35 145.86,132.2 146,132.2 146.78,132.98 146.92,132.98 147.07,132.83 147.07,132.69 146.29,131.92 146.29,131.77 147.25,130.81 147.25,119.3 150.21,116.34 150.86,116.34 153.33,113.86 153.33,99.88 153.57,99.65 153.57,97.43 v6(153.95,97.04)
M_B_DQ62: length 79.2
  TOP w0.102: v6(148.79,156.09) 148.79,155.78 149.18,155.39 151.16,155.39 151.56,155 CPU1.AV28
  TOP w0.114: DIMM2.245 152.37,99 150.51,97.13 150.51,96.86 v6(149.56,95.91)
  L6 w0.102: v6(149.56,95.91) 149.56,95.99 150.06,96.49 150.06,98.81 148.77,100.1 148.77,100.36 148.87,100.46 149.32,100.46 149.42,100.57 149.42,100.77 149.32,100.87 148.87,100.87 148.77,100.97 148.77,112.56 147.48,113.85 146.85,113.85 144.73,115.97 144.73,128.8 141.42,132.11 141.42,150.2 142.99,151.76 142.99,153.21 144.1,154.33 145.12,154.33 146.89,156.09 v6(148.79,156.09)
M_B_DQ63: length 79
  TOP w0.102: CPU1.AV27 151.56,156 151.16,155.61 150.74,155.61 v6(150.34,156)
  TOP w0.114: v6(151.04,94.02) 151.64,94.02 152.12,93.53 DIMM2.246
  L6 w0.102: v6(151.04,94.02) 151.04,94.07 150.47,94.63 150.47,99.06 150.03,99.5 150.03,102.15 149.71,102.47 149.71,112.13 147.64,114.2 147.06,114.2 146.24,115.02 146.24,115.16 146.47,115.39 146.47,115.54 146.32,115.68 146.18,115.68 145.95,115.45 145.81,115.45 145.66,115.59 145.66,115.73 145.86,115.94 145.86,116.08 145.72,116.22 145.58,116.22 145.37,116.02 145.23,116.02 145.04,116.21 145.04,128.95 141.73,132.26 141.73,149.96 143.29,151.52 143.29,153.09 144.14,153.93 145.32,153.93 146.9,155.52 150.17,155.52 150.34,155.68 v6(150.34,156)
M_B_DQS_DN0: length 92.6
  TOP w0.127: DIMM2.11 212.87,99.03 212.75,98.9 212.75,97.73 213.83,96.65 v6(214.29,96.65) ; CPU1.A22 189.32,161 189.5,161.18 v6(189.5,161.5)
  L6 w0.127: v6(214.29,96.65) 213.91,96.65 213.64,96.92 213.64,99.47 215.62,101.45 215.62,101.83 215.73,101.95 215.73,102.33 215.62,102.44 215.62,102.82 215.73,102.94 215.73,103.32 215.62,103.43 215.62,103.82 215.73,103.93 215.73,104.31 215.62,104.42 215.62,104.95 215.89,105.22 216.05,105.22 216.32,105.49 216.32,105.65 216.59,105.92 216.75,105.92 217.02,106.19 217.02,106.35 217.86,107.19 217.86,107.82 217.58,108.1 217.06,108.1 216.93,108.23 216.93,108.56 217.06,108.68 217.58,108.68 217.86,108.96 217.86,115.07 209.08,123.85 209.08,139.32 207.4,141 207.4,143.74 207.02,144.12 206.63,144.12 206.03,143.53 205.86,143.53 205.62,143.77 205.62,143.95 206.21,144.54 206.21,144.93 205.83,145.31 205.44,145.31 204.85,144.72 204.67,144.72 204.43,144.95 204.43,145.13 205.01,145.71 205.01,146.12 203.72,147.41 203.72,150.63 193.48,160.87 189.25,160.87 189.13,161 189.13,161.13 v6(189.5,161.5)
