# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CLK4_M2SSD_P_R: length 3.8
  TOP w0.102: R2648.1 173.67,38.3 173,38.3 ; v3(173,38.68) 173,38.3 ; 173,38.3 172.42,38.3 172.16,38.05 171.15,38.05 PCH1.AB26
PEG_CLK_CPU_N: length 40
  TOP w0.102: GPU1.AR43 v6(89.15,168)
  BOTTOM w0.102: 93.95,166.04 104.24,166.04 104.78,166.57 112.11,166.57 114.96,169.43 115.42,169.43 116.78,170.79 120.35,170.79 122.35,172.8 123.08,172.8 R2651.1 ; 93.95,166.04 v2(93.95,166.37) ; 93.95,166.04 93.61,166.04 93.11,166.53 89.66,166.53 88.8,167.39 88.8,167.65 v6(89.15,168)
PEG_CLK_CPU_N_R: length 56
  TOP w0.102: CPU1.AF7 v6(163.5,176.5)
  BOTTOM w0.102: v2(128.24,175.46) 128.49,175.22 ; 128.49,175.22 129.46,176.2 129.46,177.02 131.87,179.43 140.89,179.43 145.03,183.57 146.2,183.57 146.93,184.3 147.62,184.3 149.25,185.93 163.15,185.93 164.08,184.99 164.08,177.09 v6(163.5,176.5) ; 128.49,175.22 126.17,172.91 125.41,172.91 125.3,172.8 124.78,172.8 R2651.2
PEG_CLK_CPU_P: length 40.9
  TOP w0.102: GPU1.AR42 v6(88.25,168)
  BOTTOM w0.102: R2650.1 123.08,172.59 122.44,172.59 121.01,171.17 ; 121.01,171.17 120.43,170.59 119.29,170.59 119.19,170.49 118.88,170.49 118.79,170.59 118.48,170.59 118.38,170.49 118.08,170.49 117.98,170.59 117.67,170.59 117.57,170.49 117.27,170.49 117.17,170.59 116.87,170.59 115.51,169.23 115.05,169.23 112.19,166.37 104.86,166.37 104.33,165.84 95.95,165.84 95.85,165.74 95.54,165.74 95.44,165.84 95.14,165.84 95.04,165.74 94.73,165.74 94.64,165.84 94.33,165.84 94.23,165.74 93.93,165.74 93.83,165.84 93.52,165.84 93.03,166.33 89.57,166.33 88.6,167.3 88.6,167.65 v6(88.25,168) ; 121.01,171.17 v2(121.26,170.92)
PEG_CLK_CPU_P_R: length 55.1
  TOP w0.102: v6(163.48,177.51) 163.99,177 CPU1.AF6
  BOTTOM w0.102: v6(163.48,177.51) 163.49,177.51 163.88,177.9 163.88,184.91 163.06,185.72 149.33,185.72 147.7,184.09 147.01,184.09 146.28,183.36 145.12,183.36 142.69,180.94 142.69,180.8 142.48,180.58 142.34,180.58 142.12,180.36 142.12,180.22 141.9,180.01 141.76,180.01 141.55,179.79 141.55,179.65 141.33,179.44 141.19,179.44 140.98,179.22 131.95,179.22 131.55,178.82 131.55,178.68 131.33,178.46 131.19,178.46 130.98,178.25 130.98,178.11 130.76,177.89 130.62,177.89 129.67,176.94 129.67,176.12 128.8,175.25 128.8,175.11 128.58,174.89 128.44,174.89 127.46,173.91 ; 127.46,173.91 126.26,172.71 125.5,172.71 125.38,172.59 124.78,172.59 R2650.2 ; 127.46,173.91 v2(127.71,173.66)
PEG_CLKREQ0_NGFF#_C: length 6
  TOP w0.114: v3(179.3,53.61) 179.09,53.82 178.84,53.82 178.52,54.14 R2476.1 178.79,54.98 181.78,54.98 182,54.75 WLAN1.53
PEG_CLKREQ0_WLAN#: length 53.4
  TOP w0.114: R2476.2 177.63,55.09 177.63,55.1 177.63,55.46 178.24,56.07 178.24,57.68 177.62,58.3 177.62,66.92 178.41,67.72 178.75,67.72 180.31,69.28 180.99,69.28 185.64,73.93 200.16,73.93 200.3,73.79 v1(203.94,73.79) ; v1(204.44,66.07) R416.2 R417.2 202.29,65.27 Q26.S
  BOTTOM w0.114: v1(204.44,66.07) 203.94,66.57 v5(203.94,71.92) v1(203.94,73.79)
PEG_CLKREQ0_WLAN_C: length 83.4
  TOP w0.114: v1(201.83,66.34) 201.83,66.04 200.91,65.12 200.78,65.12 200.51,64.85 199.16,64.85 198.54,64.22 R414.2 198.59,63.91 Q26.D 202.13,63.91 202.6,64.38 R417.1 ; v1(175.72,60.71) 175.87,60.86 175.87,63.2 175.52,63.54 175.52,65.87 179.58,69.93 180.72,69.93 185.98,75.18 200,75.18 v1(200.84,74.35) ; PCH1.AD26 172.19,36.6 v1(172.31,36.47) 172.36,36.47 173.02,35.81 173.69,35.81 174.01,35.49 RN2412.3
  L6 w0.102: v1(172.31,36.47) 172.39,36.55 172.39,37.91 174.54,40.07 174.54,44.09 176.02,45.57 176.02,47.67 175.06,48.63 175.06,60.05 v1(175.72,60.71)
  BOTTOM w0.114: v1(201.83,66.34) v5(201.83,68.22) 201.83,69.32 200.84,70.31 v1(200.84,74.35)
PEG_CLKREQ1_LAN#: length 66.4
  TOP w0.114: LAUOC1.23 134.25,9.15 135.15,10.06 136.7,10.06 137.12,9.64 143.14,9.64 143.26,9.52 144.61,9.52 145.38,8.74 145.87,8.74 v1(146.3,8.31) ; PCH1.AD25 170.6,36.2 171.55,36.2 v1(171.68,36.07) 172.69,35.05 v3(173.13,35.05) 173.34,34.84 RN2412.4
  L4 w0.114: v1(146.3,8.31) 146.3,8.6 147.1,9.4 154.47,9.4 159.07,14 161.58,14 163.3,15.71 v1(163.3,16.76)
  L6 w0.102: v1(163.3,16.76) 163.3,17.7 161.87,19.13 161.87,27.85 170.09,36.07 v1(171.68,36.07)
PEG_CLKREQ4_SSD#: length 137
  TOP w0.114: PCH1.AA23 v6(168.2,38.6) ; v1(110.72,89.46) 110,90.18 SSDC1.52 ; v1(172.62,59.13) 172.4,59.35 172.4,66.92 178.18,72.69 179.63,72.69 v1(179.76,72.57)
  L3 w0.114: v1(179.76,72.57) 179.71,72.52 178.05,72.52 176.4,74.17 176.4,80.52 175.09,81.83 168.87,81.83 167,83.69 v1(166.93,83.69)
  L6 w0.102: v6(168.2,38.6) 168.2,39.97 168.82,40.59 169.97,40.59 175.31,45.94 175.31,47.37 174.35,48.34 174.35,57.4 v1(172.62,59.13)
  BOTTOM w0.114: v1(166.93,83.69) 166.5,83.69 165.56,82.75 v5(163.58,82.75) 161.57,82.75 160.81,83.52 156.26,83.52 155.73,84.05 155.07,84.05 152.01,87.11 148.52,87.11 143.71,91.92 134.81,91.92 134.58,92.15 130.75,92.15 129.15,93.75 121.56,93.75 117.35,89.53 110.79,89.53 v1(110.72,89.46) ; v6(168.2,38.6) 168.84,39.24 169.85,39.24 170.72,38.37 RN2414.3
PEG_CLKREQ5#: length 4.6
  TOP w0.114: v6(168.99,40.18) 168.3,40.18 167.92,39.8 PCH1.Y22
  BOTTOM w0.114: v6(168.99,40.18) 169.29,39.88 v5(170.43,39.88) 171.29,39.02 RN2414.4
PEG_RX_CPU_N0: length 103.4
  TOP w0.102: CPU1.F5 v6(184.5,178.5)
  L6 w0.102: v1(196.29,184.12) 196.29,184 193.42,181.13 188.93,181.13 187.89,180.09 187.19,180.09 187.03,180.25 186.22,180.25 185.34,179.37 185.34,178.46 184.99,178.11 184.89,178.11 v6(184.5,178.5)
  BOTTOM w0.102: C534.2 119.49,172.01 120.23,172.01 122.33,174.12 125.32,174.12 131.47,180.27 140.5,180.27 140.53,180.29 140.57,180.29 144.68,184.4 145.41,184.4 ; v1(196.29,184.12) 195.71,183.54 195.71,183.39 194.23,181.91 172.11,181.91 171.15,182.88 171.15,184.12 168.5,186.77 148.82,186.77 147.19,185.13 146.58,185.13 145.85,184.4 145.41,184.4 ; v2(145.41,184.76) 145.41,184.4
PEG_RX_CPU_N1: length 101.3
  TOP w0.102: CPU1.G4 v6(182.5,179.48)
  L6 w0.102: v1(196.29,186.87) 195.9,186.47 195.62,186.47 194.98,185.84 194.98,183.88 193.07,181.97 185.93,181.97 183.06,179.1 182.87,179.1 v6(182.5,179.48)
  BOTTOM w0.102: v2(173.1,183.97) 173.1,183.64 ; 173.1,183.64 184.23,183.64 185.24,182.63 193.77,182.63 195,183.85 195,185.81 195.62,186.44 195.86,186.44 v1(196.29,186.87) ; 173.1,183.64 172.67,183.64 168.86,187.45 146.71,187.45 140.22,180.96 131.19,180.96 125.57,175.34 124.73,175.34 C538.2
PEG_RX_CPU_N2: length 98.9
  TOP w0.102: CPU1.H6 v6(182.48,176.49)
  L6 w0.089: v6(182.48,176.49) 182.1,176.87 182.1,178.39 182.1,178.4 182.1,178.68 182.1,178.68 182.1,178.73 182.1,178.73 182.1,179.64 182.33,179.88 182.98,179.88 183.68,180.59 183.69,180.59 183.88,180.77
  L6 w0.102: 183.88,180.77 185.75,182.64 192.23,182.64 192.49,182.9 192.49,183.09 v1(192.84,183.44)
  BOTTOM w0.102: 176.38,184.71 177.12,184.71 177.5,184.33 179.76,184.33 180.04,184.61 192.18,184.61 192.58,184.2 192.58,183.69 v1(192.84,183.44) ; 176.38,184.71 v2(176.38,185.06) ; 176.38,184.71 172.59,184.71 169.16,188.14 146.43,188.14 139.93,181.65 130.82,181.65 125.6,176.43 122,176.43 120.03,174.46 119.35,174.46 C541.2
PEG_RX_CPU_N3: length 82.9
  TOP w0.102: CPU1.J5 v6(181.51,178.44)
  L6 w0.102: v6(181.51,178.44) 181.25,178.44 181.06,178.63 181.06,180.35 184.98,184.26 187.29,184.26 187.63,184.61 187.63,184.94 v1(187.99,185.29)
  BOTTOM w0.102: 178.66,185.24 178.04,185.24 177.3,185.98 172.29,185.98 169.45,188.82 146.14,188.82 139.65,182.33 130.49,182.33 125.85,177.69 124.71,177.69 C545.2 ; 178.66,185.24 179.43,185.24 180.16,185.98 187.3,185.98 v1(187.99,185.29) ; 178.66,185.24 v2(178.66,185.57)
PEG_RX_CPU_N4: length 98.6
  TOP w0.102: CPU1.K7 v6(179.5,176.5)
  L6 w0.102: v6(179.5,176.5) 179.9,176.1 180,176.1 180.42,176.52 180.42,181.2 185.2,185.99 190.03,185.99 v1(190.73,185.29)
  BOTTOM w0.102: v1(190.73,185.29) 190.35,185.67 190.35,185.85 189.53,186.66 172.58,186.66 169.73,189.51 145.86,189.51 139.37,183.02 130.18,183.02 125.91,178.74 122.5,178.74 ; C546.2 119.39,176.76 119.77,176.76 121.75,178.74 122.5,178.74 ; 122.5,178.74 v2(122.5,179.07)
PEG_RX_CPU_N5: length 97.4
  TOP w0.102: CPU1.K4 v6(179.53,178.5)
  L6 w0.102: v1(193.47,185.29) 193.12,185.64 193.12,185.83 192.1,186.86 184.21,186.86 180,182.64 180,178.73 179.77,178.5 v6(179.53,178.5)
  BOTTOM w0.102: v1(193.47,185.29) 193.09,185.67 193.09,185.98 191.72,187.35 172.86,187.35 170.02,190.2 145.57,190.2 139.08,183.7 129.57,183.7 128.07,182.19 ; 128.07,182.19 127.6,181.73 127.46,181.73 127.24,181.51 127.24,181.37 127.03,181.16 126.89,181.16 126.67,180.94 126.67,180.8 126.46,180.59 126.32,180.59 126.1,180.37 126.1,180.23 125.89,180.01 124.75,180.01 C548.2 ; 128.07,182.19 v2(127.81,182.45)
PEG_RX_CPU_N6: length 95
  TOP w0.102: CPU1.L6 v6(178.5,176.5)
  L6 w0.089: 179.16,179.31 179.14,179.3 179.14,179.27 179.11,179.24 179.11,179.23 178.9,179.02 178.9,176.73 178.67,176.5 v6(178.5,176.5)
  L6 w0.102: 179.16,179.31 179.46,179.62 179.46,183.33 184.67,188.53 187.29,188.53 v1(187.99,187.83)
  BOTTOM w0.102: 173.61,188.06 184.8,188.06 185.26,188.52 187.41,188.52 187.63,188.3 187.63,188.18 187.97,187.83 v1(187.99,187.83) ; 173.61,188.06 173.15,188.06 170.33,190.88 145.29,190.88 138.8,184.39 128.65,184.39 125.42,181.15 122.2,181.15 120.18,179.14 119.38,179.14 C528.2 ; 173.61,188.06 v2(173.61,188.39)
PEG_RX_CPU_N7: length 93.9
  TOP w0.102: CPU1.M5 v6(178.5,178.5)
  L6 w0.102: v1(189.81,187.83) 190.16,188.18 190.16,188.82 189.84,189.14 189.53,189.14 189.42,189.03 189.12,189.03 189.01,189.14 188.7,189.14 188.59,189.03 188.29,189.03 188.17,189.14 184.42,189.14 179.15,183.87 179.15,181.32 178.11,180.28 178.11,178.89 v6(178.5,178.5)
  BOTTOM w0.102: C553.2 124.7,182.17 125.71,182.17 128.41,184.87 138.6,184.87 145.09,191.36 170.53,191.36 172.89,189 175.23,189 ; v2(175.23,188.65) 175.23,189 ; 175.23,189 176.02,189 176.48,188.54 184.58,188.54 185.04,189 189.86,189 190.15,188.71 190.15,188.17 v1(189.81,187.83)
PEG_RX_CPU_N8: length 111.4
  TOP w0.102: CPU1.N7 v6(177.5,175.5)
  L6 w0.089: 177.33,178.08 177.33,178.05 177.34,178.04 177.34,177.34 177.91,176.78 177.91,175.74 177.66,175.5 v6(177.5,175.5)
  L6 w0.102: 177.33,178.08 177.33,180.78 178.33,181.78 178.33,182.93 178.12,183.15 178.12,184.34 183.96,190.18 191.55,190.18 193.12,188.61 193.12,188.18 v1(193.47,187.83)
  BOTTOM w0.102: 142.64,190.17 138.23,185.76 130.41,185.76 130.31,185.86 130,185.86 129.9,185.76 129.6,185.76 129.5,185.86 129.19,185.86 129.09,185.76 128.79,185.76 128.69,185.86 128.39,185.86 128.29,185.76 127.98,185.76 125.69,183.46 122.35,183.46 120.28,181.39 119.32,181.39 C556.2 ; 142.64,190.17 v2(142.39,190.42) ; 142.64,190.17 143.01,190.54 143.01,190.68 143.22,190.89 143.36,190.89 143.58,191.11 143.58,191.25 143.79,191.47 143.93,191.47 144.15,191.68 144.15,191.82 144.36,192.04 144.5,192.04 144.72,192.25 170.9,192.25 173.26,189.89 191.24,189.89 193.3,187.83 v1(193.47,187.83)
PEG_RX_CPU_N9: length 106.4
  TOP w0.102: CPU1.N4 v6(176.5,179.5)
  L6 w0.102: v1(196.29,189.61) 195.89,189.21 193.95,189.21 192.15,191.01 183.62,191.01 177.15,184.54 177.15,181.57 176.82,181.24 176.82,179.82 v6(176.5,179.5)
  BOTTOM w0.102: v1(196.29,189.61) 195.91,189.23 194.28,189.23 192.94,190.58 173.59,190.58 171.23,192.94 144.24,192.94 143.76,192.46 133.57,192.46 125.66,184.55 125.3,184.55 ; 125.3,184.55 124.72,184.55 C560.2 ; 125.3,184.55 v2(125.3,184.89)
PEG_RX_CPU_N10: length 99.8
  TOP w0.102: CPU1.P6 v6(175.51,176.49)
  L6 w0.089: v6(175.51,176.49) 175.42,176.49 175.27,176.65 175.27,176.76 175.4,176.9 175.8,176.9 176.1,177.2 176.1,179.89 176.15,179.93 176.15,180.1
  L6 w0.102: v1(187.07,191.49) 187.41,191.83 187.41,191.93 187.22,192.13 183.85,192.13 176.47,184.75 176.47,181.8 176.15,181.48 176.15,180.1
  BOTTOM w0.102: v2(122.48,185.09) 122.48,185.42 ; 122.48,185.42 125.48,185.42 125.95,185.89 126.09,185.89 126.3,186.11 126.3,186.25 126.52,186.46 126.66,186.46 126.87,186.68 126.87,186.82 127.09,187.03 127.23,187.03 127.45,187.25 127.45,187.39 131.04,190.98 131.18,190.98 131.39,191.2 131.39,191.34 131.61,191.55 131.75,191.55 131.96,191.77 131.96,191.91 133,192.94 143.56,192.94 144.04,193.42 171.43,193.42 173.66,191.19 177.73,191.19 178.52,191.97 178.82,191.97 178.92,191.87 179.23,191.87 179.33,191.97 179.63,191.97 179.73,191.87 180.04,191.87 180.13,191.97 180.44,191.97 180.54,191.87 180.84,191.87 180.94,191.97 183.74,191.97 183.84,191.87 184.14,191.87 184.24,191.97 184.55,191.97 184.64,191.87 184.95,191.87 185.05,191.97 185.35,191.97 185.45,191.87 185.76,191.87 185.86,191.97 186.87,191.97 187.07,191.77 v1(187.07,191.49) ; 122.48,185.42 122.11,185.42 120.1,183.42 119.29,183.42 C564.2
PEG_RX_CPU_N11: length 100.3
  TOP w0.102: CPU1.R5 v6(175.5,178.5)
  L6 w0.102: v6(175.5,178.5) 175.44,178.44 175.44,178.23 175.34,178.13 175.19,178.13 175.02,178.3 175.02,178.31 174.76,178.57 174.76,181.24 175.64,182.12 175.64,185.11 183.63,193.1 184.69,193.1 184.8,192.99 185.11,192.99 185.22,193.1 185.52,193.1 185.64,192.99 185.94,192.99 186.05,193.1 186.36,193.1 186.47,192.99 186.77,192.99 186.89,193.1 187.41,193.1 188.33,192.19 189.88,192.19 190.07,192 190.07,191.74 v1(189.81,191.49)
  BOTTOM w0.102: 146.18,194.51 171.31,194.51 173.95,191.87 177.33,191.87 178.39,192.94 179.13,192.94 179.23,192.84 179.54,192.84 179.64,192.94 179.94,192.94 180.04,192.84 180.35,192.84 180.44,192.94 180.75,192.94 180.85,192.84 181.15,192.84 181.25,192.94 184.92,192.94 185.02,192.84 185.32,192.84 185.42,192.94 185.73,192.94 185.82,192.84 186.13,192.84 186.23,192.94 186.53,192.94 186.63,192.84 186.94,192.84 187.04,192.94 187.35,192.94 188.06,192.23 189.71,192.23 189.99,191.95 189.99,191.67 v1(189.81,191.49) ; 146.18,194.51 v2(146.18,194.18) ; 146.18,194.51 143.63,194.51 142.74,193.62 132.71,193.62 125.58,186.49 124.68,186.49 C568.2
PEG_RX_CPU_N12: length 118.8
  TOP w0.102: CPU1.T7 v6(173.51,176.48)
  L6 w0.102: v1(193.47,191.49) 193.17,191.8 193.17,193.5 191.76,194.91 187.82,194.91 187.08,194.17 183.22,194.17 174.6,185.55 174.6,185.46 174.6,185.46 174.6,184.86 174.6,183.52 174.12,183.03 174.12,177.29 173.7,176.87 173.7,176.67 v6(173.51,176.48)
  BOTTOM w0.102: C572.2 119.28,185.77 120.01,185.77 122.05,187.81 125.25,187.81 ; 125.25,187.81 v2(125.25,188.14) ; 125.25,187.81 125.64,187.81 132.34,194.51 141.02,194.51 142.57,196.06 157.23,196.06 158.5,197.33 170.84,197.33 173.33,194.84 192.23,194.84 193.07,194.01 193.07,191.9 v1(193.47,191.49)
PEG_RX_CPU_N13: length 68.7
  TOP w0.102: CPU1.T5 v6(173.5,178.5)
  L6 w0.102: v1(132.03,195.78) 132.38,196.13 132.38,196.32 132.84,196.79 134.86,196.79 135.76,197.69 141.47,197.69 142.29,196.87 142.57,196.87 145.26,194.18 157.43,194.18 159.68,191.94 170.32,191.94 173.84,188.42 173.84,187.3 173.84,179.76 173.91,179.68 173.91,179.43 v6(173.5,178.5)
  BOTTOM w0.102: 128.54,191.68 126.86,190 126.25,190 125.25,189.01 124.68,189.01 C576.2 ; 128.54,191.68 v2(128.3,191.92) ; 128.54,191.68 129.96,193.1 129.96,193.72 v1(132.03,195.78)
PEG_RX_CPU_N14: length 76.8
  TOP w0.102: v6(172.5,176.5) CPU1.U6
  L6 w0.089: 172.9,180.37 172.9,180.35 172.91,180.33 172.91,176.91 v6(172.5,176.5)
  L6 w0.102: 172.9,180.37 172.9,183.53 172.8,183.63 172.8,187.55 169.54,190.8 158.83,190.8 156.49,193.14 144.75,193.14 142.06,195.83 141.86,195.83 141.18,196.51 138.71,196.51 138.59,196.4 138.29,196.4 138.18,196.51 137.87,196.51 137.76,196.4 137.46,196.4 137.34,196.51 137.02,196.51 136.53,196.01 136.53,195.5 v1(136.83,195.2)
  BOTTOM w0.102: 135.88,196.1 136.37,195.61 136.47,195.61 136.83,195.25 v1(136.83,195.2) ; 135.88,196.1 v2(136.12,196.34) ; 135.88,196.1 135.28,196.7 134.19,196.7 134.01,196.88 131.18,196.88 130.4,196.1 130.4,195.33 125.58,190.5 125.37,190.5 124.94,190.08 122.57,190.08 122.57,190.07 121.59,190.07 121.27,189.75 121.13,189.75 120.92,189.53 120.92,189.39 120.7,189.18 120.56,189.18 120.34,188.96 120.34,188.82 120.13,188.61 119.99,188.61 119.77,188.39 119.77,188.25 119.56,188.04 119.29,188.04 C580.2
PEG_RX_CPU_N15: length 68.4
  TOP w0.102: CPU1.V5 v6(172.5,178.5)
  L6 w0.089: 172.22,180.9 172.22,180.87 172.21,180.86 172.21,180.16 172.09,180.04 172.09,178.91 v6(172.5,178.5)
  L6 w0.102: 172.22,180.9 172.22,181.95 172.55,182.28 172.55,183.2 172.16,183.59 172.03,183.72 172.03,184.46 172.15,184.58 172.15,184.88 172.03,184.99 172.03,185.3 172.15,185.41 172.15,185.71 172.03,185.83 172.03,186.13 172.15,186.24 172.15,186.55 172.03,186.66 172.03,187.35 169.35,190.03 158.38,190.03 155.92,192.49 144.54,192.49 144.5,192.53 144.49,192.53 142.02,195.01 141.82,195.01 140.93,195.9 139.36,195.9 v1(138.66,195.2)
  BOTTOM w0.102: 138.9,196.73 138.45,197.18 137.91,197.18 137.81,197.08 137.5,197.08 137.41,197.18 137.1,197.18 137,197.08 136.7,197.08 136.6,197.18 136.29,197.18 136.19,197.08 135.89,197.08 135.79,197.18 134.39,197.18 134.21,197.36 130.94,197.36 129.92,196.34 129.92,195.53 125.38,190.99 124.65,190.99 C584.2 ; 138.9,196.73 v2(138.66,196.49) ; 138.9,196.73 139.17,196.46 139.17,195.48 139.09,195.4 139.09,195.38 138.91,195.2 v1(138.66,195.2)
PEG_RX_CPU_P0: length 102.7
  TOP w0.102: CPU1.F6 v6(184.5,177.5)
  L6 w0.102: v1(196.29,183.21) 195.81,183.21 193.51,180.91 189.01,180.91 187.98,179.88 187.1,179.88 186.94,180.04 186.31,180.04 185.56,179.29 185.56,178.37 185.08,177.89 184.89,177.89 v6(184.5,177.5)
  BOTTOM w0.102: v1(196.29,183.21) 195.82,183.21 194.32,181.71 172.03,181.71 170.94,182.8 170.94,184.04 168.42,186.56 148.9,186.56 147.27,184.93 146.67,184.93 145.94,184.2 144.76,184.2 140.63,180.07 131.55,180.07 125.74,174.26 ; C532.2 119.49,171.81 120.31,171.81 122.42,173.91 125.4,173.91 125.74,174.26 ; 125.74,174.26 v2(125.98,174.02)
PEG_RX_CPU_P1: length 101.3
  TOP w0.102: CPU1.G5 v6(182.5,178.51)
  L6 w0.102: v6(182.5,178.51) 182.87,178.89 183.15,178.89 186.02,181.75 193.16,181.75 195.2,183.79 195.2,185.75 195.71,186.26 196.03,186.26 196.29,185.99 v1(196.29,185.95)
  BOTTOM w0.102: v1(196.29,185.95) 196.01,186.23 195.71,186.23 195.2,185.72 195.2,183.77 193.85,182.42 185.16,182.42 184.14,183.44 172.58,183.44 168.77,187.25 147.65,187.25 ; 147.65,187.25 146.8,187.25 140.3,180.76 131.27,180.76 125.65,175.14 124.73,175.14 C536.2 ; 147.65,187.25 v2(147.65,186.92)
PEG_RX_CPU_P2: length 99.6
  TOP w0.102: CPU1.H7 v6(181.51,176.5)
  L6 w0.089: 183.66,180.86 183.66,180.83 182.9,180.07 182.25,180.07 181.91,179.72 181.91,178.32 181.91,178.31 181.91,176.91 v6(181.51,176.5)
  L6 w0.102: 183.66,180.86 185.66,182.85 189.3,182.85 189.41,182.96 189.72,182.96 189.83,182.85 190.13,182.85 190.24,182.96 190.55,182.96 190.66,182.85 190.97,182.85 191.08,182.96 191.38,182.96 191.49,182.85 192.14,182.85 192.27,182.99 192.27,183.09 v1(191.92,183.44)
  BOTTOM w0.102: 174.9,184.51 172.51,184.51 169.08,187.93 146.51,187.93 140.02,181.44 130.9,181.44 125.69,176.23 122.08,176.23 121.83,175.97 121.83,175.83 121.61,175.62 121.47,175.62 121.26,175.4 121.26,175.26 121.04,175.05 120.9,175.05 120.69,174.83 120.69,174.69 120.47,174.48 120.33,174.48 120.12,174.26 119.35,174.26 C539.2 ; 174.9,184.51 v2(174.9,184.18) ; 174.9,184.51 177.04,184.51 177.42,184.12 179.84,184.12 180.12,184.4 180.42,184.4 180.52,184.3 180.83,184.3 180.93,184.4 181.23,184.4 181.33,184.3 181.64,184.3 181.73,184.4 182.04,184.4 182.14,184.3 182.44,184.3 182.54,184.4 187.62,184.4 187.72,184.3 188.03,184.3 188.13,184.4 188.43,184.4 188.53,184.3 188.83,184.3 188.93,184.4 189.24,184.4 189.34,184.3 189.64,184.3 189.74,184.4 192.09,184.4 192.38,184.12 192.38,183.9 v1(191.92,183.44)
PEG_RX_CPU_P3: length 83.5
  TOP w0.102: CPU1.J6 v6(181.51,177.42)
  L6 w0.102: v1(187.07,185.29) 187.41,184.95 187.41,184.7 187.2,184.48 184.89,184.48 180.85,180.44 180.85,178.07 181.43,177.49 181.44,177.49 v6(181.51,177.42)
  BOTTOM w0.102: v1(187.07,185.29) 187.07,185.65 186.94,185.78 182.67,185.78 182.57,185.68 182.27,185.68 182.17,185.78 181.86,185.78 181.76,185.68 181.46,185.68 181.36,185.78 181.05,185.78 180.96,185.68 180.65,185.68 180.55,185.78 180.25,185.78 179.51,185.04 177.95,185.04 177.22,185.78 174.77,185.78 174.67,185.68 174.37,185.68 174.27,185.78 173.96,185.78 173.86,185.68 173.56,185.68 173.46,185.78 173.16,185.78 173.06,185.68 172.75,185.68 172.65,185.78 172.21,185.78 169.36,188.62 146.23,188.62 139.73,182.13 130.57,182.13 125.93,177.49 125.48,177.49 ; 125.48,177.49 v2(125.48,177.14) ; 125.48,177.49 124.71,177.49 C543.2
PEG_RX_CPU_P4: length 97.4
  TOP w0.102: CPU1.K8 v6(179.5,175.5)
  L6 w0.102: v1(189.81,185.29) 189.81,185.52 189.56,185.78 185.29,185.78 180.63,181.11 180.63,176.43 180.09,175.89 179.89,175.89 v6(179.5,175.5)
  BOTTOM w0.102: v1(189.81,185.29) 190.14,185.62 190.14,185.77 189.45,186.46 172.49,186.46 169.65,189.31 145.94,189.31 139.45,182.81 130.27,182.81 125.99,178.54 121.83,178.54 120.43,177.13 ; v2(120.68,176.89) 120.43,177.13 ; 120.43,177.13 119.85,176.56 119.39,176.56 C523.2
PEG_RX_CPU_P5: length 97.1
  TOP w0.102: CPU1.K5 v6(179.5,177.5)
  L6 w0.102: v6(179.5,177.5) 180.21,178.21 180.21,182.55 184.3,186.64 192.01,186.64 192.91,185.74 192.91,185.64 v1(192.56,185.29)
  BOTTOM w0.102: v2(191.95,186.31) 192.21,186.57 ; 192.21,186.57 192.89,185.89 192.89,185.62 v1(192.56,185.29) ; 192.21,186.57 191.63,187.15 172.78,187.15 169.93,189.99 145.66,189.99 139.17,183.5 129.66,183.5 125.97,179.81 124.75,179.81 C547.2
PEG_RX_CPU_P6: length 95.3
  TOP w0.102: CPU1.L7 v6(178.5,175.5)
  L6 w0.089: 179.31,179.16 179.09,178.94 179.09,176.12 178.5,175.53 v6(178.5,175.5)
  L6 w0.102: v1(187.07,187.83) 187.27,188.03 187.27,188.24 187.2,188.32 184.76,188.32 179.68,183.24 179.68,179.53 179.31,179.16
  BOTTOM w0.102: 125.4,180.95 122.28,180.95 120.27,178.93 119.38,178.93 C549.2 ; 125.4,180.95 v2(125.4,180.62) ; 125.4,180.95 125.5,180.95 125.72,181.17 125.86,181.17 126.07,181.38 126.07,181.52 126.29,181.74 126.43,181.74 126.64,181.95 126.64,182.09 126.86,182.31 127,182.31 127.21,182.52 127.21,182.66 127.59,183.04 127.73,183.04 127.95,183.26 127.95,183.4 128.17,183.61 128.31,183.61 128.52,183.83 128.52,183.97 128.74,184.19 138.88,184.19 145.37,190.68 170.25,190.68 173.07,187.86 184.89,187.86 185.34,188.32 187.32,188.32 187.43,188.21 187.43,188.07 187.19,187.83 v1(187.07,187.83)
PEG_RX_CPU_P7: length 95.9
  TOP w0.102: CPU1.M6 v6(178.5,177.5)
  L6 w0.102: v1(190.73,187.83) 190.38,188.18 190.38,188.91 189.93,189.36 184.33,189.36 178.93,183.96 178.93,181.41 177.89,180.37 177.89,178.77 177.91,178.75 177.91,178.09 v6(178.5,177.5)
  BOTTOM w0.102: 177.29,188.75 184.5,188.75 184.95,189.2 189.94,189.2 190.36,188.79 190.36,188.21 v1(190.73,187.83) ; 177.29,188.75 v2(177.29,189.1) ; 177.29,188.75 176.56,188.75 176.11,189.2 172.98,189.2 170.62,191.57 145,191.57 138.51,185.07 128.32,185.07 125.62,182.38 124.7,182.38 C552.2
PEG_RX_CPU_P8: length 110.4
  TOP w0.102: CPU1.N8 v6(177.5,174.5)
  L6 w0.089: v6(177.5,174.5) 177.93,174.93 177.93,175.49 178.1,175.67 178.1,176.86 177.53,177.42 177.53,177.97 177.55,177.99 177.55,178.08
  L6 w0.102: v1(192.56,187.83) 192.91,188.18 192.91,188.52 191.46,189.97 184.05,189.97 178.33,184.25 178.33,183.24 178.55,183.02 178.55,181.69 177.55,180.69 177.55,178.08
  BOTTOM w0.102: v2(125.37,182.93) 125.37,183.26 ; 125.37,183.26 125.77,183.26 128.07,185.56 138.31,185.56 144.8,192.05 170.82,192.05 173.18,189.69 191.16,189.69 192.56,188.29 v1(192.56,187.83) ; 125.37,183.26 122.44,183.26 120.37,181.19 119.32,181.19 C554.2
PEG_RX_CPU_P9: length 106.9
  TOP w0.102: CPU1.N5 v6(176.5,178.5)
  L6 w0.102: v1(196.29,188.7) 195.99,189 193.86,189 192.06,190.79 183.71,190.79 177.37,184.45 177.37,181.48 177.04,181.15 177.04,179.65 v6(176.5,178.5)
  BOTTOM w0.102: 130.44,189.04 133.65,192.25 143.84,192.25 144.32,192.74 171.15,192.74 173.51,190.37 192.85,190.37 194.2,189.03 195.96,189.03 v1(196.29,188.7) ; 130.44,189.04 v2(130.68,188.8) ; 130.44,189.04 125.75,184.34 124.71,184.34 C558.2
PEG_RX_CPU_P10: length 101.4
  TOP w0.102: CPU1.P7 v6(175.5,175.5)
  L6 w0.089: v6(175.5,175.5) 175.07,175.93 175.07,176.84 175.33,177.09 175.72,177.09 175.91,177.28 175.91,180.08 175.93,180.1
  L6 w0.102: 175.93,180.1 175.93,181.57 176.25,181.89 176.25,184.84 183.76,192.34 187.31,192.34 187.63,192.02 187.63,191.85 v1(187.99,191.49)
  BOTTOM w0.102: 144.3,193.62 v2(144.3,193.95) ; 144.3,193.62 143.95,193.62 143.47,193.14 132.91,193.14 125.39,185.62 122.02,185.62 120.02,183.62 119.29,183.62 C562.2 ; 144.3,193.62 171.51,193.62 173.75,191.39 177.65,191.39 178.44,192.18 187.07,192.18 187.76,191.49 v1(187.99,191.49)
PEG_RX_CPU_P11: length 101.1
  TOP w0.102: CPU1.R6 v6(175.49,177.52)
  L6 w0.102: v6(175.49,177.52) 174.86,178.16 174.86,178.16 174.55,178.48 174.55,181.33 175.43,182.21 175.43,185.2 183.54,193.32 187.5,193.32 188.42,192.41 189.97,192.41 190.28,192.09 190.28,191.94 v1(190.73,191.49)
  BOTTOM w0.102: 142.11,193.83 142.65,193.83 143.54,194.72 171.39,194.72 174.03,192.07 177.24,192.07 178.31,193.14 187.43,193.14 188.15,192.43 189.8,192.43 190.2,192.03 190.2,192.02 v1(190.73,191.49) ; 142.11,193.83 132.63,193.83 125.49,186.69 124.68,186.69 C566.2 ; 142.11,193.83 v2(142.11,194.16)
PEG_RX_CPU_P12: length 118.8
  TOP w0.102: CPU1.T8 v6(173.52,175.45)
  L6 w0.102: v6(173.52,175.45) 173.86,176.25 173.91,176.3 173.91,176.78 174.32,177.19 174.33,177.22 174.33,182.94 174.82,183.43 174.82,184.95 174.82,185.46 183.31,193.95 187.17,193.95 187.91,194.69 191.67,194.69 192.95,193.41 192.95,191.88 v1(192.56,191.49)
  BOTTOM w0.102: 143.08,195.86 157.32,195.86 158.59,197.13 170.76,197.13 173.25,194.64 192.14,194.64 192.86,193.92 192.86,191.8 v1(192.56,191.49) ; 143.08,195.86 v2(143.08,195.53) ; 143.08,195.86 142.66,195.86 141.11,194.31 132.43,194.31 125.72,187.6 122.14,187.6 120.1,185.56 119.28,185.56 C570.2
PEG_RX_CPU_P13: length 68.7
  TOP w0.102: CPU1.T4 v6(173.5,179.5)
  L6 w0.102: v6(173.5,179.5) 173.63,179.63 173.63,179.65 173.62,179.67 173.62,187.39 173.62,188.33 173.36,188.59 173.2,188.59 172.98,188.81 172.98,188.97 172.77,189.18 172.61,189.18 172.39,189.4 172.39,189.56 172.18,189.77 172.02,189.77 171.8,189.99 171.8,190.15 170.23,191.72 159.59,191.72 157.34,193.97 145.17,193.97 142.48,196.65 142.2,196.65 141.38,197.47 138.35,197.47 138.24,197.36 137.93,197.36 137.82,197.47 137.52,197.47 137.41,197.36 137.1,197.36 136.99,197.47 136.69,197.47 136.57,197.36 136.27,197.36 136.16,197.47 135.85,197.47 134.95,196.57 132.93,196.57 132.59,196.23 132.59,196.13 v1(132.94,195.78)
  BOTTOM w0.102: v1(132.94,195.78) 132.46,195.3 131.83,195.3 131.62,195.08 131.62,194.94 131.4,194.73 131.26,194.73 131.05,194.51 131.05,194.37 130.83,194.16 130.69,194.16 130.17,193.63 130.17,193.02 126.94,189.8 126.33,189.8 125.99,189.45 ; 125.99,189.45 125.34,188.8 124.68,188.8 C574.2 ; 125.99,189.45 v2(126.24,189.2)
PEG_RX_CPU_P14: length 77.4
  TOP w0.102: CPU1.U7 v6(172.49,175.5)
  L6 w0.089: v6(172.49,175.5) 173.1,176.12 173.1,180.33 173.11,180.35 173.11,180.37
  L6 w0.102: v1(135.92,195.2) 136.31,195.59 136.31,196.1 136.93,196.72 141.27,196.72 141.95,196.04 142.15,196.04 144.84,193.36 156.58,193.36 158.92,191.02 169.63,191.02 173.01,187.64 173.01,187.46 173.01,183.72 173.11,183.62 173.11,180.37
  BOTTOM w0.102: v2(126.72,190.88) 126.48,191.12 ; 126.48,191.12 125.67,190.3 125.46,190.3 125.03,189.87 122.66,189.87 122.65,189.87 121.68,189.87 119.64,187.83 119.26,187.83 C578.2 ; 126.48,191.12 130.61,195.24 130.61,196.01 131.27,196.67 133.93,196.67 134.1,196.49 135.2,196.49 135.92,195.78 v1(135.92,195.2)
PEG_RX_CPU_P15: length 67.9
  TOP w0.102: CPU1.V6 v6(172.5,177.53)
  L6 w0.089: v6(172.5,177.53) 171.9,178.13 171.9,180.12 172.02,180.24 172.02,180.86 172.01,180.87 172.01,180.9
  L6 w0.102: v1(139.57,195.2) 139.57,195.58 139.67,195.68 140.84,195.68 141.73,194.79 141.93,194.79 144.44,192.28 155.83,192.28 158.29,189.81 169.26,189.81 171.82,187.26 171.82,183.63 172.14,183.3 172.34,183.11 172.34,182.37 172.01,182.04 172.01,180.9
  BOTTOM w0.102: 138.13,197.38 134.47,197.38 134.29,197.56 130.85,197.56 129.72,196.43 129.72,195.61 125.3,191.19 124.65,191.19 C582.2 ; 138.13,197.38 v2(138.13,197.74) ; 138.13,197.38 138.53,197.38 139.37,196.55 139.37,195.91 139.57,195.71 v1(139.57,195.2)
PEG_TX_CPU_N0: length 83.4
  TOP w0.102: v3(127.86,192.84) 127.58,193.1 ; 127.58,193.1 129.87,195.39 129.87,196.19 130.73,197.05 144.87,197.05 145.08,196.85 154.81,196.85 156.97,199.01 184.98,199.01 186.36,197.63 186.36,194.27 185.4,193.31 185.4,182.4 CPU1.E1 ; 127.58,193.1 125.46,190.99 124.66,190.99 C533.1
PEG_TX_CPU_N1: length 90.2
  TOP w0.102: v3(121.18,188.59) 120.91,188.87 ; 120.91,188.87 121.23,189.18 121.9,189.18 122.61,189.89 124.82,189.89 125.15,190.22 126.44,190.22 130.56,194.34 130.56,195.91 131.01,196.37 144.59,196.37 144.79,196.16 155.14,196.16 157.25,198.27 183.76,198.27 185.29,196.74 185.29,194.39 184.51,193.61 184.51,182.33 184.4,182.22 184.4,180.4 CPU1.F3 ; 120.91,188.87 119.9,187.85 119.25,187.85 C537.1
PEG_TX_CPU_N2: length 79.6
  TOP w0.102: CPU1.G2 183.4,181.4 183.4,182.39 183.31,182.48 183.31,183.22 183.82,183.73 183.82,193.34 182.52,194.64 182.52,196.71 181.65,197.59 157.58,197.59 156.08,196.09 156.04,196.09 155.43,195.48 144.51,195.48 144.3,195.68 142.27,195.68 ; v3(142.27,195.3) 142.27,195.68 ; 142.27,195.68 134.8,195.68 134.06,194.94 132.38,194.94 126.24,188.8 124.68,188.8 C540.1
PEG_TX_CPU_N3: length 81.7
  TOP w0.102: 125.73,188.01 126.41,188.01 132.66,194.26 142.58,194.26 143.11,194.79 156.06,194.79 158.17,196.9 178.43,196.9 182.65,192.68 182.65,184.05 182.4,183.8 182.4,182.4 CPU1.H1 ; 125.73,188.01 v3(125.73,187.6) ; 125.73,188.01 125.27,188.01 124.84,187.58 122.49,187.58 120.48,185.56 119.25,185.56 C544.1
PEG_TX_CPU_N4: length 76
  TOP w0.102: C524.1 124.68,186.49 125.86,186.49 132.95,193.57 142.86,193.57 143.39,194.11 170.59,194.11 172.25,195.76 178.4,195.76 180.92,193.24 180.92,189.03 181.5,188.45 181.5,187.88 ; 181.5,187.88 181.5,186.19 181.79,185.9 181.79,182.74 181.4,182.35 181.4,180.4 CPU1.J3 ; 181.5,187.88 v3(181.1,187.88)
PEG_TX_CPU_N5: length 79.6
  TOP w0.102: 141.86,192.89 133.23,192.89 125.79,185.45 122.49,185.45 120.46,183.42 119.27,183.42 C526.1 ; 141.86,192.89 v3(141.86,192.51) ; 141.86,192.89 143.14,192.89 143.68,193.42 171.64,193.42 173.29,195.07 177.87,195.07 180.24,192.7 180.24,187.09 180.4,186.93 180.4,181.4 CPU1.K2
PEG_TX_CPU_N6: length 71.9
  TOP w0.102: 128.09,186.54 133.76,192.2 139.01,192.2 139.85,191.36 142.59,191.36 143.96,192.74 171.94,192.74 173.59,194.39 177.51,194.39 179.4,192.5 179.4,182.4 CPU1.L1 ; 128.09,186.54 v3(128.37,186.26) ; 128.09,186.54 125.9,184.35 124.69,184.35 C550.1
PEG_TX_CPU_N7: length 74.3
  TOP w0.102: 141.38,189.81 141.38,190.27 141.78,190.68 142.88,190.68 144.25,192.05 173.14,192.05 178.4,186.79 178.4,180.4 CPU1.M3 ; 141.38,189.81 v3(141.78,189.81) ; 141.38,189.81 141.38,189.18 137.59,185.39 127.99,185.39 126.24,183.64 125.46,183.64 125.05,183.24 122.26,183.24 120.22,181.2 119.3,181.2 C529.1
PEG_TX_CPU_N8: length 65.5
  TOP w0.102: 125.58,182.17 124.62,182.17 124.35,181.9 C555.1 ; 125.58,182.17 126.07,182.17 126.89,183 127.03,183 127.25,183.21 127.25,183.35 127.46,183.57 127.6,183.57 127.82,183.78 127.82,183.92 128.03,184.14 128.17,184.14 128.39,184.35 128.39,184.49 128.61,184.71 137.88,184.71 144.53,191.36 172.74,191.36 177.32,186.78 177.32,182.4 177.4,182.32 177.4,181.4 CPU1.N2 ; 125.58,182.17 v3(125.58,181.79)
PEG_TX_CPU_N9: length 69.1
  TOP w0.102: v3(120.09,178.54) 120.09,178.93 ; 120.09,178.93 119.38,178.93 C559.1 ; 120.09,178.93 120.48,178.93 122.44,180.9 124.65,180.9 124.75,181 126.24,181 126.3,181.06 126.3,181.06 129.26,184.02 138.34,184.02 145,190.68 172.1,190.68 176.4,186.38 176.4,182.4 CPU1.P1
PEG_TX_CPU_N10: length 63.4
  TOP w0.102: C563.1 124.75,179.81 126.22,179.81 129.75,183.34 138.89,183.34 145.54,189.99 171.72,189.99 175.4,186.32 175.4,180.4 CPU1.R3
PEG_TX_CPU_N11: length 67.7
  TOP w0.102: 125.25,178.56 v3(125.25,178.18) ; 125.25,178.56 125.95,178.56 130.04,182.65 139.23,182.65 145.88,189.31 171.02,189.31 174.35,185.98 174.35,182.6 174.4,182.55 174.4,181.4 CPU1.T2 ; 125.25,178.56 122.89,178.56 120.88,176.56 119.39,176.56 C567.1
PEG_TX_CPU_N12: length 58.8
  TOP w0.102: CPU1.U1 173.4,182.4 173.4,185.19 169.97,188.62 146.17,188.62 139.51,181.97 130.32,181.97 125.5,177.14 124.55,177.14 C571.1
PEG_TX_CPU_N13: length 65.9
  TOP w0.102: C575.1 119.36,174.26 120.55,174.26 121.24,174.95 ; v3(121.51,174.68) 121.24,174.95 ; 121.24,174.95 122.13,175.84 125.17,175.84 130.61,181.28 139.8,181.28 146.27,187.75 169.8,187.75 172.4,185.15 172.4,180.4 CPU1.V3
PEG_TX_CPU_N14: length 57.5
  TOP w0.102: 131.37,180.59 140.33,180.59 140.64,180.9 140.64,180.9 146.5,186.76 169.5,186.76 171.4,184.85 171.4,183.03 171.32,182.95 171.32,182.45 171.4,182.37 171.4,181.4 CPU1.W2 ; 131.37,180.59 130.91,180.59 125.07,174.75 124.54,174.75 124.53,174.76 C579.1 ; 131.37,180.59 v3(131.37,180.21)
PEG_TX_CPU_N15: length 62.2
  TOP w0.102: 120.22,171.81 119.49,171.81 C583.1 ; 120.22,171.81 120.48,171.81 120.94,172.26 123.57,172.26 124.96,173.66 125.1,173.66 125.32,173.87 125.32,174.01 125.53,174.23 125.67,174.23 125.89,174.44 125.89,174.58 130.56,179.25 131.67,179.25 132.33,179.91 132.99,179.91 133.09,179.81 133.39,179.81 133.49,179.91 133.8,179.91 133.9,179.81 134.2,179.81 134.3,179.91 134.61,179.91 134.7,179.81 135.01,179.81 135.11,179.91 141.12,179.91 144.93,183.72 145.95,183.72 146.43,184.2 146.57,184.2 146.79,184.42 146.79,184.56 147,184.77 147.14,184.77 147.36,184.99 147.36,185.13 147.57,185.34 147.71,185.34 147.93,185.56 147.93,185.7 148.23,186 156.9,186 157,185.91 157.31,185.91 157.41,186 157.71,186 157.81,185.91 158.11,185.91 158.21,186 158.52,186 158.62,185.91 158.92,185.91 159.02,186 165.89,186 165.99,185.91 166.29,185.91 166.39,186 166.7,186 166.8,185.91 167.1,185.91 167.2,186 167.51,186 167.6,185.91 167.91,185.91 168.01,186 169.05,186 170.4,184.66 170.4,182.4 CPU1.Y1 ; 120.22,171.81 v3(120.22,171.42)
PEG_TX_CPU_P0: length 83.7
  TOP w0.102: v3(128.07,194.44) 128.35,194.16 ; 128.35,194.16 129.67,195.48 129.67,196.28 130.64,197.26 144.96,197.26 145.16,197.05 154.73,197.05 156.89,199.21 185.06,199.21 186.56,197.71 186.56,194.18 185.6,193.22 185.6,182.4 CPU1.D1 ; 128.35,194.16 125.38,191.19 124.66,191.19 C531.1
PEG_TX_CPU_P1: length 90.6
  TOP w0.102: v3(129.62,194.26) 129.9,193.97 ; 129.9,193.97 126.36,190.42 125.07,190.42 124.74,190.09 122.53,190.09 121.82,189.38 121.14,189.38 119.81,188.05 119.25,188.05 C535.1 ; 129.9,193.97 130.35,194.42 130.35,195.99 130.93,196.57 144.67,196.57 144.88,196.37 155.06,196.37 157.17,198.48 183.85,198.48 185.5,196.82 185.5,194.31 184.71,193.52 184.71,182.25 184.6,182.14 184.6,180.4 CPU1.E3
PEG_TX_CPU_P2: length 80.4
  TOP w0.102: 125.4,189.01 124.68,189.01 C521.1 ; 125.4,189.01 126.15,189.01 126.47,189.32 126.47,189.46 126.68,189.68 126.82,189.68 127.04,189.89 127.04,190.03 127.25,190.25 127.39,190.25 127.61,190.46 127.61,190.6 127.82,190.82 127.96,190.82 130.58,193.43 130.58,193.57 130.8,193.79 130.94,193.79 131.15,194.01 131.15,194.15 131.37,194.36 131.51,194.36 131.72,194.58 131.72,194.72 131.94,194.93 132.08,194.93 132.29,195.15 133.98,195.15 134.71,195.88 144.39,195.88 144.59,195.68 155.34,195.68 155.95,196.29 156,196.29 157.5,197.79 181.74,197.79 182.73,196.8 182.73,194.72 184.02,193.43 184.02,183.64 183.51,183.13 183.51,182.56 183.6,182.48 183.6,181.4 CPU1.F2 ; 125.4,189.01 v3(125.4,189.41)
PEG_TX_CPU_P3: length 82.2
  TOP w0.102: 182.85,187.88 182.85,192.76 178.51,197.1 158.08,197.1 155.97,195 143.02,195 142.49,194.46 132.58,194.46 126.33,188.21 125.19,188.21 124.76,187.78 122.41,187.78 122.19,187.57 122.05,187.57 121.84,187.35 121.84,187.21 121.54,186.91 121.4,186.91 121.18,186.69 121.18,186.55 120.96,186.34 120.82,186.34 120.61,186.12 120.61,185.98 120.39,185.77 119.25,185.77 C542.1 ; 182.85,187.88 v3(183.24,187.88) ; 182.85,187.88 182.85,183.96 182.6,183.71 182.6,182.4 CPU1.G1
PEG_TX_CPU_P4: length 76.3
  TOP w0.102: v3(181.53,189.59) 181.13,189.59 ; 181.13,189.59 181.13,189.11 181.71,188.53 181.71,186.27 181.99,185.99 181.99,182.65 181.6,182.26 181.6,180.4 CPU1.H3 ; 181.13,189.59 181.13,193.32 178.49,195.96 172.16,195.96 170.51,194.31 143.31,194.31 142.78,193.78 132.86,193.78 125.78,186.69 124.68,186.69 C522.1
PEG_TX_CPU_P5: length 80
  TOP w0.102: CPU1.J2 180.6,181.4 180.6,187.01 180.44,187.17 180.44,192.79 177.95,195.28 173.2,195.28 171.55,193.62 143.59,193.62 143.06,193.09 133.15,193.09 125.7,185.65 122.4,185.65 120.38,183.62 119.96,183.62 ; C525.1 119.27,183.62 119.96,183.62 ; 119.96,183.62 v3(119.96,184.02)
PEG_TX_CPU_P6: length 73.2
  TOP w0.102: v3(140.39,191.95) 140.39,191.57 ; 140.39,191.57 142.51,191.57 143.88,192.94 171.86,192.94 173.51,194.59 177.6,194.59 179.6,192.58 179.6,191.49 179.7,191.39 179.7,191.09 179.6,190.99 179.6,190.68 179.7,190.58 179.7,190.28 179.6,190.18 179.6,185.1 179.7,185 179.7,184.7 179.6,184.6 179.6,184.29 179.7,184.19 179.7,183.89 179.6,183.79 179.6,183.49 179.7,183.39 179.7,183.08 179.6,182.98 179.6,182.4 CPU1.K1 ; 140.39,191.57 139.94,191.57 139.1,192.41 133.67,192.41 132.75,191.48 132.75,191.48 132.62,191.35 132.48,191.35 132.26,191.14 132.26,191 132.05,190.78 131.91,190.78 131.69,190.57 131.69,190.43 131.48,190.21 131.34,190.21 131.12,189.99 131.12,189.85 129.24,187.98 129.1,187.98 128.89,187.76 128.89,187.62 127.53,186.26 127.39,186.26 127.17,186.05 127.17,185.91 126.96,185.69 126.82,185.69 126.6,185.48 126.6,185.33 126.39,185.12 126.25,185.12 126.03,184.9 126.03,184.76 125.82,184.55 124.69,184.55 C527.1
PEG_TX_CPU_P7: length 74.8
  TOP w0.102: CPU1.L3 178.6,180.4 178.6,186.88 173.23,192.25 144.16,192.25 142.79,190.88 141.7,190.88 141.17,190.36 141.17,189.26 137.51,185.6 133.46,185.6 133.36,185.7 133.06,185.7 132.96,185.6 132.66,185.6 132.56,185.7 132.25,185.7 132.15,185.6 131.85,185.6 131.75,185.7 131.44,185.7 131.34,185.6 130.53,185.6 ; 130.53,185.6 127.91,185.6 126.15,183.85 125.37,183.85 124.97,183.44 122.17,183.44 120.13,181.4 119.3,181.4 C551.1 ; 130.53,185.6 v3(130.53,185.98)
PEG_TX_CPU_P8: length 65.5
  TOP w0.102: 126.39,182.78 125.98,182.38 124.7,182.38 C530.1 ; 126.39,182.78 128.52,184.91 137.79,184.91 144.45,191.57 172.82,191.57 177.52,186.87 177.52,182.48 177.6,182.4 177.6,181.4 CPU1.M2 ; 126.39,182.78 v3(126.11,183.06)
PEG_TX_CPU_P9: length 69.5
  TOP w0.102: 122.45,181.1 122.36,181.1 120.39,179.14 119.38,179.14 C557.1 ; 122.45,181.1 v3(122.45,181.51) ; 122.45,181.1 124.56,181.1 124.66,181.2 126.15,181.2 129.18,184.23 138.26,184.23 144.91,190.88 172.19,190.88 176.6,186.47 176.6,182.4 CPU1.N1
PEG_TX_CPU_P10: length 65.5
  TOP w0.102: CPU1.P3 175.6,180.4 175.6,186.4 171.81,190.2 145.46,190.2 145.03,189.77 144.89,189.77 144.68,189.56 144.68,189.42 144.46,189.2 144.32,189.2 144.11,188.99 144.11,188.85 143.94,188.68 143.8,188.68 143.59,188.47 143.59,188.33 143.37,188.11 143.23,188.11 143.01,187.89 143.01,187.75 142.8,187.54 142.66,187.54 142.44,187.32 142.44,187.18 142.23,186.97 142.09,186.97 141.87,186.75 141.87,186.61 141.66,186.4 141.52,186.4 141.3,186.18 141.3,186.04 141.09,185.83 140.95,185.83 140.73,185.61 140.73,185.47 140.51,185.25 140.37,185.25 140.16,185.04 140.16,184.9 139.94,184.68 139.8,184.68 139.59,184.47 139.59,184.33 139.37,184.11 139.23,184.11 139.02,183.9 139.02,183.76 138.8,183.54 129.66,183.54 129.56,183.44 129.42,183.44 129.21,183.23 129.21,183.09 128.99,182.87 128.85,182.87 128.64,182.65 128.64,182.51 128.42,182.3 128.28,182.3 128.07,182.08 128.07,181.94 127.85,181.73 127.71,181.73 127.5,181.51 127.5,181.37 127.28,181.16 127.14,181.16 126.92,180.94 126.92,180.8 126.71,180.59 126.57,180.59 126.35,180.37 126.35,180.23 126.14,180.01 125.53,180.01 ; 125.53,180.01 124.75,180.01 C561.1 ; 125.53,180.01 v3(125.53,180.42)
PEG_TX_CPU_P11: length 68.3
  TOP w0.102: CPU1.R2 174.6,181.4 174.6,182.63 174.55,182.69 174.55,186.06 171.1,189.51 145.8,189.51 139.14,182.85 129.95,182.85 125.86,178.77 125.56,178.77 125.46,178.86 125.15,178.86 125.05,178.77 124.75,178.77 124.65,178.86 124.35,178.86 124.25,178.77 123.94,178.77 123.84,178.86 123.54,178.86 123.44,178.77 122.8,178.77 120.8,176.76 120.27,176.76 ; 120.27,176.76 119.4,176.76 C565.1 ; 120.27,176.76 v3(120.27,177.14)
PEG_TX_CPU_P12: length 59.6
  TOP w0.102: 171.15,187.73 170.05,188.82 146.08,188.82 139.43,182.17 130.24,182.17 125.41,177.35 124.57,177.35 C569.1 ; 171.15,187.73 v3(171.42,188.01) ; 171.15,187.73 173.6,185.28 173.6,182.4 CPU1.T1
PEG_TX_CPU_P13: length 66.4
  TOP w0.102: 120.07,174.46 120.46,174.46 122.05,176.05 125.09,176.05 130.52,181.48 139.71,181.48 146.18,187.95 169.89,187.95 172.6,185.23 172.6,184.93 172.7,184.83 172.7,184.53 172.6,184.43 172.6,184.12 172.7,184.02 172.7,183.72 172.6,183.62 172.6,180.4 CPU1.U3 ; 120.07,174.46 119.36,174.46 C573.1 ; 120.07,174.46 v3(120.07,174.85)
PEG_TX_CPU_P14: length 58
  TOP w0.102: C577.1 124.62,174.96 124.99,174.96 130.83,180.8 140.25,180.8 140.75,181.3 140.75,181.44 140.97,181.65 141.11,181.65 141.32,181.87 141.32,182.01 141.54,182.22 141.68,182.22 141.89,182.44 141.89,182.58 142.11,182.8 142.25,182.8 142.46,183.01 142.46,183.15 142.68,183.37 142.82,183.37 146.41,186.96 167.24,186.96 167.34,187.06 167.64,187.06 167.74,186.96 168.05,186.96 168.15,187.06 168.45,187.06 168.55,186.96 169.58,186.96 171.6,184.94 171.6,182.95 171.53,182.87 171.53,182.53 171.6,182.46 171.6,181.4 CPU1.V2
PEG_TX_CPU_P15: length 61.4
  TOP w0.102: C581.1 119.49,172.01 120.4,172.01 120.85,172.47 123.49,172.47 123.9,172.88 ; 123.9,172.88 v3(123.62,173.15) ; 123.9,172.88 130.47,179.45 131.59,179.45 132.25,180.11 141.03,180.11 144.84,183.92 145.86,183.92 148.15,186.21 169.14,186.21 170.6,184.74 170.6,182.4 CPU1.W1
PEX_CLKREQ_R: length 6.9
  TOP w0.114: GPU1.AV41 87.21,166.2 87.66,166.65 v3(92.2,166.65) 92.58,166.65 92.8,166.87 R496.1
PGOOD_NB: length 8.6
  TOP w0.114: D7.2 214.25,227.98 214.54,228.27 R375.2 PR78.2 215.51,226.82 215.26,226.58 v1(215.26,226.42)
  BOTTOM w0.114: PU6.42 214.3,223.62 214.35,223.67 214.35,224.38 214.91,224.94 v2(214.91,225.44) 214.91,225.91 215.26,226.26 v1(215.26,226.42)
PGVDD1: length 5.9
  TOP w0.114: U8.6 201.1,25 201.17,25.08 202.11,25.08 R325.1 202.39,24.8 v3(203.71,24.8) 204.23,25.32 R324.2
PLT_RST#_APU: length 156.3
  TOP w0.114: v1(99.36,58.67) 99.24,58.67 99.16,58.6 R2440.2
  L4 w0.114: v1(152.6,81.53) 148.97,81.53 144.73,85.78 144.72,85.78 144.16,86.33 143.59,86.33 140.1,89.82 140.1,95.73 141.19,96.82 141.19,103.94 141.78,104.53 141.78,122.4 140.87,123.32 140.87,125.12 141.5,125.75 141.5,141.88 138.14,145.25 138.14,148.07 v1(137.49,148.72)
  BOTTOM w0.114: v1(137.49,148.72) 137.81,149.03 R69.1 ; v1(152.6,81.53) 152.6,81.24 148.79,77.42 124.97,77.42 123.34,79.04 123.34,80.62 122.66,81.31 121.14,81.31 LPC1.3 118.2,78.37 111.99,78.37 109.02,75.39 109.02,73.36 107.67,72.01 104.72,72.01 101.55,68.83 101.55,66.62 100.48,65.56 98.6,65.56 97.76,64.72 97.76,63.07 98.11,62.72 98.71,62.72 99.32,62.11 v5(99.9,62.11) 100.08,61.93 100.08,59.82 99.36,59.11 v1(99.36,58.67)
PLT_RST#_R: length 27.4
  TOP w0.114: v6(152.53,161.47) 153,161 CPU1.AU22
  L6 w0.102: v6(152.53,161.47) 152.53,161.47 150.9,161.47 149.5,160.07 145.75,160.07 142.77,157.1 141.83,157.1 140.54,155.8 139.7,155.8 137.03,153.14 137.03,149.96 v1(137.52,149.48)
  BOTTOM w0.114: v6(152.53,161.47) 152.12,161.06 TP97.1 ; C21.1 136.64,149.01 137.03,149.4 137.44,149.4 v1(137.52,149.48) 137.96,149.92 R69.2
PLTRST#_EC_R: length 8.3
  TOP w0.114: KBC1.7 101.07,56.94 v1(100.53,57.48) 99.75,57.48 99.35,57.87 97.96,57.87 97.68,58.15 R2440.1
  BOTTOM w0.114: C1020.1 101.54,56.49 100.76,56.49 v5(100.71,56.54) 100.53,56.72 v1(100.53,57.48)
PLTRST_LAN_N: length 134.8
  TOP w0.114: RN48.4 106.1,81.76 105.82,82.04 105.46,82.04 104.65,81.23 v1(104.62,81.23) ; LAUOC1.22 v1(133.75,6.22)
  L4 w0.114: v1(104.62,81.23) 104.62,81.01 100.51,76.89 100.51,76.55 100.51,76.55 100.51,68.71 101.9,67.32 101.9,65.82 107.95,59.77 108.24,59.77 108.52,59.5 108.52,58.07 109.45,57.14 109.45,55.19 109.73,54.91 111.12,54.91 111.44,54.6 111.44,52.68 110.52,51.76 110.52,48.52 110.22,48.22 109.91,48.22 109.63,47.94 109.02,47.94 105.73,44.65 105.73,44.26 105.66,44.2 105.66,43.04 104.65,42.03 104.65,41.22 100.69,37.25 100.69,36.78 98.76,34.86 95.34,34.86 94.14,33.65 94.14,21 94.34,20.8 94.34,13.23 93.62,12.52 93.62,10.46 94.34,9.75 103.18,9.75 104.25,8.68 104.25,7.81 104.85,7.21 109.66,7.21 111.13,5.74 133.27,5.74 v1(133.75,6.22)
  BOTTOM w0.114: v1(133.75,6.22) v2(133.75,7.04)
PLTRST_N_1: length 11.2
  TOP w0.114: RN48.1 106.1,80.32 106.1,79.73 106.25,79.58 106.53,79.58 106.75,79.8 RN48.2 107.91,80.33 R2539.1 108.14,79.01 v3(108,78.87) 108.95,77.91 R235.2 110.53,77.24 112.98,77.24 113.57,77.84 U3.4
PLTRST_SSD: length 16.2
  TOP w0.114: R2539.2 108.14,81.85 v1(108.25,81.97) ; SSDC1.50 109.5,94.27 109.5,92.56 109.35,92.41 109.35,90.55 108.48,89.69 108.11,89.69 107.73,89.3 107.73,87.34 108.84,86.23 v3(108.84,85.34) 108.84,83.93 109.82,82.94 v1(109.82,82.93)
  BOTTOM w0.114: v1(108.25,81.97) 108.86,81.97 v1(109.82,82.93)
PM_DEBUG_ENABLE: length 4.2
  TOP w0.114: R151.2 170.59,58.2 v3(170.59,57.12) 170.59,54.59 PCH1.B25
PM_GPIO0_X16_PRSNT: length 8.6
  TOP w0.114: R35.1 v3(149.84,60.16) 150.37,59.63 150.37,54.83 PCH1.B1
PM_GPIO1_PCIEX16_DET0: length 8.3
  TOP w0.114: PCH1.B4 153.01,54.59 153.01,56.11 152.91,56.21 152.91,58.04 v3(152.93,58.06) 152.91,58.09 152.91,60.13 R36.1
PM_GPIO2_PCIEX16_DET1: length 4.2
  TOP w0.114: PCH1.C6 v6(154.6,53.8)
  BOTTOM w0.114: R82.1 153.42,56.07 154.44,55.04 154.46,55.04 v5(154.58,54.91) 154.58,53.82 v6(154.6,53.8)
PM_GPIO3_PCIEX16_DET2: length 7.7
  TOP w0.114: PCH1.B6 154.66,54.54 154.66,56.49 154.66,56.5 154.66,56.82 154.86,57.03 v3(154.86,60.31) 154.86,61.61 R40.1
PM_GPIO4_SSD_DET: length 96.6
  TOP w0.114: PCH1.A6 155,56.68 155.68,57.36 155.68,61.7 157.33,63.35 160.48,63.35 165.85,68.73 165.85,81.64 165.15,82.35 165.15,83.49 165.4,83.74 v1(165.56,83.74) ; R2601.1 118.14,104.33 Q35.C 118.87,103.59 v1(118.87,103.2)
  BOTTOM w0.114: v1(118.87,103.2) 121.75,103.2 v2(121.83,103.28) 122.91,103.28 127.56,98.63 127.56,96.26 131.02,92.8 134.85,92.8 135.08,92.57 143.98,92.57 148.79,87.76 152.3,87.76 155.35,84.71 156.08,84.71 156.62,84.18 161.06,84.18 161.65,83.59 165.4,83.59 v1(165.56,83.74)
PM_GPIO_R0: length 7.3
  TOP w0.114: R155.2 149.48,61.59 151,60.07 v3(151,58.65) PCH1.A1
PM_GPIO_R1: length 10.5
  TOP w0.114: PCH1.B3 152.21,54.59 152.21,55.41 151.64,55.98 v3(151.64,57.4) 151.64,59.94 150.37,61.21 150.37,63.16 R156.2
PM_GPIO_R2: length 4.4
  TOP w0.114: PCH1.C4 v6(153,53.8)
  BOTTOM w0.114: R157.2 151.38,55.61 151.62,55.37 v5(151.64,55.37) 151.64,55.36 153,54 v6(153,53.8)
PM_GPIO_R3: length 9.5
  TOP w0.114: R158.2 150.75,63.31 150.75,61.34 v3(152.27,59.82) 152.27,56.24 152.6,55.9 PCH1.A3
PM_GPIO_R4: length 4.8
  TOP w0.114: R122.2 R123.2 169.39,58.2 169.39,57.55 v3(168.86,57.02) 168.86,56.26 169.39,55.73 169.39,55.01 PCH1.A24
PM_GPIO_R5: length 6.3
  TOP w0.114: R126.2 R125.2 v3(173.05,57.15) 173.03,57.15 171,55.12 PCH1.A26
PM_GPIO_R6: length 7.1
  TOP w0.114: PCH1.E25 170.65,52.25 171.3,52.25 171.86,52.81 v1(172.82,52.81)
  BOTTOM w0.114: v1(172.82,52.81) 173.15,53.14 R129.2 174.32,53.17 R127.2 173.53,54.19 v2(173.09,54.64)
PM_GPIO_R7: length 4.5
  TOP w0.114: PCH1.B26 171.73,54.93 v3(173.1,54.93) R132.2 175.13,54.93 R133.2
PM_GPIO_R8: length 7.1
  TOP w0.114: PCH1.F24 v6(169.8,51.4)
  BOTTOM w0.114: v6(169.8,51.4) 170.95,51.4 v2(171.91,52.35) 173.94,52.35 174.41,51.88 R136.2 174.41,51.28 174.18,51.05 R135.2
PM_GPIO_R9: length 8.3
  TOP w0.114: PCH1.E22 v6(168.2,51.4)
  BOTTOM w0.114: R139.2 173.95,48.39 R138.2 171.64,49.53 169.47,49.53 v2(168.96,50.04) 168.96,50.66 168.22,51.4 v6(168.2,51.4)
PM_GPIO_R11: length 7
  TOP w0.114: PCH1.F23 v6(169,51.4)
  BOTTOM w0.114: R150.2 172.57,49.38 v2(172.24,49.71) 172.16,49.78 170.03,49.78 169.21,50.6 169.21,51.19 v6(169,51.4)
PM_GPIO_R12: length 101.3
  TOP w0.114: PCH1.F26 v6(170.6,50.6) ; v1(168.35,62.2) 170.56,64.41 v1(171.81,64.41) ; R438.2 111.68,87.77 v1(112.03,87.77)
  L3 w0.114: v1(155.09,82.63) 155.09,82.85 155.63,83.39 161.17,83.39 162.11,82.45 165.01,82.45 165.02,82.44 165.47,82.44 165.85,82.06 166.22,82.06 171.2,77.09 171.2,65.35 171.81,64.74 v1(171.81,64.41)
  L4 w0.114: v6(170.6,50.6) 170.6,51.98 171.07,52.45 171.07,56.59 169.16,58.5 169.16,61.09 168.35,61.9 v1(168.35,62.2)
  BOTTOM w0.114: v1(112.03,87.77) 112.12,87.68 v5(114.07,87.68) 114.27,87.88 117.12,87.88 122,92.76 128.74,92.76 130.34,91.16 134.17,91.16 134.4,90.93 143.28,90.93 148.11,86.11 151.58,86.11 155.06,82.63 v1(155.09,82.63)
PM_GPP_INT_PCI_WAKE: length 50.1
  TOP w0.114: R159.2 175.12,34.11 173.7,34.11 173.69,34.12 ; PCH1.AE26 172.68,34.12 173.69,34.12 ; 173.69,34.12 v1(173.69,34.14)
  L4 w0.114: v1(152.86,22.76) 153.04,22.57 153.07,22.57 153.57,22.07 154.69,22.07 155.19,22.57 156.69,22.57 157.25,23.14 161.8,23.14 161.82,23.11 v1(163.86,23.11)
  L6 w0.102: v1(163.86,23.11) 163.86,27.1 169.73,32.97 171.27,32.97 172.44,34.14 v1(173.69,34.14)
  BOTTOM w0.114: v1(152.86,22.76) 152.86,28.44 v5(152.5,28.8) 151.88,29.41 151.88,31.92 150.12,33.68 148.79,33.68 147.46,35.01 R160.2
PM_IFDET0: length 6.8
  TOP w0.114: PCH1.C8 156.6,53.71 156.21,54.1 156.21,56.07 158.04,57.9 v3(158.04,58.01) 158.04,58.57 158.24,58.78 R147.2
PM_IFDET1: length 4.8
  TOP w0.114: R149.2 157.1,57.81 v3(156.74,57.45) 156.38,57.09 156.38,57.08 155.8,56.51 PCH1.A7
PM_INT: length 4.6
  TOP w0.114: U1.S v3(165.45,57.13) 165.45,56.55 PCH1.A21
PM_PCIE_RST: length 164.8
  TOP w0.114: v6(158.59,36.97) 158.59,37.01 PCH1.AC10 ; U3.2 110.39,78.49 110.07,78.8 R235.1 ; v1(158.7,30.2) 158.94,29.96 162.29,29.96 v3(162.31,29.97) 163.22,29.06 168.25,29.06 171.07,26.24 v1(178.05,26.24) ; U3.1 110.1,79.14 109.86,78.89 R235.1 ; R235.1 109.39,78.8 v1(109.04,79.15)
  L6 w0.102: v1(109.04,79.15) 109.63,79.73 111.12,79.73 112.65,81.25 124.43,81.25 131.37,74.32 132.35,74.32 161.4,74.32 161.96,74.88 171.02,74.88 171.44,74.46 178.74,74.46 184.81,68.39 184.81,44.37 182.4,41.96 182.4,36.5 181.28,35.38 181.28,34.82 181.91,34.19 181.91,31.17 180.77,30.02 179.3,30.02 178.16,28.88 178.16,26.35 v1(178.05,26.24)
  BOTTOM w0.114: v1(158.7,30.2) 159.63,31.13 R153.2 160.1,31.2 C207.2 159.69,32.58 159.07,32.58 158.27,33.38 158.27,34.15 158.14,34.27 158.14,35.59 158.6,36.04 158.6,36.96 v6(158.59,36.97)
PM_PCIE_WAKE#: length 260.7
  TOP w0.114: v1(133.58,8.15) 133.25,7.82 LAUOC1.21 ; v1(154.33,22.57) 160.99,22.57 v1(163.35,20.22) ; R1220.2 R1219.1 v1(195.82,58.78) ; v1(168.66,76.23) 168.91,76.48 176.99,76.48 180.59,80.09 195.02,80.09 v1(195.17,80.24) ; v1(112.01,88.65) 111.91,88.75 R439.2
  L3 w0.114: v1(156.03,82.65) 156.33,82.96 157.86,82.96 157.91,82.91 161.06,82.91 161.94,82.03 163.73,82.03 168.66,77.1 v1(168.66,76.23) 168.66,66.91 178.44,57.13 178.44,45.09 183.26,40.26 183.26,31.5 181.1,29.34 178.94,29.34 173.48,23.88 168.33,23.88 166.24,21.79 164.92,21.79 v1(163.35,20.22)
  L4 w0.114: v1(133.58,8.15) 134.35,8.93 135.83,8.93 136.21,9.31 141.14,9.31 143.75,11.93 150.11,11.93 151.19,13 154.31,13 161.52,20.22 v1(163.35,20.22)
  BOTTOM w0.114: R162.1 R160.1 146.57,35.09 148.34,33.32 149.99,33.32 151.54,31.78 151.54,27.48 152.38,26.64 152.38,22.55 152.65,22.28 154.03,22.28 154.32,22.57 v1(154.33,22.57) ; v1(195.82,58.78) 195.82,60.24 v5(195.12,60.94) 194.56,61.5 194.56,65.82 195.3,66.56 195.3,80.11 v1(195.17,80.24) ; v1(156.03,82.65) 155.57,83.11 155.09,83.11 151.74,86.46 148.26,86.46 143.44,91.27 134.54,91.27 134.31,91.5 130.49,91.5 128.89,93.1 121.83,93.1 117.09,88.36 112.3,88.36 v1(112.01,88.65)
