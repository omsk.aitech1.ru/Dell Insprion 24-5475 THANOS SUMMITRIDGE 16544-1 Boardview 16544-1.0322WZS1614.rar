# Allegro board 16544-1.0322WZS1614.brd (continued)
## Nets (continued)
1D35V_MEM_VGA: C683.1 C685.1 C696.1 C697.1 C698.1 C699.1 C708.1 C709.1 C710.1 C711.1 C712.1 C713.1 C714.1 C715.1 C722.1 C730.1 C731.1 C733.1 C734.1 C750.1 C751.1 C752.1 C753.1 C754.1 C755.1 C756.1 C757.1 C758.1 C759.1 C760.1 C761.1 C762.1 C763.1 C764.1 C765.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C776.1 C777.1 C778.1 C779.1 C780.1 C781.1 C782.1 C784.1 C785.1 C786.1 C787.1 C788.1 C789.1 C790.1 C791.1 C792.1 C793.1 C794.1 C795.1 C796.1 C797.1 C798.1 C799.1 C801.1 C802.1 C803.1 C804.1 C805.1 C806.1 C807.1 C808.1 C809.1 C810.1 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C830.1 C831.1 C832.1 C833.1 C834.1 C835.1 C836.1 C837.1 C838.1 C839.1 C840.1 C841.1 C842.1 C843.1 C844.1 C845.1 C846.1 C847.1 C848.1 C849.1 C850.1 C851.1 C852.1 C853.1 C854.1 C855.1 C857.1 C858.1 C859.1 C860.1 C861.1 C862.1 C863.1 C864.1 C865.1 C866.1 C867.1 C868.1 C869.1 C870.1 C871.1 C872.1 C874.1 C875.1 C876.1 C877.1 C878.1 C879.1 C880.1 C881.1 C882.1 C883.1 C884.1 C885.1 C886.1 C887.1 C888.1 C889.1 C891.1 C892.1 C893.1 C894.1 C895.1 C896.1 C897.1 C898.1 C899.1 C900.1 C901.1 C902.1 C903.1 C904.1 C905.1 C906.1 C1108.1 C1109.1 C1110.1 C1111.1 C1112.1 C1113.1 C1114.1 C1115.1 GPU1.AC9 GPU1.AD11 GPU1.AE7 GPU1.AE13 GPU1.AF9 GPU1.AG5 GPU1.AG11 GPU1.AJ7 GPU1.AJ13 GPU1.AK9 GPU1.AK14 GPU1.AL15 GPU1.AL19 GPU1.AM5 GPU1.AN7 GPU1.AN17 GPU1.AN20 GPU1.AR14 GPU1.AR18 GPU1.AU11 GPU1.AU15 GPU1.AW12 GPU1.AW17 GPU1.E6 GPU1.E12 GPU1.E17 GPU1.E20 GPU1.E27 GPU1.E32 GPU1.F5 GPU1.G11 GPU1.G15 GPU1.G19 GPU1.G25 GPU1.G29 GPU1.G33 GPU1.J14 GPU1.J18 GPU1.J23 GPU1.J26 GPU1.J30 GPU1.L17 GPU1.L20 GPU1.L24 GPU1.L27 GPU1.L37 GPU1.M5 GPU1.M12 GPU1.M39 GPU1.N15 GPU1.N19 GPU1.N25 GPU1.N29 GPU1.P14 GPU1.P30 GPU1.P35 GPU1.R7 GPU1.R13 GPU1.R31 GPU1.R37 GPU1.U5 GPU1.U11 GPU1.U33 GPU1.U39 GPU1.V9 GPU1.V35 GPU1.W7 GPU1.W13 GPU1.W31 GPU1.Y11 GPU1.Y33 PG198.2 PG199.2 PG202.2 PG203.2 PG205.2 PG206.2 PG207.2 PG238.2 PG239.2 PG240.2 PG241.2 PG242.2 PG243.2 PG244.2 PG245.2 PG246.2 PG247.2 R611.1 R613.1 R619.1 R620.1 R628.2 R629.2 R630.2 R631.2 R632.2 R633.2 R639.2 R643.2 R644.2 R645.2 R661.2 R662.2 R665.2 R666.2 R672.2 R673.2 R674.2 R675.2 R676.2 R677.2 R684.2 R687.2 R688.2 R691.2 R705.2 R706.2 R709.2 R710.2 TC4.1 TC5.1 TC6.1 VRAMA1.B1 VRAMA1.B3 VRAMA1.B12 VRAMA1.B14 VRAMA1.C5 VRAMA1.C10 VRAMA1.D1 VRAMA1.D3 VRAMA1.D11 VRAMA1.D12 VRAMA1.D14 VRAMA1.E5 VRAMA1.E10 VRAMA1.F1 VRAMA1.F3 VRAMA1.F12 VRAMA1.F14 VRAMA1.G1 VRAMA1.G2 VRAMA1.G4 VRAMA1.G11 VRAMA1.G13 VRAMA1.G14 VRAMA1.H3 VRAMA1.H12 VRAMA1.K3 VRAMA1.K12 VRAMA1.L1 VRAMA1.L2 VRAMA1.L4 VRAMA1.L11 VRAMA1.L13 VRAMA1.L14 VRAMA1.M1 VRAMA1.M3 VRAMA1.M12 VRAMA1.M14 VRAMA1.N5 VRAMA1.N10 VRAMA1.P1 VRAMA1.P3 VRAMA1.P11 VRAMA1.P12 VRAMA1.P14 VRAMA1.R5 VRAMA1.R10 VRAMA1.T1 VRAMA1.T3 VRAMA1.T12 VRAMA1.T14 VRAMA2.B1 VRAMA2.B3 VRAMA2.B12 VRAMA2.B14 VRAMA2.C5 VRAMA2.C10 VRAMA2.D1 VRAMA2.D3 VRAMA2.D11 VRAMA2.D12 VRAMA2.D14 VRAMA2.E5 VRAMA2.E10 VRAMA2.F1 VRAMA2.F3 VRAMA2.F12 VRAMA2.F14 VRAMA2.G1 VRAMA2.G2 VRAMA2.G4 VRAMA2.G11 VRAMA2.G13 VRAMA2.G14 VRAMA2.H3 VRAMA2.H12 VRAMA2.K3 VRAMA2.K12 VRAMA2.L1 VRAMA2.L2 VRAMA2.L4 VRAMA2.L11 VRAMA2.L13 VRAMA2.L14 VRAMA2.M1 VRAMA2.M3 VRAMA2.M12 VRAMA2.M14 VRAMA2.N5 VRAMA2.N10 VRAMA2.P1 VRAMA2.P3 VRAMA2.P11 VRAMA2.P12 VRAMA2.P14 VRAMA2.R5 VRAMA2.R10 VRAMA2.T1 VRAMA2.T3 VRAMA2.T12 VRAMA2.T14 VRAMB1.B1 VRAMB1.B3 VRAMB1.B12 VRAMB1.B14 VRAMB1.C5 VRAMB1.C10 VRAMB1.D1 VRAMB1.D3 VRAMB1.D11 VRAMB1.D12 VRAMB1.D14 VRAMB1.E5 VRAMB1.E10 VRAMB1.F1 VRAMB1.F3 VRAMB1.F12 VRAMB1.F14 VRAMB1.G1 VRAMB1.G2 VRAMB1.G4 VRAMB1.G11 VRAMB1.G13 VRAMB1.G14 VRAMB1.H3 VRAMB1.H12 VRAMB1.K3 VRAMB1.K12 VRAMB1.L1 VRAMB1.L2 VRAMB1.L4 VRAMB1.L11 VRAMB1.L13 VRAMB1.L14 VRAMB1.M1 VRAMB1.M3 VRAMB1.M12 VRAMB1.M14 VRAMB1.N5 VRAMB1.N10 VRAMB1.P1 VRAMB1.P3 VRAMB1.P11 VRAMB1.P12 VRAMB1.P14 VRAMB1.R5 VRAMB1.R10 VRAMB1.T1 VRAMB1.T3 VRAMB1.T12 VRAMB1.T14 VRAMB2.B1 VRAMB2.B3 VRAMB2.B12 VRAMB2.B14 VRAMB2.C5 VRAMB2.C10 VRAMB2.D1 VRAMB2.D3 VRAMB2.D11 VRAMB2.D12 VRAMB2.D14 VRAMB2.E5 VRAMB2.E10 VRAMB2.F1 VRAMB2.F3 VRAMB2.F12 VRAMB2.F14 VRAMB2.G1 VRAMB2.G2 VRAMB2.G4 VRAMB2.G11 VRAMB2.G13 VRAMB2.G14 VRAMB2.H3 VRAMB2.H12 VRAMB2.K3 VRAMB2.K12 VRAMB2.L1 VRAMB2.L2 VRAMB2.L4 VRAMB2.L11 VRAMB2.L13 VRAMB2.L14 VRAMB2.M1 VRAMB2.M3 VRAMB2.M12 VRAMB2.M14 VRAMB2.N5 VRAMB2.N10 VRAMB2.P1 VRAMB2.P3 VRAMB2.P11 VRAMB2.P12 VRAMB2.P14 VRAMB2.R5 VRAMB2.R10 VRAMB2.T1 VRAMB2.T3 VRAMB2.T12 VRAMB2.T14 VRAMC1.B1 VRAMC1.B3 VRAMC1.B12 VRAMC1.B14 VRAMC1.C5 VRAMC1.C10 VRAMC1.D1 VRAMC1.D3 VRAMC1.D11 VRAMC1.D12 VRAMC1.D14 VRAMC1.E5 VRAMC1.E10 VRAMC1.F1 VRAMC1.F3 VRAMC1.F12 VRAMC1.F14 VRAMC1.G1 VRAMC1.G2 VRAMC1.G4 VRAMC1.G11 VRAMC1.G13 VRAMC1.G14 VRAMC1.H3 VRAMC1.H12 VRAMC1.K3 VRAMC1.K12 VRAMC1.L1 VRAMC1.L2 VRAMC1.L4 VRAMC1.L11 VRAMC1.L13 VRAMC1.L14 VRAMC1.M1 VRAMC1.M3 VRAMC1.M12 VRAMC1.M14 VRAMC1.N5 VRAMC1.N10 VRAMC1.P1 VRAMC1.P3 VRAMC1.P11 VRAMC1.P12 VRAMC1.P14 VRAMC1.R5 VRAMC1.R10 VRAMC1.T1 VRAMC1.T3 VRAMC1.T12 VRAMC1.T14 VRAMC2.B1 VRAMC2.B3 VRAMC2.B12 VRAMC2.B14 VRAMC2.C5 VRAMC2.C10 VRAMC2.D1 VRAMC2.D3 VRAMC2.D11 VRAMC2.D12 VRAMC2.D14 VRAMC2.E5 VRAMC2.E10 VRAMC2.F1 VRAMC2.F3 VRAMC2.F12 VRAMC2.F14 VRAMC2.G1 VRAMC2.G2 VRAMC2.G4 VRAMC2.G11 VRAMC2.G13 VRAMC2.G14 VRAMC2.H3 VRAMC2.H12 VRAMC2.K3 VRAMC2.K12 VRAMC2.L1 VRAMC2.L2 VRAMC2.L4 VRAMC2.L11 VRAMC2.L13 VRAMC2.L14 VRAMC2.M1 VRAMC2.M3 VRAMC2.M12 VRAMC2.M14 VRAMC2.N5 VRAMC2.N10 VRAMC2.P1 VRAMC2.P3 VRAMC2.P11 VRAMC2.P12 VRAMC2.P14 VRAMC2.R5 VRAMC2.R10 VRAMC2.T1 VRAMC2.T3 VRAMC2.T12 VRAMC2.T14 VRAMD1.B1 VRAMD1.B3 VRAMD1.B12 VRAMD1.B14 VRAMD1.C5 VRAMD1.C10 VRAMD1.D1 VRAMD1.D3 VRAMD1.D11 VRAMD1.D12 VRAMD1.D14 VRAMD1.E5 VRAMD1.E10 VRAMD1.F1 VRAMD1.F3 VRAMD1.F12 VRAMD1.F14 VRAMD1.G1 VRAMD1.G2 VRAMD1.G4 VRAMD1.G11 VRAMD1.G13 VRAMD1.G14 VRAMD1.H3 VRAMD1.H12 VRAMD1.K3 VRAMD1.K12 VRAMD1.L1 VRAMD1.L2 VRAMD1.L4 VRAMD1.L11 VRAMD1.L13 VRAMD1.L14 VRAMD1.M1 VRAMD1.M3 VRAMD1.M12 VRAMD1.M14 VRAMD1.N5 VRAMD1.N10 VRAMD1.P1 VRAMD1.P3 VRAMD1.P11 VRAMD1.P12 VRAMD1.P14 VRAMD1.R5 VRAMD1.R10 VRAMD1.T1 VRAMD1.T3 VRAMD1.T12 VRAMD1.T14 VRAMD2.B1 VRAMD2.B3 VRAMD2.B12 VRAMD2.B14 VRAMD2.C5 VRAMD2.C10 VRAMD2.D1 VRAMD2.D3 VRAMD2.D11 VRAMD2.D12 VRAMD2.D14 VRAMD2.E5 VRAMD2.E10 VRAMD2.F1 VRAMD2.F3 VRAMD2.F12 VRAMD2.F14 VRAMD2.G1 VRAMD2.G2 VRAMD2.G4 VRAMD2.G11 VRAMD2.G13 VRAMD2.G14 VRAMD2.H3 VRAMD2.H12 VRAMD2.K3 VRAMD2.K12 VRAMD2.L1 VRAMD2.L2 VRAMD2.L4 VRAMD2.L11 VRAMD2.L13 VRAMD2.L14 VRAMD2.M1 VRAMD2.M3 VRAMD2.M12 VRAMD2.M14 VRAMD2.N5 VRAMD2.N10 VRAMD2.P1 VRAMD2.P3 VRAMD2.P11 VRAMD2.P12 VRAMD2.P14 VRAMD2.R5 VRAMD2.R10 VRAMD2.T1 VRAMD2.T3 VRAMD2.T12 VRAMD2.T14
2D5V_EN: C460.1 PR209.1 R389.2
2D5V_MEMVPP_S5: C168.1 C169.1 C189.1 C190.1 DIMM1.257 DIMM1.259 DIMM2.257 DIMM2.259 PG209.2 PG210.2
2D5V_PCH_S0: C213.1 C214.1 C215.1 C216.1 C223.1 C224.1 C225.1 C226.1 C227.1 C228.1 C241.1 C242.1 C243.1 C244.1 C245.1 C246.1 PCH1.C1 PCH1.C2 PCH1.C3 PCH1.D1 PCH1.D2 PCH1.D3 PCH1.D4 PCH1.D5 PCH1.D6 PCH1.E1 PCH1.E2 PCH1.E3 PCH1.E4 PCH1.E5 PCH1.E6 PCH1.F6 PCH1.K11 PCH1.K12 PCH1.K15 PCH1.K16 PCH1.M8 PCH1.M19 PCH1.N8 PCH1.N19 PCH1.P19 PCH1.R19 PCH1.V12 PCH1.V13 PCH1.V17 PG226.2 PG227.2 PG236.2 R161.1
2D5V_PCH_S0_PG: PR400.1 R164.1
2D5V_S5: PG148.2 PG149.2 PG209.1 PG210.1
2D5V_S5_PG: PR399.1 U21.2
3D3V_AUX_KBC: Q9.D R183.2 R184.2 R199.1 R372.1 R1222.1 R2631.1 R2746.1 R2772.1 RN12.1(A) RN12.2(A) RN44.3(B) RN44.4(B) RN46.1(A) RN46.2(A)
3D3V_AUX_S5: D4.1 PG36.1 PR63.1 R239.2 R451.1 R455.2 R2414.1 R2667.1 R2719.1 R2751.1
3D3V_DVDD_MIC: C345.2 DMIC1.5 F23.2 R2662.2
3D3V_DVDD_S0: C324.1 C325.1 C381.1 C382.1 C415.1 C416.1 F23.1 L7.1 PR1.1 PR16.1 PR30.1 R273.1 R282.2 R283.2 R284.2 R291.1 R2585.1 R2662.1 U6.7 U7.16 U8.16
3D3V_M2VAUX: C497.1 C498.1 C499.1 C500.1 C508.1 C509.1 PR219.1 R431.1 R432.1 R433.1 R434.1 R435.1 R440.1 SSDC1.2 SSDC1.4 SSDC1.12 SSDC1.14 SSDC1.16 SSDC1.18 SSDC1.70 SSDC1.72 SSDC1.74
3D3V_MUX_S0: C510.1 C511.1 C512.1 R2558.2 R2599.1 U26.6
3D3V_PCH_S0: C211.1 C212.1 L2.1 PCH1.G9 PCH1.L18 PCH1.Y20
3D3V_PCH_S5: C239.1 C240.1 L3.1 PCH1.AA8 PCH1.AB8 PCH1.AC8 PCH1.AD8 PCH1.AE8 PCH1.AF8 PCH1.V8
3D3V_S0: C161.1 C162.1 C191.1 C192.1 C948.2 C980.1 C981.1 D5.K DIMM1.255 DIMM2.255 F22.2 L1.2 L2.2 L7.2 LPC1.4 PR78.1 PR101.1 PR341.1 PR395.1 Q54.S R17.2 R34.2 R35.2 R36.2 R37.2 R38.1 R39.2 R40.2 R79.2 R80.2 R82.2 R98.2 R99.2 R100.2 R111.2 R112.2 R113.2 R121.2 R122.1 R124.2 R126.1 R129.1 R133.1 R136.1 R139.1 R140.1 R141.1 R143.1 R146.1 R148.1 R150.1 R155.1 R156.1 R157.1 R158.1 R159.1 R163.1 R251.1 R367.1 R375.1 R388.1 R431.2 R432.2 R433.2 R434.2 R435.2 R453.1 R456.2 R584.1 R586.2 R1129.2 R1217.1 R1227.1 R1230.1 R2413.1 R2558.1 R2589.2 R2598.2 R2604.2 R2627.1 R2706.2 R2714.2 R2742.2 R2752.1 R2774.2 R2783.2 RN3.3(B) RN3.4(B) RN4.1(A) RN4.2(A) RN7.3(B) RN7.4(B) RN2402.1(A) RN2402.2(A) RN2404.1(A) RN2404.2(A) RN2405.1(A) RN2405.2(A) RN2412.1(A) RN2412.2(A) RN2414.1(A) RN2414.2(A) RPWRC1.10 RPWRC1.12 U1.G U33.8 U33.9 U38.5
3D3V_S0_CT2: C991.1 U33.10
3D3V_S5: C136.1 C462.1 C989.1 CPU1.AJ19 CPU1.AK19 D9.2 F2.1 JMP1.2 L3.2 L30.2 L31.2 OSDC1.3 PC232.1 PC243.1 PC374.1 PG5.1 PG6.2 PG11.1 PG12.2 PG17.1 PG18.2 PG24.1 PG27.2 PG31.1 PG32.2 PG147.2 PG211.2 PG212.2 PG220.2 PG221.2 PG224.2 PG225.2 PG230.1 PG231.1 PG234.2 PG235.2 PR64.1 PR166.1 PR207.1 PR212.1 PR216.1 PR221.1 PR223.1 PR224.1 PR225.1 PR333.1 PR335.1 PR338.1 PR340.1 PR361.1 PR363.1 PR394.1 PU33.15 PU34.15 PU47.15 Q36.E Q85.D R23.1 R43.2 R44.2 R128.2 R130.2 R131.2 R153.1 R154.1 R269.2 R336.2 R347.1 R351.2 R359.1 R365.1 R379.1 R383.1 R399.1 R414.1 R419.1 R430.1 R1226.2 R2481.2 R2482.2 R2483.2 R2484.2 R2485.2 R2491.2 R2492.2 R2495.2 R2580.1 R2632.2 R2661.1 R2668.1 R2684.1 R2686.1 R2688.1 R2715.1 R2717.1 R2733.1 R2747.1 R2781.2 R2782.2 RN5.1(A) RN5.2(A) RN6.1(A) RN6.2(A) RN8.1(A) RN8.2(A) RN9.1(A) RN9.2(A) RN10.1(A) RN10.2(A) RN17.1(A) RN17.2(A) RN19.1(A) RN19.2(A) RN45.3(B) RN45.4(B) RN2407.1(A) RN2407.2(A) RN2408.1(A) RN2408.2(A) RPWRC1.11 U21.5 U33.6 U33.7
3D3V_SD: F22.1 R2774.1 SDRDC1.7 SDRDC1.8
3D3V_VDD_S0: C145.1 CPU1.AJ21 CPU1.AK21 L1.1 PC66.1
3D3V_VGA: C630.1 C637.1 GPU1.AL24 GPU1.AM24 PR231.1 PR324.1 PR346.1 PR374.1 PR375.1 PR392.1 PR406.1 Q54.D R478.1 R479.1 R480.1 R481.1 R482.1 R483.2 R491.2 R494.1 R495.1 R505.1 R508.2 R510.2 R516.2 R518.2 R519.1 R520.2 R525.2 R526.2 R527.2 R532.2 R533.2 R535.2 R552.1 R586.1 R1197.1 R2634.1 R2635.1 R2636.1 R2637.1 R2638.1 R2639.1 R2642.1 R2643.1 R2732.1 R2740.1 R2741.1 U28.7 U28.8
+TSVDD: C634.1 GPU1.AR26 L27.2
AC_OK#: C1160.1 Q78.G R2751.2
AD+_2: C459.2 R380.2 R382.1 U18.4 U19.4
AD_JK: C456.1 C457.1 C459.1 D8.K DCPWR1.2 DCPWR1.3 DCPWR1.6 DCPWR1.7 R380.1 U18.1 U18.2 U18.3 U19.1 U19.2 U19.3
ADAPTOR_PSID: D9.3 KBC1.99 R383.2 R384.2
ADAPTOR_PSID_R: Q21.S R384.1
ADBIA0: GPU1.P36 VRAMA1.J4
ADBIA1: GPU1.J36 VRAMA2.J4
ADBIB0: GPU1.L21 VRAMB1.J4
ADBIB1: GPU1.L19 VRAMB2.J4
ADBIC0: GPU1.W11 VRAMC1.J4
ADBIC1: GPU1.AA11 VRAMC2.J4
ADBID0: GPU1.AT9 VRAMD1.J4
ADBID1: GPU1.AT14 VRAMD2.J4
AGPIO5_DEVSLP0: CPU1.AP22 R39.1
AGPIO89: CPU1.AV22 R52.1
ALERT#: R231.2 U2.6
ALERT#_CPU: CPU1.D16 R1231.2
ALL_PWRGD_2: Q53.D R1129.1 R1195.1
ALL_SYS_PWRGD: CPU1.AM3 KBC1.10 R38.2 R2780.2
ALL_SYS_PWRGD_C: D7.3 R374.1 R2602.1 R2752.2
ALL_SYS_PWRGD_EC: KBC1.84 R2602.2
AM4R1: CPU1.AL8 R23.2 TP9.1
AMDTSI_CLK_CPU: CPU1.B18 Q75.1 RN1.4(B)
AMDTSI_DATA_CPU: CPU1.C18 Q75.4 RN1.3(B)
AMP_ASEL: PR16.2 PR17.1 U7.18
AMP_AVDD2: C385.1 C386.1 R316.1 U7.21
AMP_BST_A: C361.1 U7.2
AMP_BST_B: C362.2 U7.50
AMP_BST_B_C: C359.2 R311.1
AMP_BST_C: C363.1 U7.49
AMP_BST_C_C: C360.1 R312.2
AMP_BST_D: C364.2 U7.41
AMP_GVDD_AB: C374.2 R315.2 U7.3
AMP_GVDD_CD: C376.1 U7.40
AMP_I2C_SCL: R2512.2 R2514.2 U7.8
AMP_I2C_SDA: R2511.2 R2513.2 U7.7
AMP_ISENSEP_L: PR9.2 PR15.1 U7.25
AMP_ISENSEP_R: PR6.2 PR14.2 U7.28
AMP_IVSENSE_L: PR8.2 PR13.1 U7.26
AMP_IVSENSE_R: PR5.2 PR12.2 U7.29
AMP_LDO_1D5: C379.1 U7.22
AMP_OC_ADJ: R313.2 U7.5
AMP_OUT_A: C358.2 C361.2 L16.1 U7.55
AMP_OUT_A_C: C358.1 R310.2
AMP_OUT_A_L: C353.2 L16.2 PR9.1 R2594.2
AMP_OUT_B: C359.1 C362.1 L17.2 U7.52
AMP_OUT_C: C360.2 C363.2 L18.1 U7.47
AMP_OUT_C_L: C355.2 L18.2 PR6.1 R2595.2
AMP_OUT_D: C357.1 C364.1 L19.1 U7.44
AMP_OUT_D_C: C357.2 R309.1
AMP_PGVDD: R314.2 R315.1 U7.6
AMP_SPKR_L+_C: C354.1 L17.1 PR7.1 SPK1.2
AMP_SPKR_L-_C: PR8.1 R2594.1 SPK1.3
AMP_SPKR_R+_C: C356.1 L19.2 PR4.1 SPK1.5
AMP_SPKR_R-_C: PR5.1 R2595.1 SPK1.4
AMP_VREF1: C380.1 U7.23
AMP_VSENSEN_L: PR7.2 PR11.1 U7.27
AMP_VSENSEN_R: PR4.2 PR10.2 U7.30
APU_DBRDY: CPU1.E13 HDT1.14
APU_DBREQ#: CPU1.D14 R20.2 R725.2
APU_TCK: CPU1.C15 HDT1.2 RN2.5(B)
APU_TDI: CPU1.A14 HDT1.6 RN2.7(B)
APU_TDO: CPU1.C14 HDT1.8
APU_TMS: CPU1.B15 HDT1.4 RN2.6(B)
APU_TRST#: C925.1 CPU1.B13 R721.1 RN2.8(B)
AUO_3V_POP1: L30.1 U41.5
AUO_3V_POP2: L31.1 U42.5
AUO_AGPO_1: Q68.G R2630.1 U6.39
AUO_AGPO_1_R: D14.2 Q68.D
AUO_BEEP_C: C321.1 U6.23
AUO_BEEP_R: C321.2 C326.1 R271.1 R272.1
AUO_CBN1: C320.1 U6.28
AUO_CBN2: C323.1 U6.25
AUO_CBP1: C320.2 U6.27
AUO_CBP2: C323.2 U6.26
AUO_CPVEE: C309.2 U6.31
AUO_CPVPP: C315.2 U6.29
AUO_DMIC_CLK1: C337.2 DMIC1.3 L34.2
AUO_DMIC_CLK1_R: L34.1 U6.53
AUO_DMIC_CLK2: C2525.1 DMIC1.6 L33.2
AUO_DMIC_CLK2_R: L33.1 U6.2
AUO_DMIC_DATA1: C2534.2 DMIC1.4 R277.2
AUO_DMIC_DATA1_R: R277.1 U6.54
AUO_DMIC_DATA2: C2533.1 DMIC1.7 R286.2
AUO_DMIC_DATA2_R: R286.1 U6.4
AUO_DMIC_DET: DMIC1.1 KBC1.25 R2589.1
AUO_EAPD: PD1.K R274.1 U6.52
AUO_HDA_SDIN0_CPU_R: R275.1 U6.16
AUO_HP_LINE1_JD: C344.1 R291.2 R293.1 R294.1 U6.9
AUO_HP_MUTE1: R2628.2 U41.6
AUO_HP_MUTE2: R2629.1 U42.6
AUO_HP_MUTE_R: D14.3 R2627.2 R2628.1 R2629.2
AUO_HPOUT_JD: R293.2 SUSBC1.20
AUO_HPOUT_L: R289.1 U6.32
AUO_HPOUT_R: R290.1 U6.33
AUO_I2S_OUT_MIC1_JD: C1116.1 R2585.2 R2586.1 U6.8
AUO_INL_R2: R2624.2 U42.1
AUO_INR_L1: R2626.1 U41.1
AUO_INR_R1: R2625.1 U41.3
AUO_INR_R2: R2623.2 U42.3
AUO_IRQOUT: R282.1 U6.6
AUO_LDO1_CAP: C322.1 U6.44
AUO_LDO2_CAP: C330.1 C331.1 U6.22
AUO_LDO3_CAP: C334.1 C335.1 U6.18
AUO_LINE1-VREF_O_L: D13.3 U6.40
AUO_LINE1-VREF_O_L_N: D13.2 R2622.1
AUO_LINE1-VREF_O_L_R: L15.1 PR3.2 R304.1 R2622.2 R2623.1
AUO_LINE1-VREF_O_R_N: D13.1 R2621.1
AUO_LINE1-VREF_O_R_R: L14.1 PR2.2 R305.1 R2621.2 R2624.1
AUO_LINE1_L: PT2.1 U6.35
AUO_LINE1_L_T: PR3.1 PT2.2
AUO_LINE1_R: PT1.1 U6.34
AUO_LINE1_R_T: PR2.1 PT1.2
AUO_LINEOUT_JD: LAUOC1.39 R294.2
AUO_LINEOUT_L: C351.1 L15.2 LAUOC1.38
AUO_LINEOUT_R: C352.1 L14.2 LAUOC1.37
AUO_LINK_BCLK: C338.1 R278.1 U6.13
AUO_MIC1-VREF_O_L: RN2415.1(A) RN2415.2(A) U6.38
AUO_MIC1_CAP: C314.2 U6.41
AUO_MIC1_L: L11.1 RN2415.4(B) U6.36
AUO_MIC1_R: L10.1 RN2415.3(B) U6.37
AUO_MONITOR_SW: LAUOC1.26 R2587.1
AUO_POST_I2S_BCLK: R302.1 U6.56
AUO_POST_I2S_BCLK_R: C347.1 R302.2 U7.10 U8.10
AUO_POST_I2S_DIN: C350.1 R297.1 U6.5
AUO_POST_I2S_DIN_R: R297.2 U7.14 U8.14
AUO_POST_I2S_DOUT: R298.1 U6.3
AUO_POST_I2S_DOUT_R: C349.1 R298.2 U7.12 U8.12
AUO_POST_I2S_LRCK: R301.1 U6.1
AUO_POST_I2S_LRCK_R: C348.1 R301.2 U7.11 U8.11
AUO_PVDD1: C327.1 C328.1 C333.1 R2582.2 U6.46 U6.51
AUO_RESET_OUT: R2690.1 U6.15
AUO_SET1: C1124.2 U41.4
AUO_SET2: C1123.2 U42.4
AUO_SIO_HP_MUTE: D14.1 KBC1.30
AUO_SPDIF_IN: C1151.2 LAUOC1.8
AUO_SPDIF_IN_R: C1151.1 U6.55
AUO_VD33STB: R2718.2 R2719.2 U6.10
AUO_VREF1_1: C329.1 C332.1 U6.21
AUO_VREF_1: C312.1 C313.1 U6.43
AZ_SDIN2: CPU1.AV4 R56.1
BIST_EN_INV: KBC1.42 LAUOC1.13
CASA0B: GPU1.R32 VRAMA1.L3
CASA1B: GPU1.L35 VRAMA2.G3
CASB0B: GPU1.K21 VRAMB1.L3
CASB1B: GPU1.M19 VRAMB2.G3
CASC0B: GPU1.W12 VRAMC1.L3
CASC1B: GPU1.AA10 VRAMC2.G3
CASD0B: GPU1.AR11 VRAMD1.L3
CASD1B: GPU1.AM15 VRAMD2.G3
CHAR_CTL1_REAR: R346.1 U12.6
CHAR_CTL1_SIDE: R333.1 U10.6
CHAR_CTL2_REAR: R349.1 U12.7
CHAR_CTL2_SIDE: R335.1 U10.7
CHAR_CTL3_REAR: R352.1 U12.8
CHAR_CTL3_SIDE: R337.1 U10.8
CHAR_EN_REAR: R351.1 R354.2 R2497.1 U12.5
CHAR_EN_REAR_EC: KBC1.121 R2497.2
CHAR_EN_SIDE: R336.1 R339.2 R2498.1 U10.5
CHAR_EN_SIDE_EC: KBC1.71 R2498.2
CHAR_ILIM_HI_REAR: R356.1 U12.16
CHAR_ILIM_HI_SIDE: R341.1 U10.16
CHAR_ILIM_LO_REAR: R355.1 U12.15
CHAR_ILIM_LO_SIDE: R340.1 U10.15
CHAR_ILIM_SEL_REAR: R353.1 U12.4
CHAR_ILIM_SEL_SIDE: R338.1 U10.4
CHAR_USBOC4#: R332.1 U10.13
CHAR_USBOC6#: R345.1 U12.13
CKEA0: GPU1.P34 VRAMA1.J3
CKEA1: GPU1.M34 VRAMA2.J3
CKEB0: GPU1.N21 VRAMB1.J3
CKEB1: GPU1.N20 VRAMB2.J3
CKEC0: GPU1.Y13 VRAMC1.J3
CKEC1: GPU1.AA13 VRAMC2.J3
CKED0: GPU1.AP12 VRAMD1.J3
CKED1: GPU1.AP14 VRAMD2.J3
CLEAN_CMOS_EC: KBC1.122 R2771.2 R2772.2
CLK_100M: R561.2 R563.2
CLK_100M_R: R561.1 U29.4
CLK_100M_VDD: C638.1 C639.1 C2526.1 L28.2 U29.1
CLK_100M_XIN: C640.1 U29.2 X99.3
CLK_100M_XOUT: C641.1 U29.3 X99.1
CLK_REQ0: CPU1.AT23 RN2404.4(B)
CLK_REQ1: CPU1.AV24 RN2404.3(B)
CLK_REQ2: CPU1.AT24 R2745.1 RN2405.4(B)
CLK_REQG_L: CPU1.AR22 R70.1 R494.2 R496.2
CLKA0: GPU1.W32 R674.1 VRAMA1.J12
CLKA0B: GPU1.W33 R673.1 VRAMA1.J11
CLKA1: GPU1.M29 R675.1 VRAMA2.J12
CLKA1B: GPU1.L29 R672.1 VRAMA2.J11
CLKB0: GPU1.P26 R633.1 VRAMB1.J12
CLKB0B: GPU1.N26 R632.1 VRAMB1.J11
CLKB1: GPU1.H14 R630.1 VRAMB2.J12
CLKB1B: GPU1.G14 R631.1 VRAMB2.J11
CLKC0: GPU1.P8 R676.1 VRAMC1.J12
CLKC0B: GPU1.P7 R677.1 VRAMC1.J11
CLKC1: GPU1.AF14 R705.1 VRAMC2.J12
CLKC1B: GPU1.AF13 R706.1 VRAMC2.J11
CLKD0: GPU1.AJ12 R629.1 VRAMD1.J12
CLKD0B: GPU1.AJ11 R628.1 VRAMD1.J11
CLKD1: GPU1.AM19 R661.1 VRAMD2.J12
CLKD1B: GPU1.AN19 R662.1 VRAMD2.J11
CMOS_EC_R: JMP1.5 R2770.1 R2771.1
CORETYPE0: CPU1.AM24 KBC1.91 Q86.5 R1235.2
CORETYPE1: CPU1.AN9 KBC1.6 PC417.1 PU52.5 Q81.5 Q83.G R1233.2 R2747.2
CPU_CORE_FB_N: PR114.2 PR115.1 R31.1
CPU_CORE_FB_N_R: CPU1.F15 R31.2
CPU_CORE_FB_P: PR110.2 PR112.2 R29.1
CPU_CORE_FB_P_R: CPU1.F14 R29.2
CPU_FAN_CTRL_SIO: KBC1.81 R253.1
CPU_FAN_TACH_SIO: KBC1.31 R258.2
CPU_NB_FB_P: PR71.1 PR72.1 R30.1
CPU_NB_FB_P_R: CPU1.E15 R30.2
CSA0B_0: GPU1.Y34 VRAMA1.G12
CSA1B_0: GPU1.M27 VRAMA2.L12
CSB0B_0: GPU1.L26 VRAMB1.G12
CSB1B_0: GPU1.K12 VRAMB2.L12
CSC0B_0: GPU1.M10 VRAMC1.G12
CSC1B_0: GPU1.AF11 VRAMC2.L12
CSD0B_0: GPU1.AG12 VRAMD1.G12
CSD1B_0: GPU1.AP20 VRAMD2.L12
CTF_TRIP: C653.1 Q50.B R603.2
CYPD2122_WP: KBC1.60 LAUOC1.16 R2733.2
DC_19V: C458.1 PR410.2 R381.1 U18.5 U18.6 U18.7 U18.8 U19.5 U19.6 U19.7 U19.8
DDBIA0_0: GPU1.P43 VRAMA1.D13
DDBIA0_1: GPU1.H40 VRAMA1.D2
DDBIA0_2: GPU1.P40 VRAMA1.P13
DDBIA0_3: GPU1.F39 VRAMA1.P2
DDBIA1_0: GPU1.D36 VRAMA2.P2
DDBIA1_1: GPU1.A30 VRAMA2.P13
DDBIA1_2: GPU1.E35 VRAMA2.D2
DDBIA1_3: GPU1.H29 VRAMA2.D13
DDBIB0_0: GPU1.G24 VRAMB1.P13
DDBIB0_1: GPU1.H19 VRAMB1.P2
DDBIB0_2: GPU1.C19 VRAMB1.D2
DDBIB0_3: GPU1.C24 VRAMB1.D13
DDBIB1_0: GPU1.J17 VRAMB2.D2
DDBIB1_1: GPU1.J11 VRAMB2.D13
DDBIB1_2: GPU1.C12 VRAMB2.P2
DDBIB1_3: GPU1.A5 VRAMB2.P13
DDBIC0_0: GPU1.E1 VRAMC1.D13
DDBIC0_1: GPU1.M3 VRAMC1.D2
DDBIC0_2: GPU1.L9 VRAMC1.P13
DDBIC0_3: GPU1.U9 VRAMC1.P2
DDBIC1_0: GPU1.AD3 VRAMC2.P13
DDBIC1_1: GPU1.W3 VRAMC2.P2
DDBIC1_2: GPU1.W8 VRAMC2.D2
DDBIC1_3: GPU1.AD7 VRAMC2.D13
DDBID0_0: GPU1.AJ8 VRAMD1.P13
DDBID0_1: GPU1.AR5 VRAMD1.P2
DDBID0_2: GPU1.AK1 VRAMD1.D13
DDBID0_3: GPU1.AT4 VRAMD1.D2
DDBID1_0: GPU1.AW6 VRAMD2.D2
DDBID1_1: GPU1.AY14 VRAMD2.D13
DDBID1_2: GPU1.AY8 VRAMD2.P2
DDBID1_3: GPU1.BC14 VRAMD2.P13
DDCVGACLK: GPU1.AD34 R481.2
DDCVGADAT: GPU1.AD33 R482.2
DDI0_CRT_HPD: CPU1.H9 DISPC1.3 R2680.2
DDI0_VGA_AUX_CPU_N: CPU1.H10 DISPC1.19
DDI0_VGA_AUX_CPU_P: CPU1.G10 DISPC1.18
DDI0_VGA_DATA_CPU_N0: C1134.1 DISPC1.7
DDI0_VGA_DATA_CPU_N0_R: C1134.2 CPU1.C2
DDI0_VGA_DATA_CPU_N1: C1136.1 DISPC1.10
DDI0_VGA_DATA_CPU_N1_R: C1136.2 CPU1.B3
DDI0_VGA_DATA_CPU_N2: C1138.1 DISPC1.13
DDI0_VGA_DATA_CPU_N2_R: C1138.2 CPU1.A4
DDI0_VGA_DATA_CPU_N3: C1140.1 DISPC1.16
DDI0_VGA_DATA_CPU_N3_R: C1140.2 CPU1.C6
DDI0_VGA_DATA_CPU_P0: C1133.1 DISPC1.6
DDI0_VGA_DATA_CPU_P0_R: C1133.2 CPU1.D2
DDI0_VGA_DATA_CPU_P1: C1135.1 DISPC1.9
DDI0_VGA_DATA_CPU_P1_R: C1135.2 CPU1.C3
DDI0_VGA_DATA_CPU_P2: C1137.1 DISPC1.12
DDI0_VGA_DATA_CPU_P2_R: C1137.2 CPU1.B4
DDI0_VGA_DATA_CPU_P3: C1139.1 DISPC1.15
DDI0_VGA_DATA_CPU_P3_R: C1139.2 CPU1.C5
DDI1_DATA_CPU_N0: C1126.1 DISPC1.37
DDI1_DATA_CPU_N0_R: C1126.2 CPU1.D5
DDI1_DATA_CPU_N1: C1128.1 DISPC1.34
DDI1_DATA_CPU_N1_R: C1128.2 CPU1.D8
DDI1_DATA_CPU_N2: C1130.1 DISPC1.31
DDI1_DATA_CPU_N2_R: C1130.2 CPU1.G8
DDI1_DATA_CPU_N3: C1132.1 DISPC1.28
DDI1_DATA_CPU_N3_R: C1132.2 CPU1.F9
DDI1_DATA_CPU_P0: C1125.1 DISPC1.38
DDI1_DATA_CPU_P0_R: C1125.2 CPU1.D4
DDI1_DATA_CPU_P1: C1127.1 DISPC1.35
DDI1_DATA_CPU_P1_R: C1127.2 CPU1.D7
DDI1_DATA_CPU_P2: C1129.1 DISPC1.32
DDI1_DATA_CPU_P2_R: C1129.2 CPU1.F8
DDI1_DATA_CPU_P3: C1131.1 DISPC1.29
DDI1_DATA_CPU_P3_R: C1131.2 CPU1.E9
DDI1_HDMI1_CLK_CPU: CPU1.F11 DISPC1.26 RN3.2(A)
DDI1_HDMI1_DATA_CPU: CPU1.G11 DISPC1.25 RN3.1(A)
DDI1_HDMI_HPD: CPU1.D10 DISPC1.24 R26.2
DDR0_A_ALERT_N: CPU1.N34 DIMM1.116
DDR0_A_PARITY: CPU1.Y33 DIMM1.143
DDR1_B_ALERT_N: CPU1.N37 DIMM2.116
DDR1_B_PARITY: CPU1.AB38 DIMM2.143
DEVSLP: R437.1 SSDC1.38
DEVSLP_N: PR219.2 PR220.1 Q34.S R436.1 R437.2
DEVSLP_N_GATE: C507.1 Q34.G R438.1
DIMM_CA_VREF_A: C164.1 C165.1 DIMM1.164 R107.2 R108.2
DIMM_CA_VREF_B: C187.1 C188.1 DIMM2.164 R117.2 R118.2
DMI_RX_CPU_N0: C196.2 CPU1.AD8
DMI_RX_CPU_N0_C: C196.1 PCH1.G2
DMI_RX_CPU_N1: C198.2 CPU1.AA8
DMI_RX_CPU_N1_C: C198.1 PCH1.J2
DMI_RX_CPU_N2: C200.2 CPU1.Y7
DMI_RX_CPU_N2_C: C200.1 PCH1.L2
DMI_RX_CPU_N3: C202.2 CPU1.W5
DMI_RX_CPU_N3_C: C202.1 PCH1.N2
DMI_RX_CPU_P0: C195.2 CPU1.AE8
DMI_RX_CPU_P0_C: C195.1 PCH1.G1
DMI_RX_CPU_P1: C197.2 CPU1.AB8
DMI_RX_CPU_P1_C: C197.1 PCH1.J1
DMI_RX_CPU_P2: C199.2 CPU1.Y6
DMI_RX_CPU_P2_C: C199.1 PCH1.L1
DMI_RX_CPU_P3: C201.2 CPU1.W4
DMI_RX_CPU_P3_C: C201.1 PCH1.N1
DMI_TX_CPU_N0: C2.2 PCH1.G4
DMI_TX_CPU_N0_C: C2.1 CPU1.AE5
DMI_TX_CPU_N1: C4.2 PCH1.J4
DMI_TX_CPU_N1_C: C4.1 CPU1.AB5
DMI_TX_CPU_N2: C6.2 PCH1.L4
DMI_TX_CPU_N2_C: C6.1 CPU1.AC7
DMI_TX_CPU_N3: C8.2 PCH1.N4
DMI_TX_CPU_N3_C: C8.1 CPU1.AD6
DMI_TX_CPU_P0: C1.2 PCH1.G5
DMI_TX_CPU_P0_C: C1.1 CPU1.AE4
DMI_TX_CPU_P1: C3.2 PCH1.J5
DMI_TX_CPU_P1_C: C3.1 CPU1.AA5
DMI_TX_CPU_P2: C5.2 PCH1.L5
DMI_TX_CPU_P2_C: C5.1 CPU1.AC6
DMI_TX_CPU_P3: C7.2 PCH1.N5
DMI_TX_CPU_P3_C: C7.1 CPU1.AD5
DP_AUX_ZVSS: CPU1.E12 R25.2
DP_STEREOSYNC_APU: CPU1.K14 R32.2 R33.1
DP_ZVSS: CPU1.F12 R24.2
DPLVDS_PWMIN: LAUOC1.14 Q77.D R2559.2 R2579.2 R2742.1
DPLVDS_PWMIN_CPU: CPU1.H12 Q77.S R2559.1 R2744.1
DQA0_0: GPU1.U43 VRAMA1.A11
DQA0_1: GPU1.U41 VRAMA1.A13
DQA0_2: GPU1.U40 VRAMA1.B11
DQA0_3: GPU1.R42 VRAMA1.B13
DQA0_4: GPU1.P42 VRAMA1.E13
DQA0_5: GPU1.M43 VRAMA1.F13
DQA0_6: GPU1.M41 VRAMA1.F11
DQA0_7: GPU1.M40 VRAMA1.E11
DQA0_8: GPU1.J43 VRAMA1.E2
DQA0_9: GPU1.J42 VRAMA1.E4
DQA0_10: GPU1.H43 VRAMA1.F4
DQA0_11: GPU1.H41 VRAMA1.F2
DQA0_12: GPU1.F41 VRAMA1.B2
DQA0_13: GPU1.E43 VRAMA1.B4
DQA0_14: GPU1.C43 VRAMA1.A4
DQA0_15: GPU1.D42 VRAMA1.A2
DQA0_16: GPU1.U38 VRAMA1.N13
DQA0_17: GPU1.U37 VRAMA1.M13
DQA0_18: GPU1.R38 VRAMA1.T13
DQA0_19: GPU1.R36 VRAMA1.U13
DQA0_20: GPU1.P39 VRAMA1.U11
DQA0_21: GPU1.P37 VRAMA1.T11
DQA0_22: GPU1.M38 VRAMA1.N11
DQA0_23: GPU1.M37 VRAMA1.M11
DQA0_24: GPU1.L36 VRAMA1.U2
DQA0_25: GPU1.J40 VRAMA1.U4
DQA0_26: GPU1.J39 VRAMA1.T4
DQA0_27: GPU1.J37 VRAMA1.T2
DQA0_28: GPU1.E40 VRAMA1.M2
DQA0_29: GPU1.E41 VRAMA1.N2
DQA0_30: GPU1.D39 VRAMA1.N4
DQA0_31: GPU1.C39 VRAMA1.M4
DQA1_0: GPU1.A41 VRAMA2.U4
DQA1_1: GPU1.B40 VRAMA2.U2
DQA1_2: GPU1.A39 VRAMA2.T4
DQA1_3: GPU1.C38 VRAMA2.T2
DQA1_4: GPU1.C36 VRAMA2.N2
DQA1_5: GPU1.A36 VRAMA2.M2
DQA1_6: GPU1.B35 VRAMA2.M4
DQA1_7: GPU1.A35 VRAMA2.N4
DQA1_8: GPU1.A32 VRAMA2.M11
DQA1_9: GPU1.C32 VRAMA2.N11
DQA1_10: GPU1.D32 VRAMA2.N13
DQA1_11: GPU1.B30 VRAMA2.M13
DQA1_12: GPU1.B29 VRAMA2.T13
DQA1_13: GPU1.D27 VRAMA2.T11
DQA1_14: GPU1.C27 VRAMA2.U13
DQA1_15: GPU1.A27 VRAMA2.U11
DQA1_16: GPU1.E38 VRAMA2.E4
DQA1_17: GPU1.H36 VRAMA2.F4
DQA1_18: GPU1.F36 VRAMA2.F2
DQA1_19: GPU1.G35 VRAMA2.E2
DQA1_20: GPU1.E33 VRAMA2.A2
DQA1_21: GPU1.F33 VRAMA2.B2
DQA1_22: GPU1.F32 VRAMA2.A4
DQA1_23: GPU1.G32 VRAMA2.B4
DQA1_24: GPU1.G30 VRAMA2.F11
DQA1_25: GPU1.J29 VRAMA2.E11
DQA1_26: GPU1.E29 VRAMA2.B11
DQA1_27: GPU1.F29 VRAMA2.A11
DQA1_28: GPU1.F27 VRAMA2.B13
DQA1_29: GPU1.D26 VRAMA2.E13
DQA1_30: GPU1.E26 VRAMA2.A13
DQA1_31: GPU1.G26 VRAMA2.F13
DQB0_0: GPU1.K26 VRAMB1.M13
DQB0_1: GPU1.E25 VRAMB1.N13
DQB0_2: GPU1.F25 VRAMB1.U13
DQB0_3: GPU1.H25 VRAMB1.T13
DQB0_4: GPU1.J24 VRAMB1.U11
DQB0_5: GPU1.D23 VRAMB1.T11
DQB0_6: GPU1.E23 VRAMB1.N11
DQB0_7: GPU1.G23 VRAMB1.M11
DQB0_8: GPU1.E21 VRAMB1.T4
DQB0_9: GPU1.J20 VRAMB1.U4
DQB0_10: GPU1.G20 VRAMB1.U2
DQB0_11: GPU1.F20 VRAMB1.T2
DQB0_12: GPU1.E19 VRAMB1.N2
DQB0_13: GPU1.F19 VRAMB1.M2
DQB0_14: GPU1.E18 VRAMB1.N4
DQB0_15: GPU1.D18 VRAMB1.M4
DQB0_16: GPU1.C20 VRAMB1.E4
DQB0_17: GPU1.A20 VRAMB1.E2
DQB0_18: GPU1.D20 VRAMB1.F4
DQB0_19: GPU1.B19 VRAMB1.F2
DQB0_20: GPU1.B18 VRAMB1.B2
DQB0_21: GPU1.A17 VRAMB1.B4
DQB0_22: GPU1.C17 VRAMB1.A2
DQB0_23: GPU1.D17 VRAMB1.A4
DQB0_24: GPU1.A26 VRAMB1.A13
DQB0_25: GPU1.B26 VRAMB1.A11
DQB0_26: GPU1.C25 VRAMB1.B11
DQB0_27: GPU1.B25 VRAMB1.B13
DQB0_28: GPU1.A24 VRAMB1.E13
DQB0_29: GPU1.A23 VRAMB1.F11
DQB0_30: GPU1.B23 VRAMB1.F13
DQB0_31: GPU1.D21 VRAMB1.E11
DQB1_0: GPU1.G18 VRAMB2.F4
DQB1_1: GPU1.H18 VRAMB2.E4
DQB1_2: GPU1.F17 VRAMB2.F2
DQB1_3: GPU1.G17 VRAMB2.E2
DQB1_4: GPU1.F15 VRAMB2.B2
DQB1_5: GPU1.H15 VRAMB2.A2
DQB1_6: GPU1.D14 VRAMB2.A4
DQB1_7: GPU1.E14 VRAMB2.B4
DQB1_8: GPU1.J12 VRAMB2.F11
DQB1_9: GPU1.E11 VRAMB2.B11
DQB1_10: GPU1.F11 VRAMB2.E11
DQB1_11: GPU1.H11 VRAMB2.A11
DQB1_12: GPU1.E9 VRAMB2.B13
DQB1_13: GPU1.G9 VRAMB2.A13
DQB1_14: GPU1.H9 VRAMB2.E13
DQB1_15: GPU1.F8 VRAMB2.F13
DQB1_16: GPU1.B15 VRAMB2.U4
DQB1_17: GPU1.C15 VRAMB2.U2
DQB1_18: GPU1.A14 VRAMB2.T4
DQB1_19: GPU1.B14 VRAMB2.T2
DQB1_20: GPU1.D12 VRAMB2.N2
DQB1_21: GPU1.B11 VRAMB2.M2
DQB1_22: GPU1.C11 VRAMB2.M4
DQB1_23: GPU1.A9 VRAMB2.N4
DQB1_24: GPU1.C8 VRAMB2.N13
DQB1_25: GPU1.D8 VRAMB2.N11
DQB1_26: GPU1.C6 VRAMB2.M13
DQB1_27: GPU1.B6 VRAMB2.M11
DQB1_28: GPU1.D5 VRAMB2.T13
DQB1_29: GPU1.C4 VRAMB2.U11
DQB1_30: GPU1.B4 VRAMB2.T11
DQB1_31: GPU1.A3 VRAMB2.U13
DQC0_0: GPU1.C1 VRAMC1.A13
DQC0_1: GPU1.D2 VRAMC1.B11
DQC0_2: GPU1.D3 VRAMC1.A11
DQC0_3: GPU1.E4 VRAMC1.B13
DQC0_4: GPU1.F2 VRAMC1.F11
DQC0_5: GPU1.F3 VRAMC1.F13
DQC0_6: GPU1.H4 VRAMC1.E11
DQC0_7: GPU1.H3 VRAMC1.E13
DQC0_8: GPU1.J1 VRAMC1.E4
DQC0_9: GPU1.L3 VRAMC1.F4
DQC0_10: GPU1.L2 VRAMC1.F2
DQC0_11: GPU1.M4 VRAMC1.E2
DQC0_12: GPU1.P2 VRAMC1.B2
DQC0_13: GPU1.P1 VRAMC1.B4
DQC0_14: GPU1.R3 VRAMC1.A2
DQC0_15: GPU1.R2 VRAMC1.A4
DQC0_16: GPU1.H6 VRAMC1.M13
DQC0_17: GPU1.J8 VRAMC1.N13
DQC0_18: GPU1.J7 VRAMC1.U13
DQC0_19: GPU1.J5 VRAMC1.T13
DQC0_20: GPU1.L8 VRAMC1.U11
DQC0_21: GPU1.L6 VRAMC1.N11
DQC0_22: GPU1.L5 VRAMC1.T11
DQC0_23: GPU1.M9 VRAMC1.M11
DQC0_24: GPU1.P5 VRAMC1.T4
DQC0_25: GPU1.P4 VRAMC1.U4
DQC0_26: GPU1.R8 VRAMC1.U2
DQC0_27: GPU1.R6 VRAMC1.T2
DQC0_28: GPU1.U7 VRAMC1.N2
DQC0_29: GPU1.U6 VRAMC1.M2
DQC0_30: GPU1.V8 VRAMC1.N4
DQC0_31: GPU1.V7 VRAMC1.M4
DQC1_0: GPU1.AA4 VRAMC2.N11
DQC1_1: GPU1.AC2 VRAMC2.M13
DQC1_2: GPU1.AC1 VRAMC2.M11
DQC1_3: GPU1.AD1 VRAMC2.N13
DQC1_4: GPU1.AE3 VRAMC2.T11
DQC1_5: GPU1.AE2 VRAMC2.T13
DQC1_6: GPU1.AF2 VRAMC2.U11
DQC1_7: GPU1.AF1 VRAMC2.U13
DQC1_8: GPU1.U4 VRAMC2.U4
DQC1_9: GPU1.U3 VRAMC2.U2
DQC1_10: GPU1.U1 VRAMC2.T4
DQC1_11: GPU1.V2 VRAMC2.T2
DQC1_12: GPU1.W2 VRAMC2.M2
DQC1_13: GPU1.Y4 VRAMC2.M4
DQC1_14: GPU1.Y1 VRAMC2.N2
DQC1_15: GPU1.Y3 VRAMC2.N4
DQC1_16: GPU1.V4 VRAMC2.F4
DQC1_17: GPU1.V5 VRAMC2.E4
DQC1_18: GPU1.W6 VRAMC2.F2
DQC1_19: GPU1.W5 VRAMC2.E2
DQC1_20: GPU1.Y6 VRAMC2.B2
DQC1_21: GPU1.Y7 VRAMC2.A2
DQC1_22: GPU1.Y9 VRAMC2.B4
DQC1_23: GPU1.AA5 VRAMC2.A4
DQC1_24: GPU1.AC7 VRAMC2.F11
DQC1_25: GPU1.AC5 VRAMC2.E11
DQC1_26: GPU1.AC4 VRAMC2.B11
DQC1_27: GPU1.AD9 VRAMC2.A11
DQC1_28: GPU1.AE8 VRAMC2.B13
DQC1_29: GPU1.AE6 VRAMC2.A13
DQC1_30: GPU1.AE5 VRAMC2.E13
DQC1_31: GPU1.AF10 VRAMC2.F13
DQD0_0: GPU1.AF7 VRAMD1.M13
DQD0_1: GPU1.AF5 VRAMD1.U13
DQD0_2: GPU1.AF4 VRAMD1.N13
DQD0_3: GPU1.AG6 VRAMD1.T13
DQD0_4: GPU1.AJ6 VRAMD1.U11
DQD0_5: GPU1.AJ5 VRAMD1.T11
DQD0_6: GPU1.AJ9 VRAMD1.N11
DQD0_7: GPU1.AK7 VRAMD1.M11
DQD0_8: GPU1.AM7 VRAMD1.T4
DQD0_9: GPU1.AM6 VRAMD1.U4
DQD0_10: GPU1.AN6 VRAMD1.T2
DQD0_11: GPU1.AN5 VRAMD1.U2
DQD0_12: GPU1.AR7 VRAMD1.N2
DQD0_13: GPU1.AT6 VRAMD1.M2
DQD0_14: GPU1.AT8 VRAMD1.N4
DQD0_15: GPU1.AV5 VRAMD1.M4
DQD0_16: GPU1.AG1 VRAMD1.A11
DQD0_17: GPU1.AG3 VRAMD1.A13
DQD0_18: GPU1.AG4 VRAMD1.B11
DQD0_19: GPU1.AJ2 VRAMD1.B13
DQD0_20: GPU1.AK2 VRAMD1.F13
DQD0_21: GPU1.AM4 VRAMD1.E13
DQD0_22: GPU1.AM3 VRAMD1.E11
DQD0_23: GPU1.AM1 VRAMD1.F11
DQD0_24: GPU1.AR1 VRAMD1.E4
DQD0_25: GPU1.AR2 VRAMD1.F4
DQD0_26: GPU1.AT1 VRAMD1.F2
DQD0_27: GPU1.AT3 VRAMD1.E2
DQD0_28: GPU1.AV3 VRAMD1.B2
DQD0_29: GPU1.AW1 VRAMD1.B4
DQD0_30: GPU1.AY2 VRAMD1.A2
DQD0_31: GPU1.BA1 VRAMD1.A4
DQD1_0: GPU1.AW3 VRAMD2.F4
DQD1_1: GPU1.AW4 VRAMD2.E4
DQD1_2: GPU1.BA5 VRAMD2.E2
DQD1_3: GPU1.AY5 VRAMD2.F2
DQD1_4: GPU1.AU9 VRAMD2.B2
DQD1_5: GPU1.AW9 VRAMD2.B4
DQD1_6: GPU1.AY9 VRAMD2.A4
DQD1_7: GPU1.AT11 VRAMD2.A2
DQD1_8: GPU1.AU12 VRAMD2.F11
DQD1_9: GPU1.AV12 VRAMD2.E11
DQD1_10: GPU1.AU14 VRAMD2.B11
DQD1_11: GPU1.AW14 VRAMD2.A11
DQD1_12: GPU1.AT15 VRAMD2.A13
DQD1_13: GPU1.AV15 VRAMD2.B13
DQD1_14: GPU1.AU17 VRAMD2.F13
DQD1_15: GPU1.AV17 VRAMD2.E13
DQD1_16: GPU1.BB4 VRAMD2.U2
DQD1_17: GPU1.BC3 VRAMD2.U4
DQD1_18: GPU1.BC5 VRAMD2.T4
DQD1_19: GPU1.BA6 VRAMD2.T2
DQD1_20: GPU1.BA8 VRAMD2.M2
DQD1_21: GPU1.BC8 VRAMD2.M4
DQD1_22: GPU1.BB9 VRAMD2.N4
DQD1_23: GPU1.BC9 VRAMD2.N2
DQD1_24: GPU1.AY12 VRAMD2.N11
DQD1_25: GPU1.BA12 VRAMD2.M11
DQD1_26: GPU1.BC12 VRAMD2.M13
DQD1_27: GPU1.BB14 VRAMD2.N13
DQD1_28: GPU1.BB15 VRAMD2.T13
DQD1_29: GPU1.AY17 VRAMD2.T11
DQD1_30: GPU1.BA17 VRAMD2.U13
DQD1_31: GPU1.BC17 VRAMD2.U11
DRAM_RST1: R616.1 VRAMA1.J2 VRAMA2.J2 VRAMB1.J2 VRAMB2.J2
DRAM_RST1_R: GPU1.M14 R617.2 R618.1
DRAM_RST1_RR: C737.1 R616.2 R617.1
DRAM_RST2: R625.1 VRAMC1.J2 VRAMC2.J2 VRAMD1.J2 VRAMD2.J2
DRAM_RST2_R: GPU1.AK19 R626.2 R627.1
DRAM_RST2_RR: C740.1 R625.2 R626.1
EC_3D3V_AUX_S5: C284.1 Q9.S R181.1 R191.2 R2414.2 R2466.2
EC_3D3V_S0: C291.1 C292.1 Q15.2 Q15.5 R231.1 R232.2 R233.1 R2413.2 R2457.1 RN15.1(A) RN15.2(A) U2.1 U3.5
EC_AD0: C1009.1 KBC1.97 R2720.2
EC_AGND: C276.2 C277.2 C1004.1 C1009.2 C1016.1 C1146.1 KBC1.103 R177.2 R178.2 R2419.2 R2670.2
EC_AUD_RST_N: KBC1.82 PD2.K
EC_AVCC: C276.1 C277.1 KBC1.102 R171.2 R172.1 R183.1
EC_BEEP_GPIO_EC: KBC1.118 R2461.2
EC_CLEAR_RTC: KBC1.65 Q37.G R464.1
EC_DEBUG: KBC1.111 TP68.1
EC_I2C_CLK: KBC1.119 R2512.1 R2516.1 RN45.1(A) U2505.6 U2506.6
EC_I2C_DATA: KBC1.120 R2511.1 R2515.1 RN45.2(A) U2505.5 U2506.5
EC_PECI: KBC1.13 TP67.1
EC_SCI#: CPU1.AR3 R2433.2 RN2407.3(B)
EC_SENSE_BT1: C1146.2 KBC1.96 R2669.2 R2670.1
EC_SMI#: CPU1.AN3 R2437.1 RN2407.4(B)
EC_SPI_CLK: R2678.1 RN42.1(A)
EC_SPI_CLK_R: KBC1.92 R2672.2 R2678.2
EC_SPI_CS0_N: R2676.1 RN42.2(A)
EC_SPI_CS0_N_R: KBC1.90 R2674.2 R2676.2
EC_SPI_SI: R2679.1 RN43.2(A)
EC_SPI_SI_R: KBC1.87 R2673.2 R2679.2
EC_SPI_SO: R2677.1 RN43.1(A)
EC_SPI_SO_R: KBC1.86 R2675.2 R2677.2
EC_SWI#: CPU1.AP1 R2439.1 RN2408.3(B)
EC_VBKUP: KBC1.114 R2469.1
EC_VCC1D8V_S5: KBC1.88 R2412.2 R2425.1
EC_VDD3D3: C1006.1 C1010.1 KBC1.4 R2425.2 R2457.2
EC_VSBY: KBC1.75 R2466.1
ECRST#: C275.1 KBC1.85 Q8.E R182.2 R2631.2
ECSCI#_KBC: KBC1.29 R2433.1
ECSMI#_KBC: KBC1.11 R2437.2
ECSWI#_KBC: KBC1.123 R2439.2
EDCA0_0: GPU1.R41 VRAMA1.C13
EDCA0_1: GPU1.F42 VRAMA1.C2
EDCA0_2: GPU1.R39 VRAMA1.R13
EDCA0_3: GPU1.H38 VRAMA1.R2
EDCA1_0: GPU1.B38 VRAMA2.R2
EDCA1_1: GPU1.C29 VRAMA2.R13
EDCA1_2: GPU1.D35 VRAMA2.C2
EDCA1_3: GPU1.G27 VRAMA2.C13
EDCB0_0: GPU1.F24 VRAMB1.R13
EDCB0_1: GPU1.J19 VRAMB1.R2
EDCB0_2: GPU1.A18 VRAMB1.C2
EDCB0_3: GPU1.D24 VRAMB1.C13
EDCB1_0: GPU1.E15 VRAMB2.C2
EDCB1_1: GPU1.D9 VRAMB2.C13
EDCB1_2: GPU1.A12 VRAMB2.R2
EDCB1_3: GPU1.B5 VRAMB2.R13
EDCC0_0: GPU1.E2 VRAMC1.C13
EDCC0_1: GPU1.M1 VRAMC1.C2
EDCC0_2: GPU1.J4 VRAMC1.R13
EDCC0_3: GPU1.R5 VRAMC1.R2
EDCC1_0: GPU1.AD4 VRAMC2.R13
EDCC1_1: GPU1.V1 VRAMC2.R2
EDCC1_2: GPU1.W9 VRAMC2.C2
EDCC1_3: GPU1.AD6 VRAMC2.C13
EDCD0_0: GPU1.AG7 VRAMD1.R13
EDCD0_1: GPU1.AR4 VRAMD1.R2
EDCD0_2: GPU1.AJ3 VRAMD1.C13
EDCD0_3: GPU1.AV2 VRAMD1.C2
EDCD1_0: GPU1.AV8 VRAMD2.C2
EDCD1_1: GPU1.AW15 VRAMD2.C13
EDCD1_2: GPU1.BB6 VRAMD2.R2
EDCD1_3: GPU1.BA15 VRAMD2.R13
EDP_CABLE_DET: KBC1.55 LAUOC1.25
EFUSE_PWR: PCH1.Y21 R161.2
EGPIO97: CPU1.AW12 RN2402.4(B)
ESPI_RESET_L/KBRST_L: CPU1.AN24 R37.1
FB_VDDC_VR: GPU1.AL21 PR252.2
FB_VDDCI: GPU1.AK23 PR261.1
FB_VSSC: GPU1.AK21 PR254.2 PR263.1
FDT_OVRD_GPIO: CPU1.AN8 Q36.C R130.1 R134.1 R459.2
FDT_OVRD_GPIO_C: JMP1.1 R459.1
FWH_ID0: LPC1.6 R458.2
G2042_VDDCR_C: C450.1 R2605.2 R2606.2 U17.3
GPIO_6_TACH: GPU1.AE34 R2634.2 TP2505.1
GPP_CLK0N: PCH1.A9 R2653.1
GPP_CLK0N_R: CPU1.AG6 R2653.2
GPP_CLK0P: PCH1.A8 R2652.1
GPP_CLK0P_R: CPU1.AG5 R2652.2
GPU_AUX_ZVSS: GPU1.AY24 R720.1
GPU_BLON_PWM: GPU1.AL26 R504.2 R2579.1
GPU_DP_ZVDD_08: GPU1.AT36 R718.2
GPU_DP_ZVSS: GPU1.AV36 R719.2
GPU_DPLUS: C1121.1 GPU1.AC35 KBC1.108
GPU_EDP_AUX_SCL: C955.2 DISPC2.18
GPU_EDP_AUX_SCL_C: C955.1 GPU1.AU27
GPU_EDP_AUX_SDA: C956.2 DISPC2.19
GPU_EDP_AUX_SDA_C: C956.1 GPU1.AV27
GPU_EDP_HPD: DISPC2.3 R2748.2 R2749.2 R2750.1
GPU_EDP_HPD3: GPU1.AT29 R2748.1
GPU_EDP_HPD4: GPU1.AU29 R2749.1
GPU_EDP_IN0N: C920.2 DISPC2.7
GPU_EDP_IN0N_C: C920.1 GPU1.BA24
GPU_EDP_IN0P: C919.2 DISPC2.6
GPU_EDP_IN0P_C: C919.1 GPU1.BA25
GPU_EDP_IN1N: C922.2 DISPC2.10
GPU_EDP_IN1N_C: C922.1 GPU1.BB24
GPU_EDP_IN1P: C921.2 DISPC2.9
GPU_EDP_IN1P_C: C921.1 GPU1.BC24
GPU_EDP_IN2N: C924.2 DISPC2.13
GPU_EDP_IN2N_C: C924.1 GPU1.BC23
GPU_EDP_IN2P: C923.2 DISPC2.12
GPU_EDP_IN2P_C: C923.1 GPU1.BB23
GPU_EDP_IN3N: C954.2 DISPC2.16
GPU_EDP_IN3N_C: C954.1 GPU1.AY21
GPU_EDP_IN3P: C953.2 DISPC2.15
GPU_EDP_IN3P_C: C953.1 GPU1.AY23
GPU_GPIO_1: GPU1.V38 R507.2 R508.1
GPU_GPIO_8_ROMSO: GPU1.AN30 RN2411.2(A)
GPU_GPIO_8_ROMSO_R: R515.2 R516.1 RN2411.3(B) U28.2
GPU_GPIO_9_ROMSI: GPU1.AP32 RN2410.3(B)
GPU_GPIO_9_ROMSI_R: R517.2 R518.1 RN2410.2(A) U28.5
GPU_GPIO_10_ROMSCK: GPU1.AM30 RN2410.4(B)
GPU_GPIO_10_ROMSCK_R: RN2410.1(A) U28.6
GPU_GPIO_11: GPU1.V43 R527.1 R528.2
GPU_GPIO_12: GPU1.V42 R524.2 R525.1
GPU_GPIO_13: GPU1.V41 R520.1 R521.2
GPU_GPIO_15: GPU1.AJ31 R2702.1
GPU_GPIO_19_CTF: GPU1.AC31 R602.1 R2577.1
GPU_GPIO_19_CTF_R: D11.3 R602.2 R603.1 R604.1
GPU_GPIO_20: GPU1.AK33 R531.2 R532.1
GPU_GPIO_22_ROMCSB: GPU1.AN32 R533.1 R534.2 RN2411.1(A)
GPU_GPIO_22_ROMCSB_R: R552.2 RN2411.4(B) U28.1
GPU_GPIO_29: GPU1.AG31 R535.1 R536.2
GPU_GPIO_30_PCC_R: GPU1.AG30 R485.1
GPU_HDMI_OUT0N: C912.2 DISPC2.37
GPU_HDMI_OUT0N_C: C912.1 GPU1.BB32
GPU_HDMI_OUT0P: C911.2 DISPC2.38
GPU_HDMI_OUT0P_C: C911.1 GPU1.BC32
GPU_HDMI_OUT1N: C914.2 DISPC2.34
GPU_HDMI_OUT1N_C: C914.1 GPU1.BC30
GPU_HDMI_OUT1P: C913.2 DISPC2.35
GPU_HDMI_OUT1P_C: C913.1 GPU1.BB30
GPU_HDMI_OUT2N: C916.2 DISPC2.31
GPU_HDMI_OUT2N_C: C916.1 GPU1.AY29
GPU_HDMI_OUT2P: C915.2 DISPC2.32
GPU_HDMI_OUT2P_C: C915.1 GPU1.AY30
GPU_HDMI_OUT_CKN: C918.2 DISPC2.28
GPU_HDMI_OUT_CKN_C: C918.1 GPU1.BB29
GPU_HDMI_OUT_CKP: C917.2 DISPC2.29
GPU_HDMI_OUT_CKP_C: C917.1 GPU1.BC29
GPU_HDMI_OUT_SCL: DISPC2.26 GPU1.AU35 R2643.2
GPU_HDMI_OUT_SDA: DISPC2.25 GPU1.AV35 R2642.2
GPU_HPD_HDMI: DISPC2.24 GPU1.AU30 R1210.1
GPU_I2C_SCL: GPU1.AF34 R478.2
GPU_I2C_SDA: GPU1.AF33 R479.2
GPU_P_ZVSS: GPU1.AK30 R475.1
GPU_PPC_EC: KBC1.62 R2721.2
GPU_PPC_R: PQ12.G PR420.2 R480.2 R485.2 R2709.1 R2710.1 R2713.1 R2721.1
GPU_SMB_CLK_MAIN: GPU1.AM34 Q76.4 R2637.2
GPU_SMB_CLK_MAIN_G: Q76.5 R2636.2
GPU_SMB_DATA_MAIN: GPU1.AM33 Q76.1 R2639.2
GPU_SMB_DATA_MAIN_G: Q76.2 R2638.2
GPU_TEST_PG: GPU1.AA31 Q42.C R484.1 R487.2
GPU_TEST_PG_B: Q41.C Q42.B R483.1
GPU_TEST_PG_BACO: GPU1.Y32 Q43.C R489.1 R490.1
GPU_TEST_PG_BACO_B: Q43.B Q44.C R491.1
GPU_VBIOS_PWR: R559.2 R2732.2 U28.3
GPU_VCC3_CTL: C947.1 Q53.G R584.2
GPU_VCC3_CTL_2: C948.1 Q54.G R1195.2
GPU_WAKEB: GPU1.AV43 R495.2
GVDD_AB1: C409.2 R325.2 U8.3
H_PROCHOT_N: C1011.1 PQ2.D PQ12.D PR86.1 Q1.D Q67.D R17.1 R204.2 R2506.2
H_PROCHOT_N_EC: KBC1.24 Q67.S R204.1 R2438.1 RN44.1(A)
HDA_BITCLK_CODEC: R65.1 R278.2
HDA_BITCLK_CPU: C2532.1 CPU1.AW3 R65.2 R2693.2
HDA_RST#_CODEC: R2690.2 R2691.1
HDA_RST#_CPU: CPU1.AU1 R2691.2 R2692.2
HDA_SDIN0_CPU: CPU1.AV3 R275.2
HDA_SDIN1: CPU1.AU5 R55.1
HDA_SDOUT_CODEC: R64.1 U6.17
HDA_SDOUT_CPU: CPU1.AU4 R53.2 R64.2
HDA_SYNC_CODEC: R61.1 U6.14
HDA_SYNC_CPU: CPU1.AU2 R54.2 R61.2
HDMI_DET: KBC1.43 LAUOC1.3
HDT1_11: HDT1.11 R722.2
HDT1_13: HDT1.13 R723.2
HDT1_15: HDT1.15 R724.2
HDT_DBREQ#: HDT1.16 R725.1
HDT_PWR_EN1: Q81.2 Q81.3 R2757.2
HDT_PWR_EN2: Q80.G Q81.6 R2755.2 R2756.2
HDT_PWR_EN3: C2512.1 Q82.G R2756.1
HDT_TRST#: HDT1.9 R721.2
HOOD_SW_DET#: CPU1.AT6 R131.1 R137.2
HPOL_CON: C343.1 L12.2 R2626.2 SUSBC1.17
HPOR_CON: C342.1 L13.2 R2625.2 SUSBC1.19
HPOUT_L_R: L12.1 R289.2
HPOUT_R_R: L13.1 R290.2
HSYNC: GPU1.AP24 R2741.2
I2C3_CLK_RESUME: CPU1.AK3 R2700.1 RN5.3(B) U23.31
I2C3_DATA_RESUME: CPU1.AK2 R2701.1 RN5.4(B) U23.32
I2C_CLK: R283.1 R2514.1 R2518.1 U6.12
I2C_CLK_CN: LAUOC1.18 R2698.2 R2700.2
I2C_DATA: R284.1 R2513.1 R2517.1 U6.11
I2C_DATA_CN: LAUOC1.17 R2699.2 R2701.2
INIT_3V: LPC1.2 R453.2
INT#_TYPEC: CPU1.AR1 LAUOC1.19 RN2408.4(B)
INT_SERIRQ: CPU1.AW21 KBC1.125 R2714.1
IPCC_3D3V_S5: C466.1 IPCC1.1 PC88.1 PC92.1 PR50.1 PR420.1 R2667.2 R2668.2 R2712.1 U23.27 U24.3
IPCC_AC_PROTECT: PQ2.G PR50.2 R2761.1 U23.8
IPCC_AGND: C466.2 C467.2 PC87.2 PC88.2 R403.1 R2501.2 R2505.2 U23.26 U23.28 U23.33
IPCC_CMP_VREF: R403.2 U23.17
IPCC_CPU0: CPU1.AR4 R2688.2 R2689.1 R2722.1
IPCC_CPU0_R: R2722.2 U23.7
IPCC_CPU1: CPU1.AN2 R2686.2 R2687.1 R2723.1
IPCC_CPU1_R: R2723.2 U23.6
IPCC_CPU2: CPU1.AR6 R2684.2 R2685.1 R2724.1
IPCC_CPU2_R: R2724.2 U23.5
IPCC_I2C_CLK: R2696.2 U23.21
IPCC_I2C_CLK_R: KBC1.70 R2694.1 R2696.1 RN46.3(B)
IPCC_I2C_DATA: R2697.2 U23.22
IPCC_I2C_DATA_R: KBC1.69 R2695.1 R2697.1 RN46.4(B)
IPCC_INT_SIO#: KBC1.32 R2712.2 U23.23
IPCC_SWD_CLK: IPCC1.4 U23.12
IPCC_SWD_DATA: IPCC1.5 U23.11
IPCC_V_SENSE: R2720.1 U23.3 U24.6
IPCC_VCCD: PC87.1 U23.25
IPCC_VREF: C467.1 U23.1
IPCC_XRES#: IPCC1.3 U23.24
IPPC_GPU_CMP: R2711.2 U23.16
IPPC_GPU_CMP_R: R2501.1 R2711.1 R2713.2
IPPC_GPU_MAN: R2710.2 U23.10
IPPC_GPU_PPC: R2709.2 U23.9
JACK_PSID: L24.1 LAUOC1.6
JTAG_BP_0: GPU1.AW24 R513.2
JTAG_BP_0_R: R512.2 R513.1 TP42.1
JTAG_BP_1: GPU1.AV24 R514.2
JTAG_BP_1_R: R511.2 R514.1 TP43.1
JTAG_DRAIN: GPU1.AM20 TP45.1
JTAG_GATE: GPU1.AM21 TP44.1
JTAG_TCK: GPU1.AF30 TP110.1
JTAG_TDI: GPU1.AD30 TP108.1
JTAG_TDO: GPU1.AD31 TP107.1
JTAG_TMS: GPU1.AE31 TP109.1
JTAG_TRSTB: GPU1.AC30 R522.1 R526.1 TP112.1
KBC_ON#_GATE: C284.2 Q9.G Q10.S R194.2
KBC_ON#_GATE_L: R191.1 R193.2 R194.1
KBC_SPI_CLK: R2672.1 U45.6
KBC_SPI_CS0_N: R2674.1 RN2406.3(B) U45.1
KBC_SPI_IO2: RN2406.4(B) U45.3
KBC_SPI_IO3: R2671.2 U45.7
KBC_SPI_MISO: R2675.1 U45.2
KBC_SPI_MOSI: R2673.1 U45.5
KBC_VCC: C278.1 C279.1 C280.1 C281.1 C282.1 C283.1 KBC1.19 KBC1.46 KBC1.76 KBC1.115 R184.1
KBC_VCORF: C1005.1 KBC1.44
L_AD0: CPU1.AW20 KBC1.126 LPC1.5
L_AD1: CPU1.AV21 KBC1.127 LPC1.7
L_AD2: CPU1.AT21 KBC1.128 LPC1.9
L_AD3: CPU1.AT20 KBC1.1 LPC1.11
L_FRAME_N: CPU1.AW18 KBC1.3 LPC1.13 R124.1
LAN_DISABLE_N: CPU1.AT5 LAUOC1.24 R43.1
LPC_CLK0: R92.1 R454.2
LPC_CLK1: KBC1.2 R93.1
LPC_CLK_D: LPC1.1 R454.1
LPC_PME_N_R: KBC1.109 R2435.2
LPC_SMI_L: CPU1.AW17 PCH1.B7 R34.1
M2_PEDET: R440.2 R442.2 R2601.2 R2745.2 SSDC1.69
M_A_A0: CPU1.AA32 DIMM1.144
M_A_A1: CPU1.T32 DIMM1.133
M_A_A2: CPU1.T35 DIMM1.132
M_A_A3: CPU1.T31 DIMM1.131
M_A_A4: CPU1.R30 DIMM1.128
M_A_A5: CPU1.R33 DIMM1.126
M_A_A6: CPU1.R32 DIMM1.127
M_A_A7: CPU1.P34 DIMM1.122
M_A_A8: CPU1.P30 DIMM1.125
M_A_A9: CPU1.P31 DIMM1.121
M_A_A10: CPU1.AA36 DIMM1.146
M_A_A11: CPU1.P33 DIMM1.120
M_A_A12: CPU1.N35 DIMM1.119
M_A_A13: CPU1.AE32 DIMM1.158
M_A_ACT_N: CPU1.M35 DIMM1.114
M_A_BG0: CPU1.N31 DIMM1.115
M_A_BG1: CPU1.N32 DIMM1.113
M_A_BS0: CPU1.AA35 DIMM1.150
M_A_BS1: CPU1.AA33 DIMM1.145
M_A_CAS#: CPU1.AD32 DIMM1.156
M_A_CKE0: CPU1.M32 DIMM1.109
M_A_CKE1: CPU1.M30 DIMM1.110
M_A_CLK0: CPU1.T34 DIMM1.137
M_A_CLK1: CPU1.U33 DIMM1.138
M_A_CLK#0: CPU1.U34 DIMM1.139
M_A_CLK#1: CPU1.V33 DIMM1.140
M_A_CS#0: CPU1.AC33 DIMM1.149
M_A_CS#1: CPU1.AE35 DIMM1.157
M_A_DQ0: CPU1.E18 DIMM1.8
M_A_DQ1: CPU1.J18 DIMM1.7
M_A_DQ2: CPU1.J20 DIMM1.20
M_A_DQ3: CPU1.H21 DIMM1.21
M_A_DQ4: CPU1.H18 DIMM1.4
M_A_DQ5: CPU1.F18 DIMM1.3
M_A_DQ6: CPU1.G20 DIMM1.16
M_A_DQ7: CPU1.F20 DIMM1.17
M_A_DQ8: CPU1.H22 DIMM1.28
M_A_DQ9: CPU1.G22 DIMM1.29
M_A_DQ10: CPU1.E24 DIMM1.41
M_A_DQ11: CPU1.J24 DIMM1.42
M_A_DQ12: CPU1.F21 DIMM1.24
M_A_DQ13: CPU1.J21 DIMM1.25
M_A_DQ14: CPU1.H24 DIMM1.38
M_A_DQ15: CPU1.F24 DIMM1.37
M_A_DQ16: CPU1.J26 DIMM1.50
M_A_DQ17: CPU1.J27 DIMM1.49
M_A_DQ18: CPU1.G28 DIMM1.62
M_A_DQ19: CPU1.H28 DIMM1.63
M_A_DQ20: CPU1.H25 DIMM1.46
M_A_DQ21: CPU1.G25 DIMM1.45
M_A_DQ22: CPU1.E28 DIMM1.58
M_A_DQ23: CPU1.H27 DIMM1.59
M_A_DQ24: CPU1.F29 DIMM1.70
M_A_DQ25: CPU1.J30 DIMM1.71
M_A_DQ26: CPU1.H31 DIMM1.83
M_A_DQ27: CPU1.F32 DIMM1.84
M_A_DQ28: CPU1.J29 DIMM1.66
M_A_DQ29: CPU1.G29 DIMM1.67
M_A_DQ30: CPU1.E31 DIMM1.79
M_A_DQ31: CPU1.G31 DIMM1.80
M_A_DQ32: CPU1.AH34 DIMM1.174
M_A_DQ33: CPU1.AJ30 DIMM1.173
M_A_DQ34: CPU1.AK30 DIMM1.187
M_A_DQ35: CPU1.AL34 DIMM1.186
M_A_DQ36: CPU1.AH31 DIMM1.170
M_A_DQ37: CPU1.AH32 DIMM1.169
M_A_DQ38: CPU1.AK33 DIMM1.183
M_A_DQ39: CPU1.AK32 DIMM1.182
M_A_DQ40: CPU1.AM34 DIMM1.195
M_A_DQ41: CPU1.AM33 DIMM1.194
M_A_DQ42: CPU1.AP31 DIMM1.207
M_A_DQ43: CPU1.AR33 DIMM1.208
M_A_DQ44: CPU1.AL32 DIMM1.191
M_A_DQ45: CPU1.AL31 DIMM1.190
M_A_DQ46: CPU1.AP34 DIMM1.203
M_A_DQ47: CPU1.AP32 DIMM1.204
M_A_DQ48: CPU1.AR31 DIMM1.216
M_A_DQ49: CPU1.AK29 DIMM1.215
M_A_DQ50: CPU1.AM28 DIMM1.228
M_A_DQ51: CPU1.AL28 DIMM1.229
M_A_DQ52: CPU1.AM30 DIMM1.211
M_A_DQ53: CPU1.AN30 DIMM1.212
M_A_DQ54: CPU1.AP28 DIMM1.224
M_A_DQ55: CPU1.AR28 DIMM1.225
M_A_DQ56: CPU1.AK27 DIMM1.237
M_A_DQ57: CPU1.AK26 DIMM1.236
M_A_DQ58: CPU1.AP25 DIMM1.249
M_A_DQ59: CPU1.AR25 DIMM1.250
M_A_DQ60: CPU1.AN27 DIMM1.232
M_A_DQ61: CPU1.AM27 DIMM1.233
M_A_DQ62: CPU1.AL25 DIMM1.245
M_A_DQ63: CPU1.AM25 DIMM1.246
M_A_DQS_DN0: CPU1.G19 DIMM1.11
M_A_DQS_DN1: CPU1.G23 DIMM1.32
M_A_DQS_DN2: CPU1.F26 DIMM1.53
M_A_DQS_DN3: CPU1.E30 DIMM1.74
M_A_DQS_DN4: CPU1.AJ34 DIMM1.177
M_A_DQS_DN5: CPU1.AN33 DIMM1.198
M_A_DQS_DN6: CPU1.AN29 DIMM1.219
M_A_DQS_DN7: CPU1.AN26 DIMM1.240
M_A_DQS_DN8: DIMM1.95 R109.2
M_A_DQS_DP0: CPU1.H19 DIMM1.13
M_A_DQS_DP1: CPU1.F23 DIMM1.34
M_A_DQS_DP2: CPU1.F27 DIMM1.55
M_A_DQS_DP3: CPU1.F30 DIMM1.76
M_A_DQS_DP4: CPU1.AJ33 DIMM1.179
M_A_DQS_DP5: CPU1.AN32 DIMM1.200
M_A_DQS_DP6: CPU1.AP29 DIMM1.221
M_A_DQS_DP7: CPU1.AP26 DIMM1.242
M_A_DQS_DP8: DIMM1.97 R110.2
M_A_EVENT#: CPU1.W35 DIMM1.134 RN2416.4(B)
M_A_ODT0: CPU1.AD35 DIMM1.155
M_A_ODT1: CPU1.AF31 DIMM1.161
M_A_RAS#: CPU1.AB34 DIMM1.152
M_A_WE#: CPU1.AB35 DIMM1.151
M_B_A0: CPU1.AC36 DIMM2.144
M_B_A1: CPU1.U36 DIMM2.133
M_B_A2: CPU1.U37 DIMM2.132
M_B_A3: CPU1.T38 DIMM2.131
M_B_A4: CPU1.T37 DIMM2.128
M_B_A5: CPU1.R39 DIMM2.126
M_B_A6: CPU1.R36 DIMM2.127
M_B_A7: CPU1.P39 DIMM2.122
M_B_A8: CPU1.R38 DIMM2.125
M_B_A9: CPU1.P36 DIMM2.121
M_B_A10: CPU1.AC39 DIMM2.146
M_B_A11: CPU1.P37 DIMM2.120
M_B_A12: CPU1.N38 DIMM2.119
M_B_A13: CPU1.AG38 DIMM2.158
M_B_ACT_N: CPU1.M38 DIMM2.114
M_B_BG0: CPU1.M36 DIMM2.115
M_B_BG1: CPU1.M39 DIMM2.113
M_B_BS0: CPU1.AD38 DIMM2.150
M_B_BS1: CPU1.AC37 DIMM2.145
M_B_CAS#: CPU1.AF36 DIMM2.156
M_B_CKE0: CPU1.L37 DIMM2.109
M_B_CKE1: CPU1.K37 DIMM2.110
M_B_CLK0: CPU1.U39 DIMM2.137
M_B_CLK1: CPU1.V38 DIMM2.138
M_B_CLK#0: CPU1.V39 DIMM2.139
M_B_CLK#1: CPU1.W38 DIMM2.140
M_B_CS#0: CPU1.AE37 DIMM2.149
M_B_CS#1: CPU1.AG39 DIMM2.157
M_B_DQ0: CPU1.D20 DIMM2.8
M_B_DQ1: CPU1.B21 DIMM2.7
M_B_DQ2: CPU1.B24 DIMM2.20
M_B_DQ3: CPU1.C24 DIMM2.21
M_B_DQ4: CPU1.A20 DIMM2.4
M_B_DQ5: CPU1.C20 DIMM2.3
M_B_DQ6: CPU1.A23 DIMM2.16
M_B_DQ7: CPU1.C23 DIMM2.17
M_B_DQ8: CPU1.A26 DIMM2.28
M_B_DQ9: CPU1.C26 DIMM2.29
M_B_DQ10: CPU1.A29 DIMM2.41
M_B_DQ11: CPU1.C29 DIMM2.42
M_B_DQ12: CPU1.A25 DIMM2.24
M_B_DQ13: CPU1.B25 DIMM2.25
M_B_DQ14: CPU1.A28 DIMM2.38
M_B_DQ15: CPU1.B28 DIMM2.37
M_B_DQ16: CPU1.A31 DIMM2.50
M_B_DQ17: CPU1.B31 DIMM2.49
M_B_DQ18: CPU1.B34 DIMM2.62
M_B_DQ19: CPU1.C35 DIMM2.63
M_B_DQ20: CPU1.B30 DIMM2.46
M_B_DQ21: CPU1.C30 DIMM2.45
M_B_DQ22: CPU1.B33 DIMM2.58
M_B_DQ23: CPU1.A34 DIMM2.59
M_B_DQ24: CPU1.B36 DIMM2.70
M_B_DQ25: CPU1.E36 DIMM2.71
M_B_DQ26: CPU1.C39 DIMM2.83
M_B_DQ27: CPU1.D38 DIMM2.84
M_B_DQ28: CPU1.A35 DIMM2.66
M_B_DQ29: CPU1.C36 DIMM2.67
M_B_DQ30: CPU1.B38 DIMM2.79
M_B_DQ31: CPU1.C38 DIMM2.80
M_B_DQ32: CPU1.AK39 DIMM2.174
M_B_DQ33: CPU1.AL37 DIMM2.173
M_B_DQ34: CPU1.AN36 DIMM2.187
M_B_DQ35: CPU1.AN39 DIMM2.186
M_B_DQ36: CPU1.AK38 DIMM2.170
M_B_DQ37: CPU1.AK36 DIMM2.169
M_B_DQ38: CPU1.AM39 DIMM2.183
M_B_DQ39: CPU1.AN38 DIMM2.182
M_B_DQ40: CPU1.AR36 DIMM2.195
M_B_DQ41: CPU1.AR37 DIMM2.194
M_B_DQ42: CPU1.AU37 DIMM2.207
M_B_DQ43: CPU1.AV37 DIMM2.208
M_B_DQ44: CPU1.AP37 DIMM2.191
M_B_DQ45: CPU1.AP38 DIMM2.190
M_B_DQ46: CPU1.AT36 DIMM2.203
M_B_DQ47: CPU1.AU38 DIMM2.204
M_B_DQ48: CPU1.AW35 DIMM2.216
M_B_DQ49: CPU1.AU35 DIMM2.215
M_B_DQ50: CPU1.AW32 DIMM2.228
M_B_DQ51: CPU1.AU32 DIMM2.229
M_B_DQ52: CPU1.AV36 DIMM2.211
M_B_DQ53: CPU1.AW36 DIMM2.212
M_B_DQ54: CPU1.AW33 DIMM2.224
M_B_DQ55: CPU1.AV33 DIMM2.225
M_B_DQ56: CPU1.AW30 DIMM2.237
M_B_DQ57: CPU1.AV30 DIMM2.236
M_B_DQ58: CPU1.AW27 DIMM2.249
M_B_DQ59: CPU1.AW26 DIMM2.250
M_B_DQ60: CPU1.AV31 DIMM2.232
M_B_DQ61: CPU1.AU31 DIMM2.233
M_B_DQ62: CPU1.AV28 DIMM2.245
M_B_DQ63: CPU1.AV27 DIMM2.246
M_B_DQS_DN0: CPU1.A22 DIMM2.11
M_B_DQS_DN1: CPU1.B27 DIMM2.32
M_B_DQS_DN2: CPU1.C32 DIMM2.53
M_B_DQS_DN3: CPU1.A37 DIMM2.74
M_B_DQS_DN4: CPU1.AM36 DIMM2.177
M_B_DQS_DN5: CPU1.AT39 DIMM2.198
M_B_DQS_DN6: CPU1.AV34 DIMM2.219
M_B_DQS_DN7: CPU1.AU29 DIMM2.240
M_B_DQS_DN8: DIMM2.95 R119.2
M_B_DQS_DP0: CPU1.B22 DIMM2.13
M_B_DQS_DP1: CPU1.C27 DIMM2.34
M_B_DQS_DP2: CPU1.C33 DIMM2.55
M_B_DQS_DP3: CPU1.B37 DIMM2.76
M_B_DQS_DP4: CPU1.AM37 DIMM2.179
M_B_DQS_DP5: CPU1.AT38 DIMM2.200
M_B_DQS_DP6: CPU1.AU34 DIMM2.221
M_B_DQS_DP7: CPU1.AU28 DIMM2.242
M_B_DQS_DP8: DIMM2.97 R120.2
M_B_EVENT#: CPU1.AA38 DIMM2.134 RN2416.3(B)
M_B_ODT0: CPU1.AF39 DIMM2.155
M_B_ODT1: CPU1.AH36 DIMM2.161
M_B_RAS#: CPU1.AD36 DIMM2.152
M_B_WE#: CPU1.AD39 DIMM2.151
MA_DM0: CPU1.K19 DIMM1.12
MA_DM1: CPU1.J23 DIMM1.33
MA_DM2: CPU1.G26 DIMM1.54
MA_DM3: CPU1.H30 DIMM1.75
MA_DM4: CPU1.AJ31 DIMM1.178
MA_DM5: CPU1.AM31 DIMM1.199
MA_DM6: CPU1.AL29 DIMM1.220
MA_DM7: CPU1.AL26 DIMM1.241
MA_ZV: CPU1.Y34 R10.2
MA_ZVSS: CPU1.AJ37 R12.2
MAA0_0: GPU1.U32 VRAMA1.H4
MAA0_1: GPU1.U34 VRAMA1.H5
MAA0_2: GPU1.V31 VRAMA1.H11
MAA0_3: GPU1.U35 VRAMA1.H10
MAA0_4: GPU1.V36 VRAMA1.K11
MAA0_5: GPU1.V33 VRAMA1.K10
MAA0_6: GPU1.R33 VRAMA1.K5
MAA0_7: GPU1.R35 VRAMA1.K4
MAA0_8: GPU1.U31 VRAMA1.J5
MAA1_0: GPU1.H33 VRAMA2.K4
MAA1_1: GPU1.M32 VRAMA2.K5
MAA1_2: GPU1.J32 VRAMA2.K11
MAA1_3: GPU1.K32 VRAMA2.K10
MAA1_4: GPU1.K30 VRAMA2.H11
MAA1_5: GPU1.L30 VRAMA2.H10
MAA1_6: GPU1.H35 VRAMA2.H5
MAA1_7: GPU1.L33 VRAMA2.H4
MAA1_8: GPU1.J33 VRAMA2.J5
MAB0_0: GPU1.H23 VRAMB1.H4
MAB0_1: GPU1.N24 VRAMB1.H5
MAB0_2: GPU1.K24 VRAMB1.H11
MAB0_3: GPU1.M24 VRAMB1.H10
MAB0_4: GPU1.L25 VRAMB1.K11
MAB0_5: GPU1.M25 VRAMB1.K10
MAB0_6: GPU1.N23 VRAMB1.K5
MAB0_7: GPU1.L23 VRAMB1.K4
MAB0_8: GPU1.K23 VRAMB1.J5
MAB1_0: GPU1.N18 VRAMB2.K4
MAB1_1: GPU1.K17 VRAMB2.K5
MAB1_2: GPU1.N17 VRAMB2.K11
MAB1_3: GPU1.M17 VRAMB2.K10
MAB1_4: GPU1.L15 VRAMB2.H11
MAB1_5: GPU1.J15 VRAMB2.H10
MAB1_6: GPU1.P19 VRAMB2.H5
MAB1_7: GPU1.K18 VRAMB2.H4
MAB1_8: GPU1.L18 VRAMB2.J5
MAC0_0: GPU1.V13 VRAMC1.H4
MAC0_1: GPU1.U10 VRAMC1.H5
MAC0_2: GPU1.U13 VRAMC1.H11
MAC0_3: GPU1.U12 VRAMC1.H10
MAC0_4: GPU1.R11 VRAMC1.K11
MAC0_5: GPU1.R9 VRAMC1.K10
MAC0_6: GPU1.W14 VRAMC1.K5
MAC0_7: GPU1.V10 VRAMC1.K4
MAC0_8: GPU1.V11 VRAMC1.J5
MAC1_0: GPU1.AC8 VRAMC2.K4
MAC1_1: GPU1.AD13 VRAMC2.K5
MAC1_2: GPU1.AD10 VRAMC2.K11
MAC1_3: GPU1.AD12 VRAMC2.K10
MAC1_4: GPU1.AE11 VRAMC2.H11
MAC1_5: GPU1.AE12 VRAMC2.H10
MAC1_6: GPU1.AC13 VRAMC2.H5
MAC1_7: GPU1.AC11 VRAMC2.H4
MAC1_8: GPU1.AC10 VRAMC2.J5
MAD0_0: GPU1.AN8 VRAMD1.H4
MAD0_1: GPU1.AM12 VRAMD1.H5
MAD0_2: GPU1.AM9 VRAMD1.H11
MAD0_3: GPU1.AM10 VRAMD1.H10
MAD0_4: GPU1.AK10 VRAMD1.K11
MAD0_5: GPU1.AK11 VRAMD1.K10
MAD0_6: GPU1.AR8 VRAMD1.K5
MAD0_7: GPU1.AN11 VRAMD1.K4
MAD0_8: GPU1.AN9 VRAMD1.J5
MAD1_0: GPU1.AM17 VRAMD2.K4
MAD1_1: GPU1.AP17 VRAMD2.K5
MAD1_2: GPU1.AL18 VRAMD2.K11
MAD1_3: GPU1.AR17 VRAMD2.K10
MAD1_4: GPU1.AT18 VRAMD2.H11
MAD1_5: GPU1.AN18 VRAMD2.H10
MAD1_6: GPU1.AN15 VRAMD2.H5
MAD1_7: GPU1.AR15 VRAMD2.H4
MAD1_8: GPU1.AL17 VRAMD2.J5
MAINPOWER_CONTROL: R1196.1 R1198.2 R1202.2
MB_DM0: CPU1.C21 DIMM2.12
MB_DM1: CPU1.D26 DIMM2.33
MB_DM2: CPU1.A32 DIMM2.54
MB_DM3: CPU1.D37 DIMM2.75
MB_DM4: CPU1.AL38 DIMM2.178
MB_DM5: CPU1.AR39 DIMM2.199
MB_DM6: CPU1.AT35 DIMM2.220
MB_DM7: CPU1.AW29 DIMM2.241
MB_ZV: CPU1.Y36 R11.2
MB_ZVSS: CPU1.AJ39 R13.2
ME_CNTL1: Q36.B R457.1
ME_UNLOCK: KBC1.23 R455.1 R457.2
MEM_CALRA: GPU1.Y31 R610.1
MEM_CALRB: GPU1.P15 R612.1
MEM_CALRC: GPU1.R14 R621.1
MEM_CALRD: GPU1.AL20 R622.1
MF_A0: R683.1 VRAMA1.J1
MF_A1: R684.1 VRAMA2.J1
MF_B0: R642.1 VRAMB1.J1
MF_B1: R639.1 VRAMB2.J1
MF_C0: R686.1 VRAMC1.J1
MF_C1: R709.1 VRAMC2.J1
MF_D0: R638.1 VRAMD1.J1
MF_D1: R665.1 VRAMD2.J1
MODEL_ID_DET: C1016.2 KBC1.95 R172.2 R178.1
MPCIE_DISABLE_N: KBC1.40 R2479.1
MUXSSD_OE#: R443.1 U26.2
MUXSSD_RX_N0: R2735.2 SSDC1.43
MUXSSD_RX_N0_R: R2735.1 U26.4
MUXSSD_RX_P0: R2734.2 SSDC1.41
MUXSSD_RX_P0_R: R2734.1 U26.3
MUXSSD_SEL: R2599.2 U26.9 U43.D
MUXSSD_SEL_EN: CPU1.AL23 R2600.2 RN2405.3(B)
MUXSSD_SEL_EN_C: R2600.1 U43.G
MUXSSD_TX_N1: SSDC1.47 U26.8
MUXSSD_TX_P1: SSDC1.49 U26.7
MVREF_A: C735.1 GPU1.P25 R611.2 R614.1
MVREF_B: C736.1 GPU1.P20 R613.2 R615.1
MVREF_C: C738.1 GPU1.Y14 R619.2 R623.1
MVREF_D: C739.1 GPU1.AE14 R620.2 R624.1
NC7SB3157_A: R21.1 R1229.2 R1230.2 R1231.1 R1232.1 U38.4
NC7SB3157_B0: R1228.2 U38.3
NC7SB3157_B1: R1227.2 U38.1
NC7SB3157_S: R1233.1 U38.6
NCT_CLK: Q15.1 RN15.3(B) U2.8
NCT_DATA: Q15.4 RN15.4(B) U2.7
NGFF_BT_DISABLE: KBC1.80 R412.1 R2478.1
NGFF_CLKREQ1_N: TP94.1 WLAN1.68
NGFF_PEWAKE0_N: R1220.1 WLAN1.55
NGFF_PEWAKE1_N: R1219.2 WLAN1.70
NGFF_W_DISABLE1_N: R2479.2 WLAN1.56
NGFF_W_DISABLE2_N: R2478.2 WLAN1.54
NPMALERT: PR223.2 PR247.2 TP121.1
NSVALERT: GPU1.AN23 PR229.2 PR243.2
NVRHOT: GPU1.AJ34 PR240.2 R2635.2
OC_ADJ1: R323.2 U8.5
OSD_CONTROL_SEL: CPU1.AU13 LAUOC1.11 RN2402.3(B)
OSD_MENU: C988.1 LAUOC1.4 R1225.1 R1226.1 R2459.2 R2762.1
OSD_MENU_EC: KBC1.56 R2459.1
OSD_MENU_R: OSDC1.7 R1225.2
P0A_ZVSS: CPU1.V8 R4.1
P0B_ZVSS: CPU1.AT8 R5.1
P2800_DXN: C294.2 C295.2 Q13.E R228.2 U2.3
P2800_DXP: C294.1 C295.1 Q13.B Q13.C R228.1 U2.2
P_ZVDDP: CPU1.W8 R1.2
P_ZVSS: CPU1.W7 R3.1
PANEL_ON: CPU1.AL1 LAUOC1.12 R2782.1 R2783.1
PB_IN_SW1: OSDC1.6 R451.2 R452.1
PC_MONITOR_SW_D: R2586.2 U40.D
PC_MONITOR_SW_G: C1117.1 R2587.2 R2588.1 U40.G
PCB_VER_ID: C1004.2 KBC1.98 R171.1 R177.1
PCH_CHAR_CTL3_REAR: KBC1.35 R352.2 R353.2
PCH_CHAR_CTL3_SIDE: KBC1.39 R337.2 R338.2
PCH_SUSCLK_WLAN: PCH1.F25 R2477.1 R2536.2 TP2506.1
PCIE_RST#: RN48.3(B) WLAN1.52 WLAN1.66
PCIE_RST#_APU: C926.1 CPU1.AL7 D11.1 D11.2 GPU1.AV42 PR419.1 R44.1 R2682.1 TP98.1
PCIE_RST#_APU_R: PCH1.V6 R2682.2
PCIE_RX_LAN_N1: PCH1.R22 TYPEC1.7
PCIE_RX_LAN_P1: PCH1.P23 TYPEC1.6
PCIE_RX_PCH_N0: PCH1.R24 WLAN1.43
PCIE_RX_PCH_P0: PCH1.R23 WLAN1.41
PCIE_RX_SSDX4_N4: PCH1.L22 U26.18
