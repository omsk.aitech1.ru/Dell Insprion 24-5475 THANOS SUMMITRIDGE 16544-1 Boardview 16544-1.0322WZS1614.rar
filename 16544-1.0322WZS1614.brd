# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_HDMI_OUT2P_C: length 154.6
  TOP w0.102: v1(14.81,160.84) 14.77,160.88 C915.1 ; 77.3,157.38 77.3,156.8 73.08,152.57 73.08,149.19 72.63,148.74 71.93,148.74 v1(71.53,148.34) ; 77.3,157.38 v3(77.7,157.38) ; 77.3,157.38 77.3,163.9 77.4,164 GPU1.AY30
  L6 w0.102: v1(71.53,148.34) 71.89,148.72 72.97,148.72 73.49,148.2 73.49,141.44 70,137.95 70,122.15 70.73,121.42 71.37,120.78 71.37,113.79 70.13,112.55 35.23,112.55 32.05,115.72 32.05,125.25 30.28,127.03 28.96,127.03 27.41,128.58 27.41,134.8 24.54,137.67 24.54,145.72 22.54,147.72 22.54,147.88 22.32,148.09 22.16,148.09 20.66,149.59 20.66,149.75 20.45,149.96 20.29,149.96 20.08,150.18 20.08,150.34 19.86,150.55 19.7,150.55 19.4,150.86 19.4,150.86 19.02,151.23 19.02,158.5 17.09,160.43 15.22,160.43 v1(14.81,160.84)
GPU_HDMI_OUT_CKN: length 10.9
  TOP w0.102: DISPC2.28 7.75,159.75 7.89,159.9 9.44,159.9 10,159.33 ; 10,159.33 v3(9.73,159.05) ; 10,159.33 11.09,158.24 16.33,158.24 C918.2
GPU_HDMI_OUT_CKN_C: length 152.5
  TOP w0.102: 75.21,156.75 72.19,153.73 72.19,150.98 71.98,150.77 71.45,150.77 v1(71.04,151.18) ; 75.21,156.75 75.85,157.39 75.85,161.28 76.07,161.5 76.15,161.5 76.25,161.6 76.25,161.85 GPU1.BB29 ; 75.21,156.75 v3(74.93,157.02) ; C918.1 17.85,158.31 18.67,158.31 18.9,158.09 18.9,157.05 18.24,156.39 v1(17.5,156.39)
  L6 w0.102: v1(71.04,151.18) 71.42,150.8 73.74,150.8 74.47,150.06 74.47,140.82 71.12,137.46 71.12,122.4 72.34,121.18 72.34,113.41 70.54,111.61 34.72,111.61 31.05,115.28 31.05,121.7 28.17,124.59 28.17,124.59 24.71,128.04 24.71,136.07 23.41,137.38 23.41,144.87 16.85,151.42 16.85,155.31 17.39,155.85 17.4,155.85 17.41,155.9 v1(17.5,156.39)
GPU_HDMI_OUT_CKP: length 11
  TOP w0.102: 11.76,158.44 16.17,158.44 C917.2 ; 11.76,158.44 11.18,158.44 9.52,160.1 7.89,160.1 7.75,160.25 DISPC2.29 ; 11.76,158.44 v3(11.76,158.83)
GPU_HDMI_OUT_CKP_C: length 152.3
  TOP w0.102: v1(18.01,155.63) 18.01,155.88 19.1,156.96 19.1,157.58 ; v3(19.48,157.58) 19.1,157.58 ; 19.1,157.58 19.1,158.17 18.76,158.52 17.85,158.52 C917.1 ; v1(71.04,150.27) 71.35,150.57 72.07,150.57 72.39,150.89 72.39,153.64 76.05,157.3 76.05,161.2 76.15,161.3 GPU1.BC29
  L6 w0.102: v1(71.04,150.27) 71.36,150.58 73.65,150.58 74.26,149.97 74.26,140.91 70.9,137.55 70.9,122.31 72.12,121.09 72.12,113.5 70.45,111.82 34.81,111.82 31.27,115.37 31.27,121.79 24.93,128.13 24.93,136.16 23.62,137.47 23.62,137.77 23.73,137.88 23.73,138.19 23.62,138.3 23.62,138.6 23.73,138.72 23.73,139.02 23.62,139.13 23.62,139.44 23.73,139.55 23.73,139.85 23.62,139.96 23.62,140.76 23.73,140.87 23.73,141.17 23.62,141.28 23.62,142.46 23.73,142.57 23.73,142.88 23.62,142.99 23.62,143.29 23.73,143.4 23.73,143.71 23.62,143.82 23.62,144.12 23.73,144.24 23.73,144.54 23.62,144.65 23.62,144.96 22.47,146.11 22.47,146.26 22.26,146.48 22.1,146.48 21.89,146.69 21.89,146.85 21.67,147.07 21.51,147.07 21.3,147.28 21.3,147.44 21.08,147.66 20.92,147.66 19.88,148.7 19.88,148.86 19.66,149.08 19.5,149.08 19.29,149.29 19.29,149.45 19.07,149.66 18.91,149.66 18.7,149.88 18.7,150.04 18.48,150.25 18.33,150.25 17.07,151.51 17.07,155.22 17.48,155.63 v1(18.01,155.63)
GPU_HDMI_OUT_SCL: length 227.5
  TOP w0.102: 11.64,156.97 11.35,157.26 11.16,157.26 v1(10.74,157.68) 10.37,157.3 10.16,157.3 8.86,158.6 7.89,158.6 7.75,158.75 DISPC2.26 ; 11.64,156.97 v3(11.94,157.28) ; 11.64,156.97 12.1,156.51 12.58,156.51 R2643.2 ; GPU1.AU35 81.46,166.6 81.89,166.17 v6(82.02,166.17)
  L6 w0.102: v1(10.74,157.68) 10.23,157.16 10.23,156.43 9.5,155.7 9.5,139.98 12.05,137.43 12.05,135.44 14.06,133.44 14.06,115.88 21.16,108.79 24.1,108.79 25.37,107.52 106.65,107.52 108.51,109.37 108.51,122.89 107.09,124.31 107.09,132.56 108.04,133.52 108.04,135.24 106.22,137.06 106.22,137.12 106.17,137.17 106.17,141.5 106.44,141.77 106.44,142.84 103.38,145.9 103.38,147.8 99.67,151.51 99.67,156.91 99.35,157.23 99.16,157.23 v1(98.81,157.58)
  BOTTOM w0.102: v6(82.02,166.17) 82.45,165.74 82.45,164.3 83.17,163.58 92.2,163.58 93.4,162.38 93.4,160.47 96.65,157.23 98.45,157.23 v1(98.81,157.58)
GPU_HDMI_OUT_SDA: length 227.4
  TOP w0.102: 9.79,157.39 v3(9.5,157.1) ; 9.79,157.39 10.08,157.1 10.28,157.1 v1(10.74,156.64) 11.16,157.06 11.27,157.06 12.01,156.31 12.58,156.31 R2642.2 ; 9.79,157.39 8.78,158.4 7.89,158.4 7.75,158.25 DISPC2.25 ; v6(81.92,165.35) 81.85,165.35 GPU1.AV35
  L6 w0.102: v1(10.74,156.64) 9.72,155.61 9.72,140.07 9.93,139.85 10.09,139.85 10.31,139.63 10.31,139.48 10.52,139.26 10.68,139.26 10.9,139.05 10.9,138.89 11.11,138.67 11.27,138.67 11.49,138.46 11.49,138.3 12.27,137.52 12.27,135.53 14.28,133.53 14.28,133.3 14.39,133.19 14.39,132.88 14.28,132.77 14.28,132.47 14.39,132.35 14.39,132.05 14.28,131.94 14.28,131.63 14.39,131.52 14.39,131.22 14.28,131.1 14.28,129.45 14.39,129.34 14.39,129.03 14.28,128.92 14.28,128.61 14.39,128.5 14.39,128.2 14.28,128.09 14.28,127.78 14.39,127.67 14.39,127.36 14.28,127.25 14.28,126.13 14.39,126.02 14.39,125.72 14.28,125.61 14.28,125.3 14.39,125.19 14.39,124.88 14.28,124.77 14.28,124.47 14.39,124.36 14.39,124.05 14.28,123.94 14.28,122.46 14.39,122.35 14.39,122.04 14.28,121.93 14.28,121.63 14.39,121.51 14.39,121.21 14.28,121.1 14.28,120.79 14.39,120.68 14.39,120.38 14.28,120.26 14.28,118.8 14.39,118.68 14.39,118.38 14.28,118.27 14.28,117.96 14.39,117.85 14.39,117.55 14.28,117.43 14.28,117.13 14.39,117.02 14.39,116.71 14.28,116.6 14.28,115.97 14.41,115.84 14.57,115.84 14.79,115.62 14.79,115.46 15,115.25 15.16,115.25 15.38,115.03 15.38,114.87 15.59,114.66 15.75,114.66 15.97,114.44 15.97,114.29 16.94,113.31 17.1,113.31 17.32,113.09 17.32,112.93 17.53,112.72 17.69,112.72 17.91,112.5 17.91,112.35 18.12,112.13 18.28,112.13 18.49,111.91 18.49,111.76 19.48,110.77 19.64,110.77 19.85,110.56 19.85,110.4 20.07,110.18 20.23,110.18 20.44,109.97 20.44,109.81 20.66,109.59 20.82,109.59 21.03,109.38 21.03,109.22 21.25,109 22.53,109 22.64,109.12 22.94,109.12 23.06,109 23.36,109 23.47,109.12 23.78,109.12 23.89,109 24.19,109 25.46,107.73 106.56,107.73 108.29,109.46 108.29,122.8 106.87,124.22 106.87,132.65 107.82,133.6 107.82,135.15 105.96,137.02 105.96,141.59 106.22,141.86 106.22,142.75 103.16,145.81 103.16,147.71 99.45,151.42 99.45,156.82 99.26,157.02 99.16,157.02 v1(98.81,156.67)
  BOTTOM w0.102: v1(98.81,156.67) 98.45,157.02 96.56,157.02 93.2,160.39 93.2,162.29 92.12,163.37 83.08,163.37 82.25,164.21 82.25,165.02 v6(81.92,165.35)
GPU_HPD_HDMI: length 220.7
  TOP w0.114: DISPC2.24 7.84,157.75 7.85,157.76 8.64,157.76 8.86,157.53 8.86,156.64 10.1,155.4 v1(10.4,155.4) ; GPU1.AU30 77.93,166.6 78.33,167 v6(78.49,167)
  L6 w0.102: v1(10.4,155.4) 10.4,154.6 10.26,154.46 10.26,140.99 12.83,138.43 12.83,137.79 13.34,137.29 14.6,137.29 15.04,136.85 15.04,116.28 16.1,115.21 20.91,115.21 27.87,108.25 106.07,108.25 107.77,109.96 107.77,122.53 106.35,123.95 106.35,132.85 107.31,133.82 107.31,134.94 105.45,136.81 105.45,142.13 99.42,148.16 99.39,148.16 92.2,155.35 92.2,161.93 v1(91.69,162.43)
  BOTTOM w0.114: v6(78.49,167) 78.8,166.69 R1210.1 78.8,165.52 79.48,164.85 80.39,164.85 83.04,162.2 84.06,162.2 v2(84.07,162.2) 84.07,162.2 87.03,162.2 87.57,162.74 91.39,162.74 v1(91.69,162.43)
GPU_I2C_SCL: length 69.4
  TOP w0.114: GPU1.AF34 81,175.65 v6(81.45,175.2)
  L6 w0.102: v1(99.56,209.96) 100.84,209.96 104.5,206.31 104.5,205.84 106.07,204.27 106.88,204.27 107.44,203.71 107.44,202.9 110.36,199.98 110.36,187.81 110.53,187.64 111.25,186.92 111.25,185.82 100.29,174.85 99.01,174.85 98.02,173.86 89.66,173.86 87.86,175.66 81.91,175.66 v6(81.45,175.2)
  BOTTOM w0.114: R478.2 97.78,209.33 v5(98.32,209.88) 98.41,209.96 v1(99.56,209.96)
GPU_I2C_SDA: length 70.5
  TOP w0.114: GPU1.AF33 80.2,175.65 v6(80.65,175.2)
  L6 w0.102: v6(80.65,175.2) 81.31,175.86 88.68,175.86 89.28,175.26 100.12,175.26 110.85,185.99 110.85,186.65 110.08,187.41 110.08,193.25 109.96,193.38 109.96,199.81 107.04,202.73 107.04,203.2 106.37,203.86 105.9,203.86 104.09,205.68 104.09,206.14 100.96,209.27 99.31,209.27 98.96,209.62 v1(98.96,210.69)
  BOTTOM w0.114: v1(98.96,210.69) 97.66,210.69 96.9,209.93 v5(96.88,209.93) 96.88,209.91 96.71,209.74 R479.2
GPU_P_ZVSS: length 3
  TOP w0.114: v6(78.25,171.6) 77.8,172.05 GPU1.AK30
  BOTTOM w0.114: R475.1 76.45,170.84 77.02,171.41 77.35,171.41 77.54,171.6 v6(78.25,171.6)
GPU_PPC_EC: length 7.5
  TOP w0.114: v1(118.26,46.05) 118.21,46 118.21,45.11 117.44,44.34 115.89,44.34 115.65,44.58 KBC1.62
  BOTTOM w0.114: R2721.2 118.34,47.42 118.26,47.35 v5(118.26,47.22) v1(118.26,46.05)
GPU_PPC_R: length 394.2
  TOP w0.114: v1(102.18,221.84) 103.12,222.78 R485.2 103.67,222.99 R480.2 ; R2709.1 13.97,142.39 R2710.1 12.62,142.39 12.06,141.83 v1(12.06,141.37) ; v1(96.04,58.72) 96.01,58.75 94.35,58.75 93.9,59.21 93.37,59.21 v1(93.27,59.31)
  L3 w0.114: v1(96.04,58.72) 96.14,58.72 96.58,59.16 100.14,59.16 101.64,60.66 101.64,61.16 101.68,61.2 101.68,61.95 102.06,62.34 102.49,62.34 102.77,62.05 110.36,62.05 112.57,59.84 114.12,59.84 115.21,58.76 121.08,58.76 124.19,55.65 124.19,54.33 122.11,52.25 v1(120.86,52.25) ; v1(93.27,59.31) 91.29,57.33 89.89,57.33 87.78,59.44 87.78,80.93 89.82,82.97 89.82,95 91.11,96.29 91.11,99.19 98.09,106.17 101.96,106.17 106.79,111 106.79,122.19 106.05,122.94 106.05,133.93 106.43,134.32 v1(106.43,134.39)
  L4 w0.114: v1(110.21,203.81) 110.49,203.53 110.49,202.09 110.16,201.76 110.16,200.99 111.63,199.52 111.63,192.79 112.32,192.1 112.32,189.21 109.64,186.53 109.64,185.93 113.39,182.19 113.39,169.76 111.05,167.42 109.98,167.42 109.94,167.38 109.3,167.38 108.44,166.52 108.43,166.52 108.33,166.42 108.33,163.34 109,162.67 109,162 108.46,161.45 108.46,159.03 108.83,158.65 108.83,152.84 110.61,151.06 110.61,142.87 108.32,140.58 108.32,139.03 108.52,138.84 108.52,136.49 v1(106.43,134.39)
  L6 w0.102: v1(110.21,203.81) 110.22,203.82 110.22,205.5 109.12,206.61 109.12,207.09 107.37,208.84 106.88,208.84 106.88,208.84 106.38,208.84 105.54,209.68 105.54,219.94 103.63,221.84 v1(102.18,221.84) ; v1(12.06,141.37) 12.27,141.37 12.34,141.3 13.2,141.3 16.23,138.27 16.23,137.06 18.41,134.87 19.81,134.87 20.7,133.99 20.7,130.85 21.66,129.89 21.66,125.05 21.84,124.87 21.84,116.76 28.73,109.88 97.94,109.88 98.4,110.34 102.64,110.34 106.78,114.48 106.78,121.97 105.54,123.22 105.54,133.5 v1(106.43,134.39)
  BOTTOM w0.114: R2713.1 16.01,138.52 v2(15.57,138.96) 14.34,140.2 13.83,140.2 PQ12.G 13.43,140.95 13.13,141.25 12.39,141.25 12.27,141.37 v1(12.06,141.37) 12,141.44 PR420.2 ; v1(120.86,52.25) 120.57,51.96 120.57,51.49 120.46,51.38 120.46,50.77 119.95,50.27 119.23,50.27 118.61,49.64 R2721.1
GPU_SMB_CLK_MAIN: length 50.1
  TOP w0.114: Q76.4 121.4,169.81 120.86,169.27 120.86,168.99 120.45,168.57 v1(120.45,168.22) 119.74,168.22 119.35,167.84 R2637.2 ; v6(80.65,170.4) 81,170.75 GPU1.AM34
  BOTTOM w0.114: v1(120.45,168.22) 120.09,168.58 v2(117.74,168.58) 115.31,168.58 112.08,165.35 110.37,165.35 109.99,165.73 105.13,165.73 104.59,165.2 100.1,165.2 99.62,164.72 95.86,164.72 95.5,165.07 93.38,165.07 92.76,165.69 88.87,165.69 88.3,166.26 85.77,166.26 84.82,167.21 84.48,167.21 84.24,166.97 83.11,166.97 82.57,167.51 81.24,168.84 81.24,169.46 80.65,170.05 v6(80.65,170.4)
GPU_SMB_CLK_MAIN_G: length 4
  TOP w0.114: Q76.5 121.52,169.16 121.06,168.7 121.06,168 120.47,167.41 R2636.2 121.27,167.14 v3(121.54,166.88)
GPU_SMB_DATA_MAIN: length 53.4
  TOP w0.114: v6(79.85,170.4) 80.2,170.75 GPU1.AM33 ; v1(124.97,166.29) 124.84,166.17 123.84,166.17 R2639.2 123.83,167.89 123.74,167.98 Q76.1
  BOTTOM w0.114: v1(124.97,166.29) v2(123.28,166.29) 123.25,166.32 114.02,166.32 112.28,164.58 110.45,164.58 110.13,164.58 109.73,164.98 109.04,164.98 108.62,164.56 99.94,164.56 99.76,164.38 95.72,164.38 95.37,164.72 93.21,164.72 92.55,165.38 88.88,165.38 88.21,166.04 85.47,166.04 85.12,166.39 84.48,166.39 84.24,166.62 83.15,166.62 83.02,166.76 82.42,167.36 81.03,168.75 81.03,169.36 79.98,170.4 v6(79.85,170.4)
GPU_SMB_DATA_MAIN_G: length 3.7
  TOP w0.114: Q76.2 123.71,169.14 123.24,169.14 122.95,168.85 122.95,168.67 122.94,168.65 v3(122.94,167.13) 122.68,166.88 R2638.2
GPU_TEST_PG: length 81
  TOP w0.114: GPU1.AA31 79.2,181.2 80.51,181.2 80.59,181.28 v6(80.62,181.28) ; v1(101.04,217.32) 100.79,217.58 R487.2 100.82,218.71 100.82,221.79 101.16,222.12 Q42.C 101.16,223.27 101.52,223.64 R484.1
  L6 w0.102: v6(80.62,181.28) 81.35,180.55 85.6,180.55 86.07,180.09 99.29,180.09 103.48,184.28 105.87,184.28 108.61,187.02 108.61,190.55 109.37,191.31 109.37,192.83 109.07,193.13 109.07,196.52 108.13,197.46 108.13,198.86 107.69,199.3 107.69,199.95 106.55,201.08 105.91,201.08 102.37,204.62 100.5,204.62 100.29,204.42 99.71,204.42 98.83,205.29 98.83,208.17 97.79,209.21 97.79,213.16 101.04,216.41 v1(101.04,217.32)
  BOTTOM w0.114: v1(101.04,217.32) 100.71,217.65 v5(100.71,218.57)
GPU_TEST_PG_B: length 7.3
  TOP w0.114: Q41.C 99.73,217.58 v3(99.73,218.8) 99.73,219.25 100.17,219.69 Q42.B 100.17,222.25 100.49,222.57 R483.1
GPU_TEST_PG_BACO: length 76.6
  TOP w0.114: v1(102.95,217.14) 103.48,217.68 103.85,217.68 R490.1 103.87,216.28 Q43.C ; GPU1.Y32 79.4,181.95 v6(79.85,182.4)
  L6 w0.102: v6(79.85,182.4) 80.38,182.93 81.81,182.93 82.88,184.01 99.17,184.01 102.41,187.25 102.41,189.29 103.52,190.39 104.66,190.39 104.91,190.64 104.91,191.18 104.09,191.99 104.09,192.57 104.19,192.67 104.19,196.67 104.11,196.75 104.11,200.18 102.06,202.23 97.75,202.23 97.52,202.46 96.16,202.46 95.65,202.97 94.61,202.97 94.31,203.28 94.31,204.62 96.09,206.4 96.09,206.44 97.33,207.68 97.33,214.76 100.41,217.83 102.26,217.83 v1(102.95,217.14)
  BOTTOM w0.114: v1(102.95,217.14) 103.2,217.4 103.66,217.4 v5(103.78,217.27) 103.86,217.2 103.86,216.81 103.59,216.55 R489.1
GPU_TEST_PG_BACO_B: length 11.2
  TOP w0.114: R491.1 104.74,221.14 102.59,219 v3(102.59,217.93) 102.59,217.73 102.46,217.6 102.46,216.1 102.57,216 v1(102.57,215.39) 102.57,214.27 Q43.B
  BOTTOM w0.114: v1(102.57,215.39) 102.39,215.21 101.03,215.21 Q44.C
GPU_VBIOS_PWR: length 3.8
  TOP w0.254: R2732.2 R559.2 113.65,162.53 v3(114.38,162.53) 114.64,162.27 U28.3
GPU_VCC3_CTL: length 6.8
  TOP w0.114: v3(130.76,165.94) 130.76,164.99 R584.2 129.16,164.91 C947.1 129.1,166.05 127.32,167.83 Q53.G
GPU_VCC3_CTL_2: length 3.9
  TOP w0.114: v3(128.27,158.37) 128.27,158.95 Q54.G 129.02,159.7 C948.1 R1195.2
GPU_WAKEB: length 6.7
  TOP w0.114: GPU1.AV43 89.93,166.2 91.97,164.17 v3(92.48,164.17) 93.53,165.21 R495.2
GVDD_AB1: length 4.8
  TOP w0.114: U8.3 200.23,23.8 200.34,23.69 200.82,23.69 v3(201.19,23.32) 201.64,23.32 R325.2 203.14,23.99 C409.2
H_PROCHOT_N: length 520.8
  TOP w0.114: R17.1 211.16,156.53 Q1.D ; R17.1 v1(210.63,157.92) ; R17.1 208.33,154.75 208.33,151.66 207.04,150.37 205.56,150.37 R2506.2 ; v1(96.5,97.43) 92.94,97.43 89.92,100.46 v1(88.27,100.46) ; v1(96.67,49.6) 96.67,49.96 97.28,50.57 Q67.D ; PR86.1 223.22,220.19 v1(223.24,220.22) ; v1(16,142.44) 15.91,142.54 15.91,142.55 15.58,142.87 PQ2.D
  L3 w0.114: v1(96.67,49.6) 96.67,49.23 95.83,48.39 92.69,48.39 85.74,55.34 85.74,81.69 87.84,83.79 87.84,94.18 87.84,95.82 88.27,96.25 v1(88.27,100.46) 88.27,101.53 87.33,102.46 87.33,104.78 80.18,111.93 27.09,111.93 24.3,114.72 23.84,115.18 13.3,115.18 8.98,119.5 8.98,127.85 13.77,132.64 13.77,133.66 15.67,135.56 15.67,139.68 15.23,140.12 15.23,141.67 v1(16,142.44) ; v1(205.51,83.57) 205.92,83.16 206.02,83.16 209.08,80.1 210.2,80.1 211.21,79.09 215.61,79.09 217.67,81.14 220.43,81.14 v1(220.95,81.66) ; v1(210.63,157.92) 210.9,157.66 214.48,157.66 217.55,154.58 217.55,148.21 217.4,148.06 217.4,145.26 216.56,144.42 216.56,138.57 v1(217.47,137.66)
  L4 w0.114: v1(217.47,137.66) 217.56,137.58 217.56,136.81 217.91,136.46 217.91,135.23 214.86,132.18 214.86,129.82 215.29,129.39 215.29,120.87 215.29,120.87 215.29,120.27 219.38,116.18 220.17,115.39 220.17,105.16 219.38,104.37 219.38,96.39 222.5,93.27 222.5,88.04 223.22,87.33 223.22,83.92 v1(220.95,81.66)
  BOTTOM w0.114: v1(223.24,220.22) 224.89,218.57 225.02,218.57 225.56,218.57 227.13,217 227.13,214.12 222.33,209.32 220.62,209.32 218.24,206.93 217.12,206.93 215.24,205.05 213.61,205.05 211.51,202.95 211.51,202.29 209.81,200.59 209.81,198.35 209.81,197.81 208.44,196.44 207.47,196.44 203.33,192.3 202.03,192.3 200.61,190.88 200.61,186.92 202.69,184.84 202.69,170.76 204.09,169.37 204.09,166.07 210.63,159.52 v1(210.63,157.92) ; v1(16,142.44) 15.34,141.78 PQ12.D ; v1(96.67,49.6) 97.09,49.6 97.64,50.15 97.64,50.46 C1011.1 97.64,50.48 97.64,51.31 v2(98.07,51.74) 98.35,51.74 98.98,51.1 R204.2 ; v1(205.51,83.57) 205.28,83.34 170.99,83.34 169.98,84.35 162.48,84.35 161.47,85.37 155.63,85.37 152.48,88.52 150.75,88.52 146.94,92.33 145.16,92.33 144.27,93.22 135.35,93.22 135.12,93.45 131.29,93.45 128.21,96.53 128.21,98.9 123.18,103.92 110.81,103.92 109.17,102.28 109.17,98.83 107.77,97.43 v1(96.5,97.43)
H_PROCHOT_N_EC: length 19.1
  TOP w0.114: KBC1.24 100.71,50.14 v1(100.63,50.22) 100.59,50.22 99.91,50.89 98.62,50.89 97.97,51.54 97.5,51.54 96.45,52.59 Q67.S 96.15,52.59 95.71,52.15 94.87,52.15 v1(94.34,52.68)
  BOTTOM w0.114: v1(94.34,52.68) 94.54,52.88 94.54,54.02 95.21,54.69 97.58,54.69 97.75,54.52 RN44.1 ; R2438.1 102.14,50.33 101.68,49.86 v2(101.65,49.86) 100.99,49.86 v1(100.63,50.22) 100.29,50.56 R204.1
HDA_BITCLK_CODEC: length 227.6
  TOP w0.114: v1(130.58,172.62) 130.68,172.52 R65.1 ; v1(211.96,36.07) 211.66,35.77 R278.2
  L4 w0.114: v1(199.52,69.72) 198.88,70.36 195.58,70.36 195.45,70.22 179.41,70.22 170.43,79.2 148.7,79.2 143.26,84.63 141.51,84.63 138.24,87.9 137.12,87.9 134.67,90.36 133.62,90.36 124.42,99.56 124.42,113.08 123.71,113.8 123.71,117.46 122.99,118.19 122.99,135.64 125.03,137.67 125.03,143.43 124.24,144.22 124.24,164.24 126.8,166.8 126.8,170.12 129.29,172.62 v1(130.58,172.62)
  L6 w0.102: v1(211.96,36.07) 209.8,38.23 207.67,38.23 207.42,38.48 206.69,38.48 206.69,38.48 206.38,38.48 205.84,39.01 199.42,39.01 198.63,38.23 195.65,38.23 194.44,39.44 194.44,40.1 192.96,41.58 191.47,41.58 189.59,43.46 189.59,55.6 194.79,60.81 196,60.81 197.13,61.93 197.13,66.44 199.52,68.83 v1(199.52,69.72)
  BOTTOM w0.114: v2(129.59,172.92) 129.9,172.62 v1(130.58,172.62)
HDA_BITCLK_CPU: length 25.7
  TOP w0.114: R65.2 131.57,170.6 C2532.1 R2693.2 133,171.33 134.93,171.33 135.74,172.14 137.21,172.14 137.7,172.63 140.59,172.63 140.84,172.88 v3(140.84,172.88) 142.42,172.88 143.55,174 143.55,174.56 145.75,176.76 145.75,178.46 146.33,179.04 147.52,179.04 148.48,180 CPU1.AW3
HDA_RST#_CODEC: length 2.4
  TOP w0.114: R2690.2 211.33,36.96 v3(211.46,37.08) 212.03,37.08 212.22,36.89 R2691.1
HDA_RST#_CPU: length 255.7
  TOP w0.114: CPU1.AU1 152.53,182.47 v1(152.5,182.47) ; R2691.2 212.66,37.85 R2692.2 212.66,39.69 v1(212.6,39.75)
  L4 w0.114: v1(152.5,182.47) 150.89,182.47 148.92,180.5 148.92,180.21 147.62,178.92 147.4,178.92 146.86,178.38 144.32,178.38 141.33,175.39 141.33,174.82 140.44,173.94 134.92,173.94 134.9,173.91 133.6,173.91 132.68,174.83 131.84,174.83 130.85,173.85 129.9,173.85 126.47,170.41 125.18,170.41 124.36,169.6 124.36,166.33 123.8,165.77 123.8,162.13 123.72,162.05 123.72,137.21 122.53,136.02 122.53,117.88 123.22,117.2 123.22,113.7 124,112.91 124,99.38 133.44,89.94 134.49,89.94 136.95,87.48 137.27,87.48 140.63,84.12 143.18,84.12 148.54,78.77 160.35,78.77 161.09,78.03 170.99,78.03 179.22,69.8 193.68,69.8 194.61,68.86 196.75,68.86 197.41,69.52 198.6,69.52 198.88,69.23 200.04,69.23 200.4,69.59 v1(200.42,69.59)
  L6 w0.102: v1(200.42,69.59) 200.41,69.58 200.41,69.14 197.53,66.26 197.53,61.76 196.17,60.4 195.02,60.4 189.99,55.37 189.99,43.69 191.69,41.99 193.13,41.99 195.39,39.73 199.26,39.73 199.49,39.5 205.93,39.5 206.54,38.89 207.59,38.89 207.85,38.63 211.48,38.63 v1(212.6,39.75)
  BOTTOM w0.114: v2(213.17,40.53) 212.6,39.95 v1(212.6,39.75)
HDA_SDIN0_CPU: length 243.9
  TOP w0.114: R275.2 211.1,39.47 v1(211.61,39.47) ; v1(149.48,180.44) 149.5,180.42 151.18,180.42 151.31,180.29 151.67,180.29 151.96,180 CPU1.AV3
  L4 w0.114: v1(149.48,180.44) 149.43,180.39 149.43,179.83 148.12,178.52 147.61,178.52 147.02,177.93 146.41,177.93 145.57,177.09 145.57,176.4 141.82,172.66 136.36,172.66 128.65,164.95 128.65,159.13 128.03,158.51 128.03,147.6 127.6,147.17 127.6,136.1 125.68,134.18 125.68,101.16 134.72,92.11 134.72,92.1 136.83,89.99 136.83,89.98 137.64,89.16 138.81,89.16 142.08,85.89 144.01,85.89 149.4,80.51 173.36,80.51 178.07,75.79 179.3,75.79 183.61,71.48 194.67,71.48 195.45,72.26 v1(200.28,72.26)
  L6 w0.102: v1(211.61,39.47) 211.2,39.07 208.15,39.07 207.92,39.29 206.71,39.29 205.93,40.07 203.64,40.07 202.69,41.02 199.39,41.02 198.5,40.13 195.56,40.13 193.27,42.42 191.9,42.42 190.73,43.59 190.73,55.29 195.44,59.99 196.34,59.99 197.94,61.59 197.94,65.86 201.27,69.19 201.27,70.26 200.28,71.25 v1(200.28,72.26)
  BOTTOM w0.114: v1(211.61,39.47) 211.64,39.5 v2(211.64,40.44)
HDA_SDIN1: length 39.9
  TOP w0.114: CPU1.AU5 v1(153.52,178.52)
  BOTTOM w0.114: R55.1 144.45,175.56 144.78,175.23 146.91,175.23 147.12,175.44 147.12,175.64 146.99,175.77 146.2,175.77 146.07,175.9 146.07,176.15 146.2,176.28 146.99,176.28 147.12,176.4 147.12,176.61 146.99,176.73 145.9,176.73 145.47,176.3 145.47,175.9 145.29,175.72 145.11,175.72 144.96,175.87 144.96,176.55 145.62,177.22 148.54,177.22 148.67,177.34 148.67,177.55 148.54,177.67 145.44,177.67 145.33,177.79 145.33,180.57 145.45,180.7 145.66,180.7 145.78,180.57 145.78,178.28 145.91,178.16 146.11,178.16 146.24,178.28 146.24,180.11 146.37,180.24 146.61,180.24 146.74,180.11 146.74,179.77 146.85,179.65 147.26,179.65 147.37,179.54 147.37,179.31 147.26,179.2 146.85,179.2 146.74,179.08 146.74,178.33 146.84,178.23 150.34,178.23 150.45,178.35 150.45,178.7 150.57,178.82 150.8,178.82 150.91,178.7 150.91,178.35 151.02,178.23 151.25,178.23 151.37,178.35 151.37,178.87 151.49,178.99 151.7,178.99 151.82,178.87 151.82,178.35 151.94,178.23 152.17,178.23 152.28,178.35 152.28,178.87 152.41,178.99 152.61,178.99 152.74,178.87 152.74,178.35 152.85,178.23 153.23,178.23 v1(153.52,178.52)
HDA_SDOUT_CODEC: length 227.8
  TOP w0.114: U6.17 205.99,40.36 206.74,39.62 207.04,39.62 207.67,38.99 209.14,38.99 v1(210.01,39.85) ; R64.1 133.22,173.32 v1(133,173.53)
  L4 w0.114: v1(201.68,70.99) 201.36,71.3 195.13,71.3 194.89,71.06 182.4,71.06 178.09,75.37 177.9,75.37 173.21,80.06 149.25,80.06 143.84,85.47 141.91,85.47 138.86,88.52 138.81,88.52 138.59,88.74 137.89,88.74 137.47,88.74 125.35,100.86 125.26,100.95 125.26,117.21 123.83,118.64 123.83,135.15 125.86,137.19 125.86,143.83 125.56,144.14 125.56,162.16 126.09,162.69 126.09,164.77 127.66,166.34 127.66,169.8 129.41,171.55 131.02,171.55 v1(133,173.53)
  L6 w0.102: v1(210.01,39.85) 209.63,39.47 208.56,39.47 207.52,40.51 203.84,40.51 202.82,41.53 195.55,41.53 194.26,42.82 192.07,42.82 191.26,43.63 191.26,55.24 195.61,59.59 196.51,59.59 198.34,61.43 198.34,65.5 201.68,68.83 v1(201.68,70.99)
  BOTTOM w0.114: v5(201.63,71.98) 201.63,71.04 v1(201.68,70.99)
HDA_SDOUT_CPU: length 25.7
  TOP w0.114: CPU1.AU4 152.46,179.54 152.46,180.13 152.07,180.52 151.41,180.52 151.28,180.64 150.96,180.64 150.24,181.36 149.33,181.36 147.37,179.4 146.2,179.4 145.39,178.59 145.39,176.94 142.9,174.45 142.9,174.02 142.36,173.48 139.41,173.48 v3(139.18,173.25) 137.81,173.25 137.06,172.49 135.46,172.49 135.24,172.28 R53.2 R64.2
HDA_SYNC_CODEC: length 226.7
  TOP w0.114: v1(132.38,174.35) 132.89,174.35 133.38,173.86 135.7,173.86 R61.1 ; U6.14 204.28,38.19 204.42,38.05 205.77,38.05 v1(205.79,38.07)
  L4 w0.114: v1(199.52,70.82) 195.35,70.82 195.18,70.64 179.6,70.64 170.61,79.63 148.86,79.63 143.44,85.05 141.68,85.05 138.41,88.32 138.07,88.32 137.3,88.32 134.84,90.78 133.83,90.78 124.84,99.77 124.84,113.26 124.13,113.97 124.13,117.64 123.41,118.36 123.41,135.46 125.44,137.5 125.44,143.64 124.66,144.43 124.66,163.95 127.23,166.52 127.23,169.96 129.24,171.97 130.63,171.97 131.39,172.74 131.39,173.72 132.02,174.35 v1(132.38,174.35)
  L6 w0.102: v1(199.52,70.82) 198.88,70.18 198.88,68.83 196.72,66.67 196.72,62.1 195.83,61.21 194.57,61.21 189.18,55.82 189.18,43.29 191.3,41.17 192.79,41.17 194.03,39.93 194.03,39.27 195.58,37.72 198.88,37.72 199.77,38.61 202.75,38.61 203.29,38.07 v1(205.79,38.07)
  BOTTOM w0.114: v2(204.77,37.67) 205.38,37.67 v1(205.79,38.07)
HDA_SYNC_CPU: length 22.6
  TOP w0.114: R61.2 R54.2 137.02,172.96 138.18,174.12 v3(141.81,174.12) 142.06,174.12 145.03,177.09 145.03,178.79 146,179.76 147.22,179.76 149.26,181.8 150.42,181.8 150.75,182.13 151.87,182.13 CPU1.AU2
HDMI_DET: length 64.2
  TOP w0.114: LAUOC1.3 124.25,7.81 124.11,7.95 121.26,7.95 119.43,6.12 117.68,6.12 117.05,6.75 117.05,7.56 117.07,7.58 117.07,8.41 v3(116.18,9.3) v1(114.91,10.57) ; KBC1.43 108.05,44.55 107.57,44.07 107.06,44.07 106.4,43.41 106.4,42.24 v1(106.86,41.78)
  L6 w0.102: v1(114.91,10.57) 114,9.65 108.98,9.65 100.25,18.38 100.25,20.83 101.04,21.62 101.04,27.07 100.63,27.47 100.63,34.34 103.05,36.75 103.2,36.75 106.32,39.88 106.4,39.88 107.34,40.82 107.34,41.48 107.04,41.78 v1(106.86,41.78)
HDT1_11: length 6.6
  TOP w0.114: HDT1.11 225.12,152.25 226.01,153.14 v3(226.82,153.14) 227.9,152.06 R722.2
HDT1_13: length 5.8
  TOP w0.114: HDT1.13 225.04,153.52 226.11,154.58 v3(226.82,154.58) 227.42,153.99 R723.2
HDT1_15: length 6.7
  TOP w0.114: R724.2 228.43,154.88 v3(227.97,155.35) 227.86,155.45 225.76,155.45 225.09,154.79 HDT1.15
HDT_DBREQ#: length 5.3
  TOP w0.114: R725.1 214.76,154.98 v3(214.76,154.31) 215.59,154.31 216.08,154.79 HDT1.16
HDT_PWR_EN1: length 4.7
  BOTTOM w0.114: Q81.2 215.96,140.97 R2757.2 216.09,140.14 v5(215.77,139.83) 215.39,139.83 214.9,140.32 Q81.3
HDT_PWR_EN2: length 6.9
  BOTTOM w0.114: Q80.G 213.49,144.84 R2756.2 R2755.2 213.3,143.38 212.72,143.38 v5(212.42,143.08) Q81.6
HDT_PWR_EN3: length 10.8
  BOTTOM w0.114: R2756.1 214.44,147.21 214.77,147.54 v5(214.77,147.9) 214.77,148.83 213.87,149.73 213.87,152.72 C2512.1 212.63,153.03 Q82.G
HDT_TRST#: length 5.6
  TOP w0.114: R721.2 226.82,151.22 v3(226.82,151.64) 224.92,151.64 224.26,150.98 HDT1.9
HOOD_SW_DET#: length 7
  TOP w0.114: v6(149.86,178.9) 150.28,178.9 150.62,178.56 152.15,178.56 152.53,178.18 152.53,177.95 152.61,177.87 152.61,177.84 152.84,177.61 152.94,177.61 153.55,177 CPU1.AT6
  BOTTOM w0.114: v6(149.86,178.9) R137.2 147.93,178.9 R131.1
HPOL_CON: length 44.8
  TOP w0.508: L12.2 206.31,52.72 C343.1 207.34,53.34 206.83,53.85 v4(206.25,53.85) 206.25,53.91 R2626.2
  TOP w0.61: SUSBC1.17 233.04,32.5 232.88,32.66 231.38,32.66 230.61,33.43 v4(229.92,33.43)
  L6 w1.016: v4(206.25,53.85) 206.25,49.28 206.35,49.18 206.35,49.1 210.72,44.73 216.66,44.73 223.93,37.47 225.55,37.47 229.59,33.43 v4(229.92,33.43)
  BOTTOM w0.508: v2(207.21,54.26) 206.66,54.26 v4(206.25,53.85)
HPOR_CON: length 46.6
  TOP w0.508: L13.2 203.23,53.59 C342.1 203.95,54.5 204.22,54.23 v4(204.34,54.23) 204.28,54.29 R2625.2
  TOP w0.61: v4(230.48,34.72) 230.5,34.72 231.73,33.5 SUSBC1.19
  L6 w1.016: v4(230.48,34.72) 218.95,46.25 212.06,46.25 208.66,49.66 208.66,54.23 207.39,55.5 205.61,55.5 v4(204.34,54.23)
  BOTTOM w0.508: v2(203.33,54.48) 204.09,54.48 v4(204.34,54.23)
HPOUT_L_R: length 2.8
  TOP w0.508: R289.2 204.36,50.31 204.72,50.67 204.72,51.41 v3(204.72,51.41) 204.72,51.41 L12.1
HPOUT_R_R: length 2.9
  TOP w0.508: L13.1 202.83,51.84 202.43,51.44 202.43,51.11 v3(202.48,51.06) 202.48,50.9 203.14,50.24 R290.2
HSYNC: length 18
  TOP w0.114: v1(72.39,168.55) 72.36,168.55 71.92,169 GPU1.AP24
  L6 w0.102: v1(73.49,154.05) 73.49,154.57 73.1,154.97 73.1,167.87 72.42,168.55 v1(72.39,168.55)
  BOTTOM w0.114: v1(73.49,154.05) 73.49,154.1 R2741.2 74.71,154.18 v2(75.18,154.18)
I2C3_CLK_RESUME: length 415.9
  TOP w0.114: v1(19.61,130.78) 19.79,130.78 22.51,133.51 23.35,133.51 24.54,134.7 24.54,137.52 23.64,138.41 U23.31 ; v1(101.88,109.27) 104.99,112.38 114.79,112.38 115,112.17 v3(116.97,112.17) v1(119.25,112.17) ; v1(120.4,170.1) 120.4,170.48 121.59,171.68 123.93,171.68 125.22,172.97 RN5.3 ; CPU1.AK3 v6(160.51,179.53) ; v1(117.88,7.21) 117.88,8.46 119.3,9.88 121.05,9.88 124.38,13.21 128.66,13.21 R2700.1
  L4 w0.114: v6(160.51,179.53) 160.51,179.56 160.91,179.96 160.91,181.64 160.54,182.02 160.31,182.02 160.02,182.3 160.02,183.87 159.46,184.43 159.46,184.45 157.54,186.37 157.53,186.37 156.61,187.29 149.38,187.29 146.04,183.95 129.16,183.95 120.29,175.08 120.29,170.31 120.4,170.21 v1(120.4,170.1) 119.06,168.77 119.06,158.73 119.63,158.16 119.63,147.35 119.34,147.06 119.34,143.31 119.06,143.03 119.06,139.1 117.4,137.44 117.4,132.21 117,131.81 117,117.44 117.41,117.02 117.41,114.01 v1(119.25,112.17)
  L6 w0.102: v1(101.88,109.27) 101.68,109.07 28.21,109.07 21.03,116.25 21.03,124.53 20.85,124.72 20.85,129.55 v1(19.61,130.78) ; v1(117.88,7.21) 115.78,7.21 113.6,5.03 105.69,5.03 102.57,8.16 102.57,9.03 100.82,10.77 96.49,10.77 95.94,10.21 94.08,10.21 93.27,11.02 93.27,19.74 91.97,21.03 91.97,27.58 91.19,28.37 91.19,47.9 91.52,48.23 91.52,59.17 91.67,59.33 91.67,81.7 95.97,86 97.33,86 99.03,87.71 101.96,87.71 104.72,90.47 106.12,90.47 118.31,102.67 118.31,111.2 119.25,112.14 v1(119.25,112.17)
I2C3_DATA_RESUME: length 411.3
  TOP w0.114: v1(120.37,169.19) 120.37,169.39 120.88,169.9 120.88,170.49 121.72,171.32 124.28,171.32 125.28,172.32 RN5.4 ; U23.32 21.64,138.91 21.8,138.75 23.78,138.75 24.88,137.66 24.88,134.55 23.49,133.16 23.2,133.16 22.65,133.16 20.1,130.61 20.1,130.58 19.79,130.28 19.02,130.28 v1(18.67,130.63) ; v1(118.8,7.22) 118.8,8.38 v3(119.14,8.73) 119.76,9.35 122.45,9.35 124.99,11.89 R2701.1 ; CPU1.AK2 160,181 v6(160.48,181.49) ; v1(119.33,111.25) 115.43,111.25 114.64,112.04 105.73,112.04 v1(105.59,111.89)
  L4 w0.114: v6(160.48,181.49) 159.73,182.24 159.73,183.55 156.41,186.87 149.56,186.87 146.2,183.51 129.34,183.51 120.73,174.9 120.73,170.48 120.9,170.31 120.9,169.82 120.37,169.29 v1(120.37,169.19) 120.37,169.09 119.79,168.5 119.79,159.87 120.14,159.51 120.14,147.27 119.79,146.91 119.79,139.22 117.83,137.26 117.83,132.05 117.42,131.64 117.42,117.61 117.83,117.2 117.83,114.38 119.76,112.45 119.76,111.68 v1(119.33,111.25)
  L6 w0.102: v1(118.8,7.22) 118.32,7.7 115.69,7.7 113.46,5.46 106.71,5.46 99.7,12.47 94.87,12.47 93.68,13.67 93.68,19.9 92.86,20.72 92.86,20.83 92.43,21.26 92.43,27.76 91.59,28.6 91.59,47.73 91.92,48.06 91.92,59 93.01,60.1 93.01,82.45 95.28,84.71 99.54,84.71 104.9,90.07 106.45,90.07 110.52,94.13 111.53,94.13 114.97,97.57 117.13,97.57 117.68,98.12 117.68,99.42 119.43,101.17 119.43,111.15 v1(119.33,111.25) ; v1(105.59,111.89) 105.42,111.89 102.18,108.66 28.04,108.66 20.62,116.08 20.62,124.36 20.44,124.55 20.44,128.86 v1(18.67,130.63)
I2C_CLK: length 37.2
  TOP w0.114: v3(204.34,29.06) 204.34,28.63 203.91,28.2 v1(203.91,27.86) ; U6.12 203.48,38.08 204.19,37.36 204.52,37.36 205.36,36.53 v1(205.36,36.5)
  L3 w0.114: v1(205.36,36.5) 205.78,36.07 205.78,32.53 205.33,32.08 205.33,30.91 203.91,29.49 v1(203.91,27.86)
  L4 w0.114: v1(203.91,27.86) 203.33,27.28 203.33,26.64 203.68,26.29 205.51,26.29 206.11,26.89 216.16,26.89 217.32,28.05 218.59,28.05 219.75,26.89 220.23,26.89 v1(220.27,26.85)
  BOTTOM w0.114: v1(203.91,27.86) 203.36,27.32 R2518.1 ; v1(220.27,26.85) 220.27,26.85 R2514.1 ; v1(205.36,36.5) 205.44,36.5 206.23,35.71 R283.1
I2C_CLK_CN: length 10.8
  TOP w0.114: LAUOC1.18 131.75,9.87 v3(131.84,9.96) 133.05,11.16 133.05,12.95 131.88,14.12 R2698.2 129.78,13.41 R2700.2
I2C_DATA: length 39
  TOP w0.114: U6.11 203.08,38.05 204.34,36.78 v1(204.39,36.78)
  L3 w0.114: v1(203.84,26.85) 203.42,27.26 203.42,29.59 204.91,31.09 204.91,32.26 205.37,32.71 205.37,35.29 204.39,36.27 v1(204.39,36.78)
  L4 w0.114: v1(220.65,26.01) 220.75,26.11 220.75,26.64 220.76,26.65 220.76,27.05 220.47,27.34 220.08,27.34 218.95,28.47 217.01,28.47 215.98,27.44 207.36,27.44 207.33,27.41 204.39,27.41 v1(203.84,26.85)
  BOTTOM w0.114: R2517.1 203.95,25.49 203.56,25.89 203.56,25.92 v2(203.55,25.92) 203.55,26.57 v1(203.84,26.85) ; v1(204.39,36.78) 204.67,37.06 206.15,37.06 R284.1 ; v1(220.65,26.01) 220.55,25.91 219.56,25.91 219.36,25.71 R2513.1
I2C_DATA_CN: length 13.7
  TOP w0.114: LAUOC1.17 131.25,10.55 v3(132.31,11.61) 132.59,11.89 132.59,12.9 131.9,13.59 130.51,13.59 130.23,13.32 130.23,12.62 129.36,11.75 R2699.2 126.85,11.75 R2701.2
INIT_3V: length 9.1
  TOP w0.114: v3(117.7,85.81) 116.88,84.99 R453.2 117.75,83.92 119.31,82.36 119.31,81.98 119.81,81.48 121.31,81.48 LPC1.2
INT#_TYPEC: length 288.4
  TOP w0.114: v1(130.64,175.37) 130.47,175.37 130.19,175.09 RN2408.4 ; v1(134.62,10.29) 134.21,10.69 v3(133.79,10.69) 133.6,10.69 132.25,9.34 LAUOC1.19 ; v6(155.5,182.58) 155,182.07 CPU1.AR1
  L4 w0.114: v1(165.51,22.28) 164.95,21.72 160.78,21.72 155.32,16.26 154.99,16.26 153.39,14.66 152.25,14.66 149.94,12.34 143.41,12.34 140.83,9.77 138.17,9.77 137.65,10.29 v1(134.62,10.29) ; v1(178.59,68.25) 178.44,68.25 169.93,76.76 167.79,76.76 167.42,76.38 148.91,76.38 142.6,82.7 139.34,82.7 134.85,87.2 133.12,87.2 132.89,87.43 130.63,87.43 123.38,94.68 123.38,96.69 122.53,97.54 121.48,97.54 119.61,99.4 119.61,101.57 121.51,103.48 121.51,116.43 119.2,118.75 119.2,127.23 119.91,127.94 119.91,136.78 121.93,138.79 121.93,168.28 122.66,169.01 122.66,171.86 125.63,174.83 129.93,174.83 130.47,175.37 v1(130.64,175.37) 130.64,175.48 131.32,176.16 131.32,178.31 132.66,179.65 142.75,179.65 142.82,179.58 146.84,179.58 147.04,179.78 147.24,179.78 150.59,183.13 154.96,183.13 v6(155.5,182.58)
  L6 w0.102: v1(178.59,68.25) 178.59,68.25 179.8,68.25 181.86,66.19 181.86,58.17 181.53,57.84 180.29,57.84 178.37,55.92 178.37,45.15 176.53,43.31 176.53,38.53 174.68,36.68 174.68,34.19 174.09,33.6 172.48,33.6 171.44,32.57 171,32.57 170,31.57 170,26.77 v1(165.51,22.28)
INT_SERIRQ: length 210.1
  TOP w0.114: v1(141.25,155.21) 141.48,155.21 145.72,159.46 146.51,159.46 149.05,162 CPU1.AW21 ; KBC1.125 105.25,60.03 105.38,59.89 v1(105.38,59.59)
  L3 w0.114: v1(141.25,155.21) 140.39,154.36 140.29,154.36 138.89,152.95 138.89,146.51 140.46,144.93 140.46,125.36 140.6,125.22 140.6,124.91 140.57,124.88 140.57,124.14 140.6,124.11 140.6,122.85 141.02,122.43 141.02,115.95 141.55,115.42 141.55,98.42 142.21,97.76 142.21,95.68 143.36,94.53 143.36,89.48 143.08,89.2 143.08,87.83 144.81,86.11 152.15,86.11 152.76,85.5 160.5,85.5 161.29,84.71 166.9,84.71 167.2,84.42 167.3,84.42 169.17,82.55 175.77,82.55 177.37,80.95 v1(177.37,73.91)
  L6 w0.102: v1(105.38,59.59) 105.38,59.84 106.78,61.24 108.45,61.24 109.29,62.08 111.25,62.08 114.3,65.13 117.96,65.13 121.31,68.48 123.12,68.48 128.55,73.91 132.18,73.91 161.57,73.91 162.12,74.47 170.85,74.47 171.46,73.86 177.32,73.86 v1(177.37,73.91)
  BOTTOM w0.114: v1(141.25,155.21) 141.5,155.21 142.21,155.93 v2(142.21,156.26) 142.21,156.97 142.04,157.15 R2714.1
IPCC_3D3V_S5: length 82.7
  TOP w0.305: U23.27 23.44,136.41 23.46,136.4 v1(23.62,136.4)
  TOP w0.356: v1(21.16,111.53) 21.64,111.05 U24.3
  TOP w0.508: PC92.1 19.94,112.02 v1(19.94,111.91) ; v1(15.61,111.53) 15.62,111.52 15.62,110.79 18.59,107.82 21.29,107.82 21.97,107.14 IPCC1.1
  L3 w0.508: v1(15.61,111.53) 16.89,112.8 19.07,112.8 19.71,112.16 19.71,112.14 v1(19.94,111.91) ; v1(23.62,136.4) 23.62,136.73 21.87,138.48 21.87,141.8 20.31,143.36 18.91,143.36 18.89,143.34 v1(17.59,143.34)
  L4 w0.508: v1(19.94,111.91) 19.94,114.12 21.21,115.39 21.21,127.36 21.19,127.37 21.19,127.76 19.23,129.72 18.38,129.72 17.96,130.15 17.96,131.02 17.91,131.07 17.91,133.6 16.36,135.15 16.36,141.02 16.71,141.38 16.71,142.46 v1(17.59,143.34)
  BOTTOM w0.508: R2712.1 23.62,134.04 v2(23.8,134.21) 23.85,134.21 24.33,134.7 24.33,135.69 v1(23.62,136.4) 23.52,136.5 PC88.1 22.33,136.87 22.33,137.11 22,137.44 C466.1 ; v1(19.94,111.91) 20.78,111.91 v1(21.16,111.53) ; R2667.2 10.79,141.6 R2668.2 10.92,143.06 PR420.1 12.33,143.4 12.77,143.4 13.37,144 15.64,144 PR50.1 17.02,142.77 v1(17.59,143.34)
IPCC_AC_PROTECT: length 7.3
  TOP w0.114: U23.8 16.79,140.87 17.07,141.15 v1(17.45,141.15) 17.49,141.18 17.49,141.56 17.5,141.58 17.5,142.36 PQ2.G
  BOTTOM w0.114: R2761.1 17.92,140.91 17.68,141.15 v1(17.45,141.15) 17.45,141.34 18.06,141.95 v2(18.06,142.29) 17.4,142.29 16.99,141.88 PR50.2
IPCC_AGND: length 4.9
  TOP w0.305: U23.28 20.5,136.91 20.27,136.91 v6(20.02,137.16) ; U23.26 20.45,135.92 19.28,135.92 19.05,135.69 v6(18.49,135.69)
  TOP w0.508: R403.1 18.33,132.59 v1(18.8,132.59)
  vias: v2(17.37,133.4) v2(19.53,138.76) v2(19.74,135.32) v6(17.53,137.13) v6(18.49,138.66) v6(18.54,137.9) v6(18.49,137.16) v6(18.52,136.4) v6(19.28,137.19)
IPCC_CMP_VREF: length 2.7
  TOP w0.254: R403.2 17.14,132.29 v3(17.14,133.15) 17.14,133.25 16.79,133.6 U23.17
IPCC_CPU0: length 219.9
  TOP w0.114: CPU1.AR4 v6(154.5,179.5) ; v1(18.41,145.03) 18.97,144.48 R2722.1 ; v1(131.88,158.62) 131.83,158.57 129.99,158.57 129.03,157.61 128.72,157.61 128.16,157.61 R2688.2 127.25,156.71 127.25,153.81 127.36,153.7 127.36,150.87 128.37,149.86 128.37,148.86 R2689.1 128.38,146.75 129.17,145.96 129.17,141.36 125.61,137.79 125.5,137.69 124.3,137.69 112.47,125.86 111,125.86 108.18,123.04 v3(108.18,121.56) 108.18,115.19 106.42,113.43 103.58,113.43 102.18,112.04 v1(102.18,110.9)
  L3 w0.114: v1(131.88,158.62) 131.57,158.93 131.57,162.64 134.42,165.48 136.27,165.48 136.97,164.78 138.33,164.78 138.46,164.91 139.11,165.56 139.16,165.61 141.5,165.61 141.81,165.92 141.81,166.01 145.72,169.92 145.72,173.13 147.66,175.07 150.66,175.07 151.56,175.97 154.73,175.97 155.02,176.26 155.02,178.98 v6(154.5,179.5)
  L6 w0.102: v1(18.41,145.03) 18.97,144.48 18.97,138.88 21.11,136.75 21.11,131.01 22.07,130.05 22.07,125.22 22.25,125.04 22.25,117.17 29.13,110.29 97.76,110.29 98.27,110.79 102.08,110.79 v1(102.18,110.9)
IPCC_CPU0_R: length 4.3
  TOP w0.114: U23.7 17.29,140.2 18.97,141.88 v3(18.97,142.24) R2722.2
IPCC_CPU1: length 220.3
  TOP w0.114: R2723.1 19.67,145.03 v1(19.3,145.03) ; R2687.1 140.93,166.11 v1(141.35,166.11) ; v1(102.9,111.3) 102.92,111.33 103.43,111.33 104.83,112.73 111.63,112.73 111.81,112.9 v3(115.34,112.9) 115.39,112.9 116.51,114.02 v1(116.51,114.55) ; CPU1.AN2 156.95,181 v6(156.52,180.57)
  L4 w0.114: v1(141.35,166.11) 141.35,166.11 141.36,166.12 141.91,166.12 142.27,166.47 142.27,172.11 150.11,179.96 151,179.96 152.02,180.97 153.69,180.97 154.07,181.36 155.32,181.36 155.72,180.96 155.72,180.93 156.03,180.62 156.47,180.62 v6(156.52,180.57)
  L6 w0.102: v1(102.9,111.3) 102.74,111.46 98.25,111.46 97.49,110.69 29.37,110.69 22.66,117.41 22.66,125.21 22.47,125.39 22.47,130.22 21.77,130.93 21.77,142.98 19.71,145.03 v1(19.3,145.03) ; v1(116.51,114.55) 116.92,114.96 116.92,117.41 122.35,122.84 122.35,126.67 125.3,129.62 125.3,135.71 127.64,138.05 127.64,153.3 131.99,157.66 132.51,157.66 139.06,164.21 139.34,164.21 141.23,166.11 v1(141.35,166.11)
  BOTTOM w0.114: v1(141.35,166.11) 140.93,166.11 R2687.1
IPCC_CPU1_R: length 5.2
  TOP w0.114: R2723.2 20.52,142.15 v3(20.49,142.11) 20.02,141.64 19.24,141.64 17.79,140.19 U23.6
IPCC_CPU2: length 214.8
  TOP w0.114: CPU1.AR6 155,177 v1(154.48,176.48) ; v1(116.46,115.37) 114.57,113.47 111.18,113.47 v3(111.06,113.36) 110.79,113.09 104.5,113.09 103.38,111.96 v1(103.38,111.94) ; v1(22.91,144.19) 22.86,144.19 22.86,144.18 R2724.1 ; v1(141.76,166.75) 140.53,166.75 R2685.1
  L3 w0.114: v1(141.76,166.75) 145.17,170.16 145.17,173.29 147.35,175.46 150.75,175.46 152.3,177.01 153.95,177.01 v1(154.48,176.48)
  L6 w0.102: v1(141.76,166.75) 141.71,166.8 141.35,166.8 139.17,164.62 133.78,164.62 129.01,159.84 129.01,159.75 127.66,158.39 127.56,158.39 127.23,158.06 127.23,138.28 124.89,135.94 124.89,129.79 121.95,126.84 121.95,123.01 116.46,117.53 v1(116.46,115.37) ; v1(22.91,144.19) 22.2,143.48 22.2,131.07 22.88,130.39 22.88,125.66 23.06,125.48 23.06,117.58 29.54,111.1 97.13,111.1 97.96,111.93 103.29,111.93 103.3,111.94 v1(103.38,111.94)
  BOTTOM w0.114: R2685.1 140.53,166.75 v1(141.76,166.75)
IPCC_CPU2_R: length 6.1
  TOP w0.114: R2724.2 21.84,143.01 21.84,142.25 v3(21.85,142.24) 21.84,142.24 20.9,141.3 19.41,141.3 18.29,140.19 U23.5
IPCC_I2C_CLK: length 5.1
  TOP w0.114: U23.21 18.79,133.74 v1(18.97,133.55)
  BOTTOM w0.114: R2696.2 20.61,130.58 19.58,131.61 v2(19.58,131.82) 19.43,131.97 19.43,133.1 v1(18.97,133.55)
IPCC_I2C_CLK_R: length 179.5
  TOP w0.114: KBC1.70 118.87,48.94 119.3,48.51 119.81,48.51 120.18,48.15 v1(120.26,48.15)
  L3 w0.114: v1(22.83,131.57) 22.83,129.82 34.16,118.49 34.16,115.16 35,114.33 81.66,114.33 81.76,114.22 84.84,114.22 91.27,107.79 91.27,105.73 90.36,104.81 90.36,96.13 89.4,95.18 89.4,83.15 87.36,81.1 87.36,56.31 88.75,54.91 88.75,54.68 93.14,50.29 95.33,50.29 96.09,51.05 98.33,51.05 98.43,51.15 113.26,51.15 114.24,50.16 118.16,50.16 120.18,48.15 v1(120.26,48.15)
  BOTTOM w0.114: RN46.3 119.85,48.56 v1(120.26,48.15) 120.26,47.59 120.64,47.21 120.64,46.53 R2694.1 ; v1(22.83,131.57) 22.99,131.42 v2(22.99,130.61) 22.76,130.61 22.73,130.58 R2696.1
IPCC_I2C_DATA: length 4.8
  TOP w0.114: U23.22 19.29,133.93 19.46,133.76 19.46,133.24 v1(20.02,132.69)
  BOTTOM w0.114: R2697.2 20.87,131.97 21.21,132.31 21.21,132.66 v2(21.08,132.79) 20.12,132.79 v1(20.02,132.69)
IPCC_I2C_DATA_R: length 181.3
  TOP w0.114: KBC1.69 118.74,48.54 119.25,48.03 119.33,48.03 v1(119.35,48.01)
  L3 w0.114: v1(119.35,48.01) 117.7,49.66 114.12,49.66 113.05,50.73 98.6,50.73 98.51,50.63 96.27,50.63 95.44,49.81 92.91,49.81 88.32,54.41 88.32,54.74 86.89,56.16 86.89,81.23 88.98,83.32 88.98,95.35 89.94,96.31 89.94,105 90.86,105.92 90.86,107.62 89.81,108.66 89.76,108.66 84.63,113.79 81.58,113.79 81.47,113.91 34.83,113.91 33.74,114.99 33.74,118.32 22.42,129.65 22.42,129.69 22.35,129.76 22.35,132.05 v1(22.89,132.59)
  BOTTOM w0.114: RN46.4 119.37,49.52 119.13,49.28 119.13,48.29 119.35,48.06 v1(119.35,48.01) 120.29,47.07 120.29,46.62 R2695.1 ; R2697.1 22.75,132.59 v1(22.89,132.59) 23.2,132.9 v2(23.8,132.9)
IPCC_INT_SIO#: length 169.3
  TOP w0.114: v1(105.33,49.73) 105.41,49.66 105.41,48.03 105,47.62 103.96,47.62 103.28,46.94 KBC1.32 ; U23.23 19.79,133.88 20.02,133.65 v1(20.02,133.6)
  L3 w0.114: v1(105.33,49.73) 104.95,49.73 104.9,49.68 99.93,49.68 99.92,49.68 99.52,49.68 99.51,49.68 98.3,49.68 97.76,50.22 96.44,50.22 95.6,49.38 92.74,49.38 87.88,54.23 87.88,54.56 86.46,55.98 86.46,81.39 88.56,83.49 88.56,94.48 88.56,94.48 88.56,95.52 89.51,96.47 89.51,105.23 90.42,106.15 90.42,107.44 89.64,108.23 89.59,108.23 84.45,113.36 81.42,113.36 81.3,113.49 34.65,113.49 33.32,114.82 33.32,118.1 22,129.43 22,129.51 20.68,130.84 20.68,132.94 v1(20.02,133.6)
  BOTTOM w0.114: v1(105.33,49.73) 105.33,50.35 v2(104.48,51.2) ; v1(20.02,133.6) 20.45,134.04 R2712.2
IPCC_SWD_CLK: length 37.6
  TOP w0.114: IPCC1.4 15.97,108.39 8.32,116.04 8.32,125.87 11.96,129.51 v3(11.96,133.02) 11.96,133.27 12.6,133.91 12.6,134.7 15.31,137.41 U23.12
IPCC_SWD_DATA: length 37.8
  TOP w0.114: U23.11 14.92,137.91 v3(14.31,137.3) 13.92,136.9 13.92,136.52 12.14,134.75 12.14,134.19 11.23,133.27 11.23,129.26 7.95,125.98 7.95,115.93 13.97,109.9 IPCC1.5
IPCC_V_SENSE: length 46.9
  TOP w0.114: U24.6 18.16,109.46 R2720.1 18.06,109.57 18.06,109.62 17.65,110.03 17.65,110.29 v3(16.91,111.03) 9.4,118.54 9.4,125.68 13.26,129.54 v1(17.14,129.54) ; v1(19.89,140.74) 19.66,140.74 19.29,140.37 U23.3
  L3 w0.114: v1(19.89,140.74) 19.61,140.74 18.03,139.16 18.03,134.55 15.19,131.72 15.19,130.5 16.15,129.54 v1(17.14,129.54)
IPCC_VCCD: length 3.9
  TOP w0.254: U23.25 21.71,135.41 22.15,134.98 v3(22.63,134.98) 23.19,134.98 v1(23.62,135.41)
  BOTTOM w0.254: v1(23.62,135.41) 23.52,135.41 23.39,135.28 PC87.1
IPCC_VREF: length 5.9
  TOP w0.254: U23.1 20.29,140.26 20.52,140.49 22,140.49 v1(22.83,141.33)
  BOTTOM w0.254: v1(22.83,141.33) 22.83,141.17 v2(22.33,140.67) 22,140.34 C467.1
IPCC_XRES#: length 40.2
  TOP w0.114: IPCC1.3 17.97,107.3 v3(14.4,110.87) 8.66,116.61 8.66,125.72 12.82,129.88 16.07,129.88 17.63,131.44 19.51,131.44 20.83,132.77 20.83,133.73 20.29,134.27 U23.24
IPPC_GPU_CMP: length 3.9
  TOP w0.114: v1(15.74,134.11) 15.99,134.36 U23.16
  BOTTOM w0.114: v2(15.74,133.14) v1(15.74,134.11) 16.03,134.4 R2711.2
IPPC_GPU_CMP_R: length 3.5
  BOTTOM w0.114: R2713.2 15.14,137.58 R2501.1 15.14,136.54 R2711.1 15.14,134.82 v2(14.61,134.28)
IPPC_GPU_MAN: length 5
  TOP w0.114: U23.10 14.93,138.41 v3(14.3,139.04) 14,139.34 14,140 12.95,141.05 R2710.2
IPPC_GPU_PPC: length 3.7
  TOP w0.114: U23.9 15.47,138.91 14.55,139.83 v3(14.55,140.54) 14.55,140.97 R2709.2
JACK_PSID: length 86.1
  TOP w0.114: v1(94.97,59.39) 94.72,59.64 93.8,59.64 93.22,60.22 L24.1 ; v1(92.74,18.64) v3(94.28,18.64) 100.51,18.64 107.09,12.06 114.3,12.06 117.41,8.95 117.41,7.44 117.39,7.42 117.39,7.01 117.68,6.72 118.99,6.72 119.32,7.06 119.32,7.41 120.58,8.67 125.37,8.67 125.75,8.29 LAUOC1.6
  L4 w0.114: v1(92.74,18.64) 92.74,18.65 92.46,18.92 92.46,54.18 93.79,55.52 93.79,56.68 93.98,56.87 93.98,57.94 94.84,58.8 94.84,59.26 v1(94.97,59.39)
JTAG_BP_0: length 8.6
  TOP w0.114: GPU1.AW24 71.95,164.9 v6(72.4,164.45)
  BOTTOM w0.114: R513.2 73.37,158.7 v2(73.03,158.7) 72.5,159.22 72.5,160.94 72.54,160.98 72.82,161.26 72.82,163.76 72.4,164.18 v6(72.4,164.45)
JTAG_BP_0_R: length 2.3
  BOTTOM w0.114: TP42.1 76.23,158.67 R512.2 R513.1
JTAG_BP_1: length 7.2
  TOP w0.114: v6(72.4,165.35) 71.95,165.8 GPU1.AV24
  BOTTOM w0.114: v6(72.4,165.35) 72.55,165.35 v2(73.18,164.72) 73.18,164.29 73.04,164.15 73.04,161.18 72.75,160.89 72.75,160.1 R514.2
JTAG_BP_1_R: length 3.2
  BOTTOM w0.114: R511.2 74.19,161.8 TP43.1 73.56,161.49 73.56,160.92 R514.1
JTAG_DRAIN: length 1.6
  TOP w0.114: GPU1.AM20 67.78,170.18 v6(67.54,170.18)
  BOTTOM w0.114: v6(67.54,170.18) 67.96,170.6 TP45.1
JTAG_GATE: length 1.6
  TOP w0.114: GPU1.AM21 69.25,170.6 68.83,170.18 v6(68.81,170.18)
  BOTTOM w0.114: TP44.1 69.23,169.76 v6(68.81,170.18)
JTAG_TCK: length 1.6
  TOP w0.114: v6(78.18,176.45) 78.18,176.33 77.8,175.95 GPU1.AF30
  BOTTOM w0.114: v6(78.18,176.45) 78.66,175.97 TP110.1
JTAG_TDI: length 1.6
  TOP w0.114: GPU1.AD30 77.8,178.35 78.16,178.71 v6(78.16,178.84)
  BOTTOM w0.114: TP108.1 78.51,178.48 v6(78.16,178.84)
JTAG_TDO: length 1.7
  TOP w0.114: GPU1.AD31 78.66,178.2 79.06,178.61 79.06,178.69 v6(79.16,178.78)
  BOTTOM w0.114: v6(79.16,178.78) 78.64,179.3 TP107.1
JTAG_TMS: length 1.6
  TOP w0.114: GPU1.AE31 78.6,177.15 78.99,177.54 78.99,177.59 v6(79.05,177.65)
  BOTTOM w0.114: TP109.1 79.34,177.35 v6(79.05,177.65)
JTAG_TRSTB: length 60.7
  TOP w0.114: GPU1.AC30 78.13,179.73 78.13,179.87 78.2,179.93 v6(78.2,180) ; R522.1 95.85,203.85 96.49,203.21 96.49,203.17 v1(96.55,203.11)
  L6 w0.102: v1(96.55,203.11) 97.39,203.11 97.46,203.05 98.22,203.05 98.25,203.07 102.33,203.07 105.4,200.01 105.47,200.01 105.71,199.77 105.71,199.48 106.17,199.02 106.17,196.49 107.42,195.25 107.42,192.94 108.09,192.26 108.09,191.43 108.11,191.42 108.11,189.72 106.91,188.52 106.91,188.03 104.12,185.24 102.87,185.24 99.36,181.74 90.88,181.74 90.13,180.98 86.5,180.98 85.83,181.66 82.75,181.66 82.52,181.89 79.7,181.89 78.2,180.39 v6(78.2,180)
  BOTTOM w0.114: v6(78.2,180) 78.77,180.57 TP112.1 ; R526.1 95.85,203.81 v1(96.55,203.11)
KBC_ON#_GATE: length 6.3
  TOP w0.114: C284.2 102.41,76.76 v3(102.23,76.58) 101.29,76.58 Q9.G 100.67,77.1 100.13,76.56 100.13,75.57 R194.2 99.94,75.38 Q10.S
KBC_ON#_GATE_L: length 3.3
  TOP w0.114: R191.1 R194.1 100.04,73.57 v3(100.08,73.53) 100.16,73.44 R193.2
KBC_SPI_CLK: length 14.2
  TOP w0.114: U45.6 128.58,71.2 127.54,70.16 126.44,70.16 124.76,68.47 124.76,64.49 124.53,64.27 v3(124.53,64.27) 124.28,64.01 124.28,62.46 123.85,62.03 123.58,62.03 R2672.1
KBC_SPI_CS0_N: length 10.2
  TOP w0.114: R2674.1 122.62,60.24 124.35,61.96 124.55,61.96 v3(124.8,62.21) 125.44,62.21 125.53,62.12 126.03,62.12 126.78,62.88 126.78,64.25 126.28,64.75 RN2406.3 126.28,65.85 126.04,66.09 U45.1
KBC_SPI_IO2: length 11.1
  TOP w0.114: RN2406.4 125.63,65.65 125.25,66.04 125.25,68.02 125.22,68.05 125.22,68.45 125.86,69.09 128.14,69.09 128.58,68.65 U45.3 128.58,66.14 127.97,65.53 v3(127.97,65.28)
KBC_SPI_IO3: length 2.9
  TOP w0.114: U45.7 127.31,73.1 127.46,73.25 v3(127.46,73.81) 127.46,74.41 R2671.2
KBC_SPI_MISO: length 17.5
  TOP w0.114: v1(128.12,64.06) 127.31,64.87 U45.2 ; R2675.1 123.05,53.77 124.59,53.77 v1(124.64,53.82)
  BOTTOM w0.114: v1(124.64,53.82) 124.5,53.96 124.5,55.05 124.26,55.29 124.26,58.63 125.12,59.49 v2(125.12,59.89) 125.12,60.32 127.75,62.95 127.75,63.46 128.12,63.83 v1(128.12,64.06)
KBC_SPI_MOSI: length 17.9
  TOP w0.114: R2673.1 123.22,59.42 123.22,60.17 124.67,61.62 126.03,61.62 126.9,62.48 127.33,62.48 129.57,64.72 129.57,64.72 v3(129.62,64.76) 129.64,64.79 129.64,64.79 130.41,65.57 130.41,68.57 129.85,69.14 U45.5
KBC_VCC: length 63.9
  TOP w0.203: KBC1.19 101.09,52.15 v1(101.09,52.15) ; KBC1.115 109.25,59.64 109.47,59.41 v1(109.47,59.36) ; KBC1.76 118.89,51.35 119.3,50.94 119.73,50.94 v1(119.74,50.93) ; KBC1.46 109.25,43.69 108.74,43.18 v1(108.74,43.08)
  TOP w0.508: C280.1 108.75,43.07 v1(108.74,43.08) ; v1(101.09,52.15) 101.07,52.17 101.07,52.29 100.54,52.81 100.54,53.23 v3(100.03,53.75) v1(98.83,54.94) 98.65,55.12 C283.1
  TOP w0.635: C283.1 R184.1
  L3 w0.635: v1(109.47,59.36) 109.47,59.82 108.08,61.21 104.55,61.21 103.4,60.07 102.16,60.07 v1(101.06,58.98)
  L4 w0.508: 113.26,46.13 110.91,43.77 110.21,43.77 109.53,43.1 108.76,43.1 v1(108.74,43.08) ; 113.26,46.13 113.18,46.2 113.18,48.18 112.85,48.51 112.85,49.38 113.13,49.66 113.13,53.04 113.92,53.82 113.92,54.94 110.9,57.96 110.9,58.04 110.39,58.55 110.39,58.57 109.6,59.36 v1(109.47,59.36) ; 113.26,46.13 113.56,46.13 118.34,50.9 119.58,50.9 119.61,50.93 v1(119.74,50.93)
  L6 w0.635: v1(101.06,58.98) 101.06,58.98 100.76,58.98 98.81,57.02 98.81,54.97 v1(98.83,54.94)
  BOTTOM w0.508: v1(101.09,52.15) 101.13,52.11 C278.1 ; v1(109.47,59.36) 109.4,59.44 109.4,60.34 C279.1 ; v1(119.74,50.93) 119.74,50.95 119.15,51.54 C281.1 118.27,51.7 C282.1
KBC_VCORF: length 4.2
  TOP w0.114: KBC1.44 108.45,44.54 107.08,43.17 v3(106.97,43.17) 106.97,42.96 C1005.1
L_AD0: length 162.2
  TOP w0.114: v1(102.29,61.85) 102.3,61.84 104.63,61.84 104.85,61.62 KBC1.126 ; CPU1.AW20 148.13,163 141.59,156.46 141.23,156.46 140.41,155.65 v1(140.41,155.12)
  L6 w0.102: v1(152.68,83.01) 147.42,88.27 147.42,92.1 144.17,95.35 144.17,111.79 142.75,113.22 142.75,126.95 139.24,130.46 139.24,130.79 139.24,143.87 138.12,144.98 138.12,153.64 139.6,155.12 v1(140.41,155.12)
  BOTTOM w0.114: v1(102.29,61.85) v5(103.15,62.71) 108.81,62.71 111.76,65.66 111.76,67.26 118.92,74.42 118.92,77.09 LPC1.5 121,79.17 122.71,79.17 124.82,77.06 148.93,77.06 153.11,81.24 153.11,82.58 v1(152.68,83.01)
L_AD1: length 165.7
  TOP w0.114: v1(102.87,60.79) 102.87,60.45 103.5,59.82 104.24,59.82 104.45,60.02 KBC1.127 ; CPU1.AV21 151.61,162.39 148.93,162.39 146.35,159.82 145.44,159.82 141.73,156.11 141.53,156.11 v1(141.4,155.98)
  L3 w0.114: v1(152.48,84.56) 151.36,85.67 144.64,85.67 142.65,87.67 142.65,89.18 142.06,89.76 142.06,95.24 141.77,95.53 141.77,97.35 141.76,97.35 141.76,97.62 141.12,98.26 141.12,108.05 140.23,108.94 140.23,111 140,111.24 140,111.62 140.23,111.86 140.23,116 139.92,116.31 139.92,116.76 140.23,117.07 140.23,117.5 139.92,117.81 139.92,121.69 140.04,121.81 140.04,144.74 138.4,146.39 138.4,154.2 140.18,155.98 v1(141.4,155.98)
  BOTTOM w0.114: v1(102.87,60.79) 102.87,61.59 103.62,62.34 108.95,62.34 113.61,67.01 113.61,68.63 119.28,74.3 119.28,75.45 LPC1.7 120.19,76.33 121.04,77.17 123.11,77.17 123.73,76.55 v2(132.82,76.55) 148.91,76.55 153.45,81.1 153.45,83.58 v1(152.48,84.56)
