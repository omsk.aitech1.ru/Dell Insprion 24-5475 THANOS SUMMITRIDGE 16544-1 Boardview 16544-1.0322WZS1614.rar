# Allegro board 16544-1.0322WZS1614.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SMD49-12H34
  rect 1.753x1.397 smd: 1(0,1.295) 2(0,-1.295)
SMD49-3215-0713H36
  rect 1.549x1.549 smd: 1(0,1.371) 2(0,-1.371)
SMD-ARES4H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-ARES4H20
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD523AKH28
  rect 0.559x1.016 smd: A(0,0.762) K(0,-0.762)
SOD882-10D6-1H20
  custom 0.114x0.114 smd: 1(0,0.445) 2(0,-0.445)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G3530H63
  rect 0.635x1.651 smd: 1(-1.905,-2.555) 2(-0.635,-2.555) 3(0.635,-2.555) 4(1.905,-2.555) 5(1.905,2.555) 6(0.635,2.555) 7(-0.635,2.555) 8(-1.905,2.555)
  rect 3.505x2.997 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SON14J3020-G2610H32
  rect 0.025x0.025 smd: 1(1.2,1.105) 6(-0.8,1.105) 9(-0.8,-1.105) 14(1.2,-1.105)
  custom 0.151x0.151 smd: 2(0.8,1.105) 7(-1.2,1.105) 8(-1.2,-1.105) 13(0.8,-1.105)
  rect 0.203x0.813 smd: 3(0.4,1.105) 4(0,1.105) 5(-0.4,1.105) 10(-0.4,-1.105) 11(0,-1.105) 12(0.4,-1.105)
  rect 2.591x0.889 smd: 15(0,0)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D8-312H58
  custom 0.254x0.254 smd: 1(-1.016,-1.118) 2(1.016,-1.118) 3(0,1.118)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H50
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT-23-5H58
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR1337H524
  rect 12.7x3.404 smd: 1(-2.095,0)
STF256R109H99
  round 6.502 hole 2.769: 1(0,0)
TPAD26-OP
  round 0.66 smd: 1(0,0)
TPAD30
  round 0.762 smd: 1(0,0)
UMT6H44
  rect 0.406x0.813 smd: 1(0.65,1.025) 2(0,1.025) 3(-0.65,1.025) 4(-0.65,-1.025) 5(0,-1.025) 6(0.65,-1.025)
unnamed#2
  round 1.016 smd: (0,0)
WTB1024PDSHF
  rect 0.61x1.702 smd: 1(-5.5,-2.85) 2(-5.5,2.85) 3(-4.5,-2.85) 4(-4.5,2.85) 5(-3.5,-2.85) 6(-3.5,2.85) 7(-2.5,-2.85) 8(-2.5,2.85) 9(-1.5,-2.85) 10(-1.5,2.85) 11(-0.5,-2.85) 12(-0.5,2.85) 13(0.5,-2.85) 14(0.5,2.85) 15(1.5,-2.85) 16(1.5,2.85) 17(2.5,-2.85) 18(2.5,2.85) 19(3.5,-2.85) 20(3.5,2.85) 21(4.5,-2.85) 22(4.5,2.85) 23(5.5,-2.85) 24(5.5,2.85)
  rect 0.838x1.803 smd: 25(-6.825,0.4) 26(6.825,0.4)
WTB1030PDSHF
  rect 0.61x1.702 smd: 1(-7,-2.85) 2(-7,2.85) 3(-6,-2.85) 4(-6,2.85) 5(-5,-2.85) 6(-5,2.85) 7(-4,-2.85) 8(-4,2.85) 9(-3,-2.85) 10(-3,2.85) 11(-2,-2.85) 12(-2,2.85) 13(-1,-2.85) 14(-1,2.85) 15(0,-2.85) 16(0,2.85) 17(1,-2.85) 18(1,2.85) 19(2,-2.85) 20(2,2.85) 21(3,-2.85) 22(3,2.85) 23(4,-2.85) 24(4,2.85) 25(5,-2.85) 26(5,2.85) 27(6,-2.85) 28(6,2.85) 29(7,-2.85) 30(7,2.85)
  rect 0.838x1.803 smd: 31(-8.325,0.4) 32(8.325,0.4)

## Nets
1V_VDDC_VGA: C656.1 C657.1 C658.1 C659.1 C660.1 C661.1 C662.1 C663.1 C664.1 C665.1 C666.1 C667.1 C670.1 C671.1 C672.1 C673.1 C674.1 C675.1 C676.1 C677.1 C678.1 C679.1 C680.1 C681.1 C682.1 C684.1 C686.1 C687.1 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C704.1 C705.1 C706.1 C707.1 C719.1 C720.1 C721.1 C728.1 C729.1 C732.1 GPU1.AA16 GPU1.AA17 GPU1.AA20 GPU1.AA21 GPU1.AA24 GPU1.AA25 GPU1.AA28 GPU1.AA29 GPU1.AB16 GPU1.AB17 GPU1.AB20 GPU1.AB21 GPU1.AB24 GPU1.AB25 GPU1.AB28 GPU1.AB29 GPU1.AC16 GPU1.AC17 GPU1.AC20 GPU1.AC21 GPU1.AC24 GPU1.AC25 GPU1.AC28 GPU1.AC29 GPU1.AD16 GPU1.AD17 GPU1.AD20 GPU1.AD21 GPU1.AD24 GPU1.AD25 GPU1.AD28 GPU1.AD29 GPU1.AE16 GPU1.AE17 GPU1.AE20 GPU1.AE21 GPU1.AE24 GPU1.AE25 GPU1.AE28 GPU1.AE29 GPU1.AF16 GPU1.AF17 GPU1.AF20 GPU1.AF21 GPU1.AF24 GPU1.AF25 GPU1.AF28 GPU1.AF29 GPU1.AG17 GPU1.AG20 GPU1.AG21 GPU1.AG24 GPU1.AG25 GPU1.AG28 GPU1.AG29 GPU1.AH18 GPU1.AH19 GPU1.AH20 GPU1.AH21 GPU1.AH22 GPU1.AH23 GPU1.AH24 GPU1.AH25 GPU1.AH26 GPU1.AH27 GPU1.AH28 GPU1.AH29 GPU1.AJ19 GPU1.AJ20 GPU1.AJ21 GPU1.AJ22 GPU1.AJ23 GPU1.AJ24 GPU1.AJ25 GPU1.AJ26 GPU1.AJ27 GPU1.AJ28 GPU1.T16 GPU1.T17 GPU1.T20 GPU1.T21 GPU1.T24 GPU1.T25 GPU1.U16 GPU1.U17 GPU1.U20 GPU1.U21 GPU1.U24 GPU1.U25 GPU1.V16 GPU1.V17 GPU1.V20 GPU1.V21 GPU1.V24 GPU1.V25 GPU1.V28 GPU1.W16 GPU1.W17 GPU1.W20 GPU1.W21 GPU1.W24 GPU1.W25 GPU1.W28 GPU1.W29 GPU1.Y16 GPU1.Y17 GPU1.Y20 GPU1.Y21 GPU1.Y24 GPU1.Y25 GPU1.Y28 GPU1.Y29 PC317.1 PC318.1 PC319.1 PC320.1 PC321.1 PC322.1 PC323.1 PC324.1 PC325.1 PC326.1 PC333.1 PC334.1 PC335.1 PC336.1 PC337.1 PC338.1 PC339.1 PC340.1 PC341.1 PC342.1 PC347.1 PC348.1 PC349.1 PC350.1 PC351.1 PC352.1 PC353.1 PC354.1 PC355.1 PC356.1 PG162.2 PG164.2 PG172.2 PG174.2 PG182.2 PG184.2 PL14.2 PL15.2 PL16.2 PL17.2 PL18.2 PL19.2 PR251.1 PT29.1 PT30.1 PT32.1 PT33.1 PT35.1 PT38.1 PT39.1
1V_VDDCI_VGA: C668.1 C669.1 C700.1 C701.1 C702.1 C703.1 C716.1 C717.1 C718.1 C723.1 C724.1 C725.1 C726.1 C727.1 GPU1.AA14 GPU1.AC14 GPU1.AD15 GPU1.AE15 GPU1.AF15 GPU1.AG16 GPU1.AH15 GPU1.AH17 GPU1.AJ16 GPU1.AJ18 GPU1.P21 GPU1.P23 GPU1.R16 GPU1.R18 GPU1.R19 GPU1.R20 GPU1.R24 GPU1.R25 GPU1.R26 GPU1.R28 GPU1.T15 GPU1.T27 GPU1.T29 GPU1.U28 GPU1.V15 GPU1.V29 GPU1.W15 GPU1.Y15 PC366.1 PC368.1 PC369.1 PC370.1 PG189.2 PL20.2 PR260.1 PT42.1 PT43.1
1V_VDDCR_CPU: C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C55.1 C56.1 C57.1 CPU1.AA7 CPU1.AA10 CPU1.AA12 CPU1.AB3 CPU1.AB6 CPU1.AB9 CPU1.AB11 CPU1.AB13 CPU1.AC2 CPU1.AC10 CPU1.AC12 CPU1.AD7 CPU1.AD9 CPU1.AD11 CPU1.AD13 CPU1.AE3 CPU1.AE6 CPU1.AE10 CPU1.AE12 CPU1.AF2 CPU1.AF9 CPU1.AF11 CPU1.AF13 CPU1.AG7 CPU1.AG10 CPU1.AG12 CPU1.AG14 CPU1.AG16 CPU1.AG18 CPU1.AG20 CPU1.AG22 CPU1.AG24 CPU1.AG26 CPU1.AH3 CPU1.AH6 CPU1.AH9 CPU1.AH11 CPU1.AH13 CPU1.AH15 CPU1.AH17 CPU1.AH19 CPU1.AH21 CPU1.AH23 CPU1.AH25 CPU1.AH27 CPU1.AJ2 CPU1.AJ10 CPU1.AJ12 CPU1.AJ14 CPU1.AJ22 CPU1.AJ24 CPU1.AK7 CPU1.AK9 CPU1.AK11 CPU1.AK13 CPU1.AL3 CPU1.AL6 CPU1.AL10 CPU1.AL12 CPU1.AL14 CPU1.AM2 CPU1.AM8 CPU1.AN7 CPU1.AN10 CPU1.AN13 CPU1.AP3 CPU1.AP9 CPU1.AP12 CPU1.AR2 CPU1.AT4 CPU1.AU3 CPU1.AU6 CPU1.AU9 CPU1.AU12 CPU1.AU15 CPU1.AV5 CPU1.AV8 CPU1.AV11 CPU1.AV14 CPU1.M7 CPU1.N3 CPU1.N6 CPU1.P2 CPU1.R7 CPU1.T3 CPU1.T6 CPU1.T9 CPU1.U2 CPU1.U10 CPU1.V9 CPU1.V11 CPU1.W3 CPU1.W6 CPU1.W10 CPU1.W12 CPU1.Y2 CPU1.Y9 CPU1.Y11 CPU1.Y13 PC1.1 PC2.1 PC3.1 PC4.1 PC5.1 PC6.1 PC7.1 PC8.1 PC9.1 PC11.1 PC12.1 PC13.1 PC14.1 PC16.1 PC17.1 PC18.1 PC19.1 PC20.1 PC21.1 PC22.1 PC23.1 PC24.1 PC25.1 PC26.1 PC27.1 PG41.1 PG46.1 PG52.1 PL3.2 PL4.2 PL5.2 PR110.1 PT7.1 PT8.1 PT11.1 PT12.1 PT15.1 PT16.1
1V_VDDCR_SOC: C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C88.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 CPU1.B5 CPU1.B8 CPU1.B11 CPU1.B14 CPU1.B17 CPU1.B20 CPU1.C4 CPU1.C7 CPU1.C10 CPU1.C13 CPU1.C16 CPU1.C19 CPU1.D3 CPU1.E2 CPU1.F7 CPU1.F10 CPU1.F13 CPU1.F16 CPU1.G3 CPU1.G6 CPU1.G9 CPU1.G12 CPU1.G15 CPU1.G18 CPU1.H2 CPU1.J7 CPU1.J10 CPU1.J12 CPU1.J14 CPU1.J16 CPU1.K3 CPU1.K6 CPU1.K9 CPU1.K11 CPU1.K13 CPU1.K15 CPU1.L2 CPU1.L10 CPU1.L12 CPU1.L14 CPU1.L16 CPU1.L18 CPU1.L20 CPU1.L22 CPU1.L24 CPU1.L26 CPU1.M9 CPU1.M11 CPU1.M13 CPU1.M15 CPU1.M17 CPU1.M19 CPU1.M21 CPU1.M23 CPU1.M25 CPU1.N10 CPU1.N12 CPU1.N14 CPU1.N16 CPU1.N18 CPU1.N20 CPU1.N22 CPU1.N24 CPU1.N26 CPU1.P9 CPU1.P11 CPU1.P13 CPU1.R10 CPU1.R12 CPU1.T11 CPU1.T13 CPU1.U12 CPU1.V13 PC28.1 PC29.1 PC30.1 PC31.1 PC32.1 PC33.1 PC34.1 PC35.1 PC36.1 PC37.1 PC38.1 PC39.1 PC40.1 PC41.1 PC42.1 PC44.1 PC45.1 PC46.1 PC47.1 PC48.1 PC49.1 PG57.1 PG62.1 PL6.2 PL7.2 PR71.2 PT17.1 PT18.1 PT19.1 PT20.1 U17.1 U17.2
3V_5V_POK: PR63.2 PR64.2 PR65.2 TP117.1
5V_3D3V_S0_EN: C929.1 R861.2 U33.3 U33.5
5V_CODEC_DIGITAL_S0: D6.K L9.2 R2730.1 R2731.1
5V_CODEC_S0: C318.1 C319.1 C336.1 L9.1 U6.45
5V_S0: C932.1 C934.1 LPC1.8 R406.1 R407.1 R2582.1 R2731.2 RPWRC1.7 U33.13 U33.14
5V_S0_CT1: C931.1 U33.12
5V_S5: C423.1 C425.1 C451.1 C990.1 OSDC1.8 PC129.1 PC208.1 PC262.1 PC268.1 PC307.1 PC308.1 PC327.1 PC328.1 PC357.1 PC358.1 PC365.1 PC418.1 PC433.1 PC456.1 PC486.1 PG9.1 PG10.2 PG15.1 PG16.2 PG21.1 PG22.2 PG25.1 PG26.2 PG29.1 PG30.2 PG213.2 PG214.1 PG232.1 PG233.2 PR84.2 PR92.1 PR102.2 PR104.2 PR145.1 PR154.1 PR163.2 PR164.2 PR273.2 PR274.2 PR277.2 PR278.2 PR287.2 PR288.2 PR291.2 PR292.2 PR301.2 PR302.2 PR305.2 PR306.2 PR313.2 PR315.2 PR423.2 PR424.2 PU6.30 PU32.21 PU37.6 PU38.6 PU40.2 PU40.3 PU41.2 PU41.3 PU42.2 PU42.3 PU43.2 PU43.3 PU44.2 PU44.3 PU45.2 PU45.3 PU46.2 PU46.3 PU51.6 PU53.6 PU55.6 PU56.6 R385.1 R2730.2 R2755.1 R2757.1 R2759.1 R2763.1 R2765.1 RPWRC1.6 RPWRC1.8 U10.1 U11.5 U12.1 U13.5 U17.4 U33.1 U33.2 U33.4 U36.3 U39.4 U44.5
5V_USB_CHAR_REAR: RPWRC1.22 U12.12 UC2.1
5V_USB_CHAR_SIDE: SUSBC1.4 SUSBC1.6 U10.12 UC1.1
12V_FAN: C301.1 F21.2 FANC1.2 R2773.2
12V_PG: PR342.1 TP118.1
12V_S0: C2522.1 F21.1 PG145.2 PG146.2 R254.1 R2773.1
19V_AMP_AVDD: C377.1 C378.1 C411.1 C412.1 R872.2 R2738.2 U7.37 U8.37
19V_AMP_PVDD: C365.2 C366.1 C367.2 C368.2 C369.1 C370.2 C371.1 C372.1 C373.1 C375.1 C399.2 C400.1 C401.2 C402.2 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 L29.2 L32.2 R872.1 R2738.1 U7.1 U7.42 U7.43 U7.48 U7.51 U7.56 U8.1 U8.42 U8.43 U8.48 U8.51 U8.56
19V_DCBATOUT: C2520.1 C2521.1 F3.1 L29.1 L32.1 PG7.1 PG8.1 PG13.1 PG14.1 PG19.1 PG20.1 PG23.1 PG28.1 PG38.1 PG39.1 PG40.1 PG43.1 PG44.1 PG45.1 PG48.1 PG49.1 PG50.1 PG53.1 PG54.1 PG55.1 PG58.1 PG59.1 PG60.1 PG63.1 PG64.1 PG66.1 PG106.1 PG109.1 PG112.1 PG121.1 PG122.1 PG125.1 PG131.1 PG133.1 PG136.1 PG143.1 PG144.1 PG155.1 PG156.1 PG157.1 PG158.1 PG159.1 PG160.1 PG165.1 PG166.1 PG167.1 PG168.1 PG169.1 PG170.1 PG175.1 PG176.1 PG177.1 PG178.1 PG179.1 PG180.1 PG185.1 PG186.1 PG187.1 PG191.1 PG194.1 PG197.1 PG201.1 PG204.1 PR83.1 PR233.2 PR410.1 PR412.1 R366.1 RPWRC1.18 RPWRC1.20
19V_DCBATOUT_CAM: C1043.2 C1044.1 C1045.1 F3.2 R366.2 WEBCM1.2 WEBCM1.3 WEBCM1.4
AGND: C309.1 C312.2 C313.2 C314.1 C315.1 C316.2 C317.2 C318.2 C319.2 C322.2 C329.2 C330.2 C331.2 C332.2 C336.2 C340.2 C341.2 C342.2 C343.2 C351.2 C352.2 C1122.2 C1123.1 C1124.1 LAUOC1.28 LAUOC1.29 LAUOC1.30 LAUOC1.31 LAUOC1.32 LAUOC1.33 LAUOC1.34 LAUOC1.35 LAUOC1.36 Q68.S R304.2 R305.2 R2615.1 R2616.1 R2617.1 R2618.1 R2619.1 R2620.1 R2630.2 SUSBC1.15 SUSBC1.18 U6.20 U6.30 U6.42 U41.2 U42.2
GND: BT1.2 C17.1 C18.1 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C207.1 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C275.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C291.2 C292.2 C297.2 C298.2 C299.2 C300.2 C301.2 C310.2 C311.2 C324.2 C325.2 C326.2 C327.2 C328.2 C333.2 C334.2 C335.2 C337.1 C338.2 C344.2 C345.1 C347.2 C348.2 C349.2 C350.2 C353.1 C354.2 C355.1 C356.2 C365.1 C366.2 C367.1 C368.1 C369.2 C370.1 C371.2 C372.2 C373.2 C374.1 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C386.2 C387.1 C388.2 C389.1 C390.2 C399.1 C400.2 C401.1 C402.1 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.1 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C434.2 C435.2 C436.2 C440.2 C450.2 C451.2 C453.2 C454.2 C455.2 C456.2 C457.2 C458.2 C460.2 C461.2 C462.2 C463.2 C464.2 C468.2 C469.2 C470.2 C475.2 C476.2 C477.2 C478.2 C493.2 C494.2 C497.2 C498.2 C499.2 C500.2 C507.2 C508.2 C509.2 C510.2 C511.2 C512.2 C518.2 C592.2 C593.2 C601.2 C602.2 C608.2 C609.2 C610.2 C611.2 C616.2 C617.2 C618.2 C619.2 C622.2 C630.2 C631.2 C632.2 C634.2 C637.2 C638.2 C639.2 C640.2 C641.2 C653.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C743.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C818.2 C821.1 C822.1 C823.1 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C842.2 C843.2 C844.2 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C852.2 C853.2 C854.2 C855.2 C857.2 C858.2 C859.2 C860.2 C861.2 C862.2 C863.2 C864.2 C865.2 C866.2 C867.2 C868.2 C869.2 C870.2 C871.2 C872.2 C874.2 C875.2 C876.2 C877.2 C878.2 C879.2 C880.2 C881.2 C882.2 C883.2 C884.2 C885.2 C886.2 C887.2 C888.2 C889.2 C891.2 C892.2 C893.2 C894.2 C895.2 C896.2 C897.2 C898.2 C899.2 C900.2 C901.2 C902.2 C903.2 C904.2 C905.2 C906.2 C908.1 C925.2 C926.2 C929.2 C931.2 C932.2 C934.2 C947.2 C952.2 C961.2 C962.2 C963.2 C964.2 C965.2 C966.2 C970.2 C971.2 C974.2 C975.2 C976.2 C977.2 C979.2 C980.2 C981.2 C982.2 C983.2 C984.2 C985.2 C986.2 C987.2 C988.2 C989.2 C990.2 C991.2 C996.2 C997.2 C999.2 C1000.2 C1001.2 C1005.2 C1006.2 C1010.2 C1011.2 C1017.2 C1020.2 C1042.2 C1043.1 C1044.2 C1045.2 C1073.2 C1074.2 C1081.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1121.2 C1122.1 C1141.2 C1142.2 C1143.2 C1144.2 C1145.2 C1152.2 C1153.2 C1154.2 C1155.2 C1156.2 C1157.2 C1158.2 C1159.2 C1160.2 C2509.2 C2510.2 C2511.2 C2512.2 C2513.2 C2514.2 C2515.2 C2516.2 C2517.2 C2520.2 C2521.2 C2522.2 C2523.2 C2524.2 C2525.2 C2526.2 C2527.2 C2528.2 C2529.2 C2530.2 C2531.2 C2532.2 C2533.2 C2534.1 CPU1.A3 CPU1.A6 CPU1.A9 CPU1.A12 CPU1.A15 CPU1.A18 CPU1.A21 CPU1.A24 CPU1.A27 CPU1.A30 CPU1.A33 CPU1.A36 CPU1.AA1 CPU1.AA4 CPU1.AA6 CPU1.AA9 CPU1.AA11 CPU1.AA13 CPU1.AA27 CPU1.AA29 CPU1.AA31 CPU1.AB7 CPU1.AB10 CPU1.AB12 CPU1.AB28 CPU1.AB30 CPU1.AC5 CPU1.AC8 CPU1.AC9 CPU1.AC11 CPU1.AC13 CPU1.AC27 CPU1.AC29 CPU1.AC31 CPU1.AD1 CPU1.AD4 CPU1.AD10 CPU1.AD12 CPU1.AD28 CPU1.AD30 CPU1.AE7 CPU1.AE9 CPU1.AE11 CPU1.AE13 CPU1.AE27 CPU1.AE29 CPU1.AE31 CPU1.AF5 CPU1.AF8 CPU1.AF10 CPU1.AF12 CPU1.AF28 CPU1.AF30 CPU1.AG1 CPU1.AG4 CPU1.AG8 CPU1.AG9 CPU1.AG11 CPU1.AG13 CPU1.AG15 CPU1.AG17 CPU1.AG19 CPU1.AG21 CPU1.AG23 CPU1.AG25 CPU1.AG27 CPU1.AG28 CPU1.AG29 CPU1.AG30 CPU1.AG31 CPU1.AG32 CPU1.AH10 CPU1.AH12 CPU1.AH14 CPU1.AH16 CPU1.AH18 CPU1.AH20 CPU1.AH22 CPU1.AH24 CPU1.AH26 CPU1.AH28 CPU1.AH29 CPU1.AH30 CPU1.AH33 CPU1.AJ5 CPU1.AJ8 CPU1.AJ9 CPU1.AJ11 CPU1.AJ13 CPU1.AJ23 CPU1.AJ25 CPU1.AJ26 CPU1.AJ27 CPU1.AJ28 CPU1.AJ29 CPU1.AJ32 CPU1.AJ35 CPU1.AJ36 CPU1.AJ38 CPU1.AK1 CPU1.AK4 CPU1.AK10 CPU1.AK12 CPU1.AK14 CPU1.AK22 CPU1.AK25 CPU1.AK28 CPU1.AK31 CPU1.AK35 CPU1.AK37 CPU1.AL9 CPU1.AL11 CPU1.AL24 CPU1.AL27 CPU1.AL30 CPU1.AL33 CPU1.AL35 CPU1.AL36 CPU1.AL39 CPU1.AM5 CPU1.AM11 CPU1.AM14 CPU1.AM26 CPU1.AM29 CPU1.AM32 CPU1.AM35 CPU1.AM38 CPU1.AN1 CPU1.AN4 CPU1.AN22 CPU1.AN25 CPU1.AN28 CPU1.AN31 CPU1.AN34 CPU1.AN35 CPU1.AN37 CPU1.AP6 CPU1.AP24 CPU1.AP27 CPU1.AP30 CPU1.AP33 CPU1.AP35 CPU1.AP36 CPU1.AP39 CPU1.AR5 CPU1.AR8 CPU1.AR11 CPU1.AR14 CPU1.AR17 CPU1.AR23 CPU1.AR26 CPU1.AR27 CPU1.AR29 CPU1.AR30 CPU1.AR32 CPU1.AR34 CPU1.AR35 CPU1.AR38 CPU1.AT1 CPU1.AT7 CPU1.AT10 CPU1.AT13 CPU1.AT16 CPU1.AT22 CPU1.AT26 CPU1.AT27 CPU1.AT28 CPU1.AT29 CPU1.AT31 CPU1.AT32 CPU1.AT33 CPU1.AT34 CPU1.AT37 CPU1.AU18 CPU1.AU21 CPU1.AU24 CPU1.AU26 CPU1.AU27 CPU1.AU30 CPU1.AU33 CPU1.AU36 CPU1.AU39 CPU1.AV2 CPU1.AV17 CPU1.AV20 CPU1.AV23 CPU1.AV26 CPU1.AV29 CPU1.AV32 CPU1.AV35 CPU1.AV38 CPU1.AW4 CPU1.AW7 CPU1.AW10 CPU1.AW13 CPU1.AW16 CPU1.AW19 CPU1.AW22 CPU1.AW25 CPU1.AW28 CPU1.AW31 CPU1.AW34 CPU1.AW37 CPU1.B19 CPU1.B23 CPU1.B26 CPU1.B29 CPU1.B32 CPU1.B35 CPU1.C1 CPU1.C22 CPU1.C25 CPU1.C28 CPU1.C31 CPU1.C34 CPU1.C37 CPU1.D6 CPU1.D9 CPU1.D12 CPU1.D15 CPU1.D18 CPU1.D19 CPU1.D21 CPU1.D22 CPU1.D23 CPU1.D24 CPU1.D25 CPU1.D27 CPU1.D29 CPU1.D30 CPU1.D31 CPU1.D32 CPU1.D33 CPU1.D34 CPU1.D35 CPU1.D36 CPU1.D39 CPU1.E4 CPU1.E5 CPU1.E8 CPU1.E11 CPU1.E14 CPU1.E17 CPU1.E20 CPU1.E21 CPU1.E23 CPU1.E26 CPU1.E27 CPU1.E29 CPU1.E32 CPU1.E35 CPU1.E38 CPU1.F1 CPU1.F4 CPU1.F17 CPU1.F19 CPU1.F22 CPU1.F25 CPU1.F28 CPU1.F31 CPU1.F34 CPU1.F35 CPU1.F37 CPU1.G7 CPU1.G21 CPU1.G24 CPU1.G27 CPU1.G30 CPU1.G33 CPU1.G35 CPU1.G36 CPU1.G39 CPU1.H4 CPU1.H5 CPU1.H8 CPU1.H11 CPU1.H14 CPU1.H17 CPU1.H20 CPU1.H23 CPU1.H26 CPU1.H29 CPU1.H32 CPU1.H35 CPU1.H38 CPU1.J1 CPU1.J4 CPU1.J8 CPU1.J9 CPU1.J11 CPU1.J13 CPU1.J15 CPU1.J17 CPU1.J19 CPU1.J22 CPU1.J25 CPU1.J28 CPU1.J31 CPU1.J34 CPU1.J35 CPU1.J37 CPU1.K10 CPU1.K12 CPU1.K18 CPU1.K20 CPU1.K21 CPU1.K22 CPU1.K23 CPU1.K26 CPU1.K27 CPU1.K28 CPU1.K29 CPU1.K30 CPU1.K33 CPU1.L4 CPU1.L5 CPU1.L8 CPU1.L9 CPU1.L11 CPU1.L13 CPU1.L15 CPU1.L17 CPU1.L19 CPU1.L21 CPU1.L25 CPU1.L27 CPU1.L28 CPU1.L29 CPU1.L30 CPU1.L31 CPU1.M1 CPU1.M4 CPU1.M8 CPU1.M10 CPU1.M12 CPU1.M14 CPU1.M16 CPU1.M18 CPU1.M20 CPU1.M24 CPU1.M26 CPU1.M27 CPU1.M28 CPU1.N9 CPU1.N11 CPU1.N13 CPU1.N15 CPU1.N17 CPU1.N19 CPU1.N21 CPU1.N23 CPU1.N25 CPU1.N27 CPU1.N29 CPU1.P4 CPU1.P5 CPU1.P8 CPU1.P10 CPU1.P12 CPU1.R1 CPU1.R4 CPU1.R8 CPU1.R9 CPU1.R11 CPU1.R13 CPU1.R27 CPU1.R29 CPU1.T10 CPU1.T12 CPU1.T28 CPU1.T30 CPU1.U4 CPU1.U5 CPU1.U8 CPU1.U9 CPU1.U11 CPU1.U13 CPU1.U27 CPU1.U29 CPU1.U31 CPU1.V1 CPU1.V4 CPU1.V7 CPU1.V10 CPU1.V12 CPU1.V28 CPU1.V30 CPU1.W9 CPU1.W11 CPU1.W13 CPU1.W27 CPU1.W29 CPU1.W31 CPU1.Y5 CPU1.Y8 CPU1.Y10 CPU1.Y12 CPU1.Y28 CPU1.Y30 D1.2 D6.A D8.A D9.1 D12.2 D15.1 D16.1 DCPWR1.1 DCPWR1.4 DCPWR1.5 DCPWR1.8 DIMM1.1 DIMM1.2 DIMM1.5 DIMM1.6 DIMM1.9 DIMM1.10 DIMM1.14 DIMM1.15 DIMM1.18 DIMM1.19 DIMM1.22 DIMM1.23 DIMM1.26 DIMM1.27 DIMM1.30 DIMM1.31 DIMM1.35 DIMM1.36 DIMM1.39 DIMM1.40 DIMM1.43 DIMM1.44 DIMM1.47 DIMM1.48 DIMM1.51 DIMM1.52 DIMM1.56 DIMM1.57 DIMM1.60 DIMM1.61 DIMM1.64 DIMM1.65 DIMM1.68 DIMM1.69 DIMM1.72 DIMM1.73 DIMM1.77 DIMM1.78 DIMM1.81 DIMM1.82 DIMM1.85 DIMM1.86 DIMM1.89 DIMM1.90 DIMM1.93 DIMM1.94 DIMM1.98 DIMM1.99 DIMM1.102 DIMM1.103 DIMM1.106 DIMM1.107 DIMM1.167 DIMM1.168 DIMM1.171 DIMM1.172 DIMM1.175 DIMM1.176 DIMM1.180 DIMM1.181 DIMM1.184 DIMM1.185 DIMM1.188 DIMM1.189 DIMM1.192 DIMM1.193 DIMM1.196 DIMM1.197 DIMM1.201 DIMM1.202 DIMM1.205 DIMM1.206 DIMM1.209 DIMM1.210 DIMM1.213 DIMM1.214 DIMM1.217 DIMM1.218 DIMM1.222 DIMM1.223 DIMM1.226 DIMM1.227 DIMM1.230 DIMM1.231 DIMM1.234 DIMM1.235 DIMM1.238 DIMM1.239 DIMM1.243 DIMM1.244 DIMM1.247 DIMM1.248 DIMM1.251 DIMM1.252 DIMM1.261 DIMM1.262 DIMM2.1 DIMM2.2 DIMM2.5 DIMM2.6 DIMM2.9 DIMM2.10 DIMM2.14 DIMM2.15 DIMM2.18 DIMM2.19 DIMM2.22 DIMM2.23 DIMM2.26 DIMM2.27 DIMM2.30 DIMM2.31 DIMM2.35 DIMM2.36 DIMM2.39 DIMM2.40 DIMM2.43 DIMM2.44 DIMM2.47 DIMM2.48 DIMM2.51 DIMM2.52 DIMM2.56 DIMM2.57 DIMM2.60 DIMM2.61 DIMM2.64 DIMM2.65 DIMM2.68 DIMM2.69 DIMM2.72 DIMM2.73 DIMM2.77 DIMM2.78 DIMM2.81 DIMM2.82 DIMM2.85 DIMM2.86 DIMM2.89 DIMM2.90 DIMM2.93 DIMM2.94 DIMM2.98 DIMM2.99 DIMM2.102 DIMM2.103 DIMM2.106 DIMM2.107 DIMM2.167 DIMM2.168 DIMM2.171 DIMM2.172 DIMM2.175 DIMM2.176 DIMM2.180 DIMM2.181 DIMM2.184 DIMM2.185 DIMM2.188 DIMM2.189 DIMM2.192 DIMM2.193 DIMM2.196 DIMM2.197 DIMM2.201 DIMM2.202 DIMM2.205 DIMM2.206 DIMM2.209 DIMM2.210 DIMM2.213 DIMM2.214 DIMM2.217 DIMM2.218 DIMM2.222 DIMM2.223 DIMM2.226 DIMM2.227 DIMM2.230 DIMM2.231 DIMM2.234 DIMM2.235 DIMM2.238 DIMM2.239 DIMM2.243 DIMM2.244 DIMM2.247 DIMM2.248 DIMM2.251 DIMM2.252 DIMM2.261 DIMM2.262 DISPC1.2 DISPC1.5 DISPC1.8 DISPC1.11 DISPC1.14 DISPC1.17 DISPC1.20 DISPC1.21 DISPC1.22 DISPC1.23 DISPC1.27 DISPC1.30 DISPC1.33 DISPC1.36 DISPC1.39 DISPC1.40 DISPC1.41 DISPC1.42 DISPC1.43 DISPC1.44 DISPC1.45 DISPC2.2 DISPC2.5 DISPC2.8 DISPC2.11 DISPC2.14 DISPC2.17 DISPC2.20 DISPC2.21 DISPC2.22 DISPC2.23 DISPC2.27 DISPC2.30 DISPC2.33 DISPC2.36 DISPC2.39 DISPC2.40 DISPC2.41 DISPC2.42 DISPC2.43 DISPC2.44 DISPC2.45 DMIC1.2 DMIC1.8 DMIC1.9 DMIC1.10 FANC1.1 G1.2 GPU1.A2 GPU1.A6 GPU1.A11 GPU1.A15 GPU1.A19 GPU1.A25 GPU1.A29 GPU1.A33 GPU1.A38 GPU1.A42 GPU1.AA3 GPU1.AA6 GPU1.AA9 GPU1.AA12 GPU1.AA15 GPU1.AA18 GPU1.AA19 GPU1.AA22 GPU1.AA23 GPU1.AA26 GPU1.AA27 GPU1.AA32 GPU1.AA33 GPU1.AA36 GPU1.AA40 GPU1.AB15 GPU1.AB18 GPU1.AB19 GPU1.AB22 GPU1.AB23 GPU1.AB26 GPU1.AB27 GPU1.AC3 GPU1.AC6 GPU1.AC12 GPU1.AC15 GPU1.AC18 GPU1.AC19 GPU1.AC22 GPU1.AC23 GPU1.AC26 GPU1.AC27 GPU1.AC32 GPU1.AC33 GPU1.AC34 GPU1.AC36 GPU1.AC40 GPU1.AC41 GPU1.AD2 GPU1.AD5 GPU1.AD8 GPU1.AD14 GPU1.AD18 GPU1.AD19 GPU1.AD22 GPU1.AD23 GPU1.AD26 GPU1.AD27 GPU1.AD32 GPU1.AD35 GPU1.AD37 GPU1.AD40 GPU1.AE1 GPU1.AE4 GPU1.AE10 GPU1.AE18 GPU1.AE19 GPU1.AE22 GPU1.AE23 GPU1.AE26 GPU1.AE27 GPU1.AE32 GPU1.AE36 GPU1.AE40 GPU1.AF3 GPU1.AF6 GPU1.AF8 GPU1.AF12 GPU1.AF18 GPU1.AF19 GPU1.AF22 GPU1.AF23 GPU1.AF26 GPU1.AF27 GPU1.AF32 GPU1.AF36 GPU1.AF40 GPU1.AF41 GPU1.AG2 GPU1.AG8 GPU1.AG10 GPU1.AG14 GPU1.AG15 GPU1.AG18 GPU1.AG19 GPU1.AG22 GPU1.AG23 GPU1.AG26 GPU1.AG27 GPU1.AG32 GPU1.AG35 GPU1.AG37 GPU1.AG40 GPU1.AH16 GPU1.AJ1 GPU1.AJ4 GPU1.AJ10 GPU1.AJ14 GPU1.AJ15 GPU1.AJ17 GPU1.AJ29 GPU1.AJ32 GPU1.AJ36 GPU1.AJ40 GPU1.AK3 GPU1.AK6 GPU1.AK12 GPU1.AK15 GPU1.AK17 GPU1.AK18 GPU1.AK20 GPU1.AK24 GPU1.AK27 GPU1.AK29 GPU1.AK32 GPU1.AK36 GPU1.AK40 GPU1.AK41 GPU1.AL23 GPU1.AL25 GPU1.AL29 GPU1.AM2 GPU1.AM8 GPU1.AM11 GPU1.AM14 GPU1.AM18 GPU1.AM26 GPU1.AM32 GPU1.AM35 GPU1.AM37 GPU1.AM40 GPU1.AN1 GPU1.AN4 GPU1.AN12 GPU1.AN24 GPU1.AN27 GPU1.AN33 GPU1.AN36 GPU1.AN40 GPU1.AP15 GPU1.AP19 GPU1.AP25 GPU1.AP29 GPU1.AP30 GPU1.AR3 GPU1.AR6 GPU1.AR9 GPU1.AR32 GPU1.AR33 GPU1.AR35 GPU1.AR36 GPU1.AR40 GPU1.AR41 GPU1.AT2 GPU1.AT5 GPU1.AT12 GPU1.AT17 GPU1.AT21 GPU1.AT26 GPU1.AT27 GPU1.AT35 GPU1.AT38 GPU1.AT39 GPU1.AT40 GPU1.AT41 GPU1.AT42 GPU1.AT43 GPU1.AU18 GPU1.AU19 GPU1.AU23 GPU1.AU24 GPU1.AU25 GPU1.AV1 GPU1.AV4 GPU1.AV6 GPU1.AV9 GPU1.AV14 GPU1.AV20 GPU1.AV29 GPU1.AV30 GPU1.AV32 GPU1.AV33 GPU1.AV38 GPU1.AV39 GPU1.AV40 GPU1.AW2 GPU1.AW5 GPU1.AW8 GPU1.AW26 GPU1.AW27 GPU1.AW29 GPU1.AW30 GPU1.AW32 GPU1.AW33 GPU1.AW35 GPU1.AW36 GPU1.AW38 GPU1.AW39 GPU1.AW41 GPU1.AW43 GPU1.AY3 GPU1.AY6 GPU1.AY11 GPU1.AY15 GPU1.AY18 GPU1.AY19 GPU1.AY25 GPU1.AY41 GPU1.B1 GPU1.B2 GPU1.B8 GPU1.B12 GPU1.B17 GPU1.B20 GPU1.B24 GPU1.B27 GPU1.B32 GPU1.B36 GPU1.B39 GPU1.B42 GPU1.B43 GPU1.BA4 GPU1.BA9 GPU1.BA14 GPU1.BA18 GPU1.BA21 GPU1.BA23 GPU1.BA26 GPU1.BA27 GPU1.BA29 GPU1.BA30 GPU1.BA32 GPU1.BA33 GPU1.BA35 GPU1.BA36 GPU1.BA38 GPU1.BA39 GPU1.BA40 GPU1.BB1 GPU1.BB2 GPU1.BB5 GPU1.BB8 GPU1.BB12 GPU1.BB17 GPU1.BB18 GPU1.BB42 GPU1.BB43 GPU1.BC2 GPU1.BC6 GPU1.BC11 GPU1.BC15 GPU1.BC18 GPU1.BC42 GPU1.C5 GPU1.C9 GPU1.C14 GPU1.C18 GPU1.C21 GPU1.C23 GPU1.C26 GPU1.C30 GPU1.C35 GPU1.C40 GPU1.D6 GPU1.D11 GPU1.D15 GPU1.D19 GPU1.D25 GPU1.D29 GPU1.D33 GPU1.D38 GPU1.D41 GPU1.E3 GPU1.E5 GPU1.E8 GPU1.E24 GPU1.E36 GPU1.E39 GPU1.E42 GPU1.F1 GPU1.F4 GPU1.F6 GPU1.F9 GPU1.F14 GPU1.F18 GPU1.F21 GPU1.F23 GPU1.F26 GPU1.F30 GPU1.F35 GPU1.F38 GPU1.F40 GPU1.F43 GPU1.H2 GPU1.H5 GPU1.H8 GPU1.H12 GPU1.H17 GPU1.H20 GPU1.H24 GPU1.H26 GPU1.H27 GPU1.H32 GPU1.H39 GPU1.H42 GPU1.J3 GPU1.J6 GPU1.J9 GPU1.J21 GPU1.J35 GPU1.J38 GPU1.J41 GPU1.K15 GPU1.K19 GPU1.K25 GPU1.K27 GPU1.K29 GPU1.L1 GPU1.L4 GPU1.L7 GPU1.L11 GPU1.L12 GPU1.L14 GPU1.L32 GPU1.L40 GPU1.L43 GPU1.M2 GPU1.M8 GPU1.M11 GPU1.M18 GPU1.M21 GPU1.M23 GPU1.M26 GPU1.M30 GPU1.M33 GPU1.M36 GPU1.M42 GPU1.P3 GPU1.P6 GPU1.P9 GPU1.P11 GPU1.P17 GPU1.P18 GPU1.P24 GPU1.P27 GPU1.P29 GPU1.P32 GPU1.P38 GPU1.P41 GPU1.R1 GPU1.R4 GPU1.R10 GPU1.R15 GPU1.R17 GPU1.R21 GPU1.R22 GPU1.R23 GPU1.R27 GPU1.R29 GPU1.R30 GPU1.R34 GPU1.R40 GPU1.R43 GPU1.T18 GPU1.T19 GPU1.T22 GPU1.T23 GPU1.T26 GPU1.T28 GPU1.U2 GPU1.U8 GPU1.U14 GPU1.U15 GPU1.U18 GPU1.U19 GPU1.U22 GPU1.U23 GPU1.U26 GPU1.U27 GPU1.U29 GPU1.U30 GPU1.U36 GPU1.U42 GPU1.V3 GPU1.V6 GPU1.V12 GPU1.V18 GPU1.V19 GPU1.V22 GPU1.V23 GPU1.V26 GPU1.V27 GPU1.V30 GPU1.V32 GPU1.V37 GPU1.W1 GPU1.W4 GPU1.W10 GPU1.W18 GPU1.W19 GPU1.W22 GPU1.W23 GPU1.W26 GPU1.W27 GPU1.W34 GPU1.W36 GPU1.W38 GPU1.W39 GPU1.W40 GPU1.W41 GPU1.Y2 GPU1.Y5 GPU1.Y8 GPU1.Y18 GPU1.Y19 GPU1.Y22 GPU1.Y23 GPU1.Y26 GPU1.Y27 GPU1.Y30 GPU1.Y35 GPU1.Y36 GPU1.Y37 GPU1.Y40 H1.1 H1.2 H1.3 H1.4 H1.5 H1.6 H1.7 H1.8 H2.1 H2.2 H2.3 H2.4 H2.5 H2.6 H2.7 H2.8 H3.1 H3.2 H3.3 H3.4 H3.5 H3.6 H3.7 H3.8 H4.1 H4.2 H4.3 H4.4 H4.5 H4.6 H4.7 H4.8 H5.1 H6.1 H7.1 H8.1 H9.1 H10.1 H11.1 H12.1 H14.1 H14.2 H14.3 H14.4 H14.5 H14.6 H14.7 H14.8 H15.1 H16.1 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDT1.3 HDT1.5 HDT1.7 HDT1.17 HS1.1 IPCC1.2 JMP1.4 JMP1.6 KBC1.5 KBC1.12 KBC1.18 KBC1.45 KBC1.78 KBC1.89 KBC1.116 LAUOC1.1 LAUOC1.2 LAUOC1.7 LAUOC1.15 LAUOC1.20 LAUOC1.27 LAUOC1.41 LAUOC1.42 LPC1.12 LPC1.14 OSDC1.2 OSDC1.9 OSDC1.10 OSDC1.11 OSDC1.12 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC11.2 PC12.2 PC13.2 PC14.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.2 PC21.2 PC22.2 PC23.2 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.2 PC49.2 PC50.2 PC51.2 PC52.2 PC53.2 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC60.2 PC61.2 PC62.2 PC63.2 PC64.2 PC65.2 PC66.2 PC67.1 PC92.2 PC94.2 PC95.2 PC96.2 PC97.2 PC98.2 PC99.2 PC100.2 PC101.2 PC102.2 PC103.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.1 PC119.2 PC122.2 PC125.1 PC126.2 PC127.2 PC128.2 PC129.2 PC130.2 PC138.2 PC141.2 PC142.2 PC143.2 PC145.2 PC146.2 PC147.2 PC148.2 PC150.2 PC151.2 PC152.2 PC153.2 PC154.2 PC156.2 PC157.2 PC158.2 PC159.2 PC160.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC171.2 PC172.2 PC173.2 PC174.2 PC175.2 PC177.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC183.2 PC184.2 PC185.2 PC186.2 PC188.2 PC189.2 PC190.2 PC191.2 PC193.2 PC194.2 PC195.2 PC196.2 PC208.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC229.2 PC230.2 PC232.2 PC234.2 PC235.2 PC236.2 PC237.2 PC238.2 PC239.2 PC240.2 PC241.2 PC243.2 PC244.2 PC245.1 PC247.2 PC248.2 PC249.2 PC250.2 PC251.2 PC252.2 PC253.2 PC254.2 PC257.2 PC260.2 PC261.2 PC262.2 PC263.2 PC266.2 PC267.2 PC268.2 PC269.2 PC270.2 PC271.2 PC272.2 PC274.2 PC275.2 PC276.2 PC277.2 PC278.2 PC281.2 PC283.2 PC285.2 PC286.2 PC289.2 PC290.2 PC291.2 PC293.2 PC296.2 PC297.2 PC304.2 PC306.2 PC307.2 PC308.2 PC310.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC323.2 PC324.2 PC325.2 PC326.2 PC327.2 PC328.2 PC331.2 PC332.2 PC333.2 PC334.2 PC335.2 PC336.2 PC337.2 PC338.2 PC339.2 PC340.2 PC341.2 PC342.2 PC344.2 PC345.2 PC346.2 PC347.2 PC348.2 PC349.2 PC350.2 PC351.2 PC352.2 PC353.2 PC354.2 PC355.2 PC356.2 PC357.2 PC358.2 PC361.2 PC362.2 PC363.2 PC364.2 PC365.2 PC366.2 PC368.2 PC369.2 PC370.2 PC371.2 PC372.2 PC374.2 PC375.2 PC376.2 PC377.2 PC378.2 PC379.2 PC380.2 PC381.2 PC382.2 PC384.2 PC386.2 PC387.2 PC388.2 PC389.2 PC390.2 PC391.2 PC392.2 PC393.2 PC396.2 PC399.2 PC400.2 PC401.2 PC405.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC414.2 PC417.2 PC418.2 PC419.2 PC422.2 PC423.2 PC424.2 PC425.2 PC426.2 PC428.2 PC430.2 PC431.2 PC432.2 PC433.2 PC437.2 PC438.2 PC439.2 PC440.2 PC456.2 PC457.2 PC458.2 PC460.2 PC461.2 PC484.2 PC485.2 PC486.2 PC487.2 PC489.2 PC490.2 PC491.2 PC492.2 PC493.2 PC494.2 PC495.2 PC496.2 PC497.2 PC498.2 PC499.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PCH1.A25 PCH1.AA3 PCH1.AA4 PCH1.AA5 PCH1.AA6 PCH1.AA10 PCH1.AA12 PCH1.AA13 PCH1.AA14 PCH1.AA15 PCH1.AA16 PCH1.AA17 PCH1.AA18 PCH1.AA19 PCH1.AA20 PCH1.AA21 PCH1.AA24 PCH1.AB10 PCH1.AB12 PCH1.AB14 PCH1.AB17 PCH1.AB20 PCH1.AB22 PCH1.AB23 PCH1.AB24 PCH1.AC1 PCH1.AC2 PCH1.AC3 PCH1.AC4 PCH1.AC11 PCH1.AC12 PCH1.AC14 PCH1.AC17 PCH1.AC20 PCH1.AC22 PCH1.AC24 PCH1.AD5 PCH1.AD6 PCH1.AD11 PCH1.AD12 PCH1.AD13 PCH1.AD14 PCH1.AD15 PCH1.AD16 PCH1.AD17 PCH1.AD18 PCH1.AD19 PCH1.AD20 PCH1.AD21 PCH1.AD22 PCH1.AD24 PCH1.AE11 PCH1.AE13 PCH1.AE15 PCH1.AE19 PCH1.AE23 PCH1.AE25 PCH1.AF11 PCH1.AF13 PCH1.AF15 PCH1.AF19 PCH1.AF23 PCH1.AF25 PCH1.B8 PCH1.B9 PCH1.B24 PCH1.C10 PCH1.C11 PCH1.C12 PCH1.C13 PCH1.C14 PCH1.C15 PCH1.C16 PCH1.C17 PCH1.C18 PCH1.D10 PCH1.D19 PCH1.D20 PCH1.D22 PCH1.D23 PCH1.D26 PCH1.E9 PCH1.E10 PCH1.E24 PCH1.F1 PCH1.F2 PCH1.F3 PCH1.F4 PCH1.F5 PCH1.F9 PCH1.F10 PCH1.F11 PCH1.F12 PCH1.F13 PCH1.F14 PCH1.F15 PCH1.F16 PCH1.F17 PCH1.F18 PCH1.F19 PCH1.F22 PCH1.G3 PCH1.G6 PCH1.G22 PCH1.G23 PCH1.G24 PCH1.G25 PCH1.G26 PCH1.H1 PCH1.H2 PCH1.H3 PCH1.H4 PCH1.H5 PCH1.H6 PCH1.H22 PCH1.H23 PCH1.J3 PCH1.J6 PCH1.J22 PCH1.J23 PCH1.J25 PCH1.J26 PCH1.K1 PCH1.K2 PCH1.K3 PCH1.K4 PCH1.K5 PCH1.K6 PCH1.K10 PCH1.K23 PCH1.K24 PCH1.L3 PCH1.L6 PCH1.L9 PCH1.L10 PCH1.L11 PCH1.L12 PCH1.L13 PCH1.L14 PCH1.L15 PCH1.L16 PCH1.L21 PCH1.M1 PCH1.M2 PCH1.M3 PCH1.M4 PCH1.M5 PCH1.M6 PCH1.M7 PCH1.M9 PCH1.M10 PCH1.M11 PCH1.M12 PCH1.M13 PCH1.M14 PCH1.M15 PCH1.M16 PCH1.M21 PCH1.M24 PCH1.N3 PCH1.N6 PCH1.N9 PCH1.N10 PCH1.N11 PCH1.N12 PCH1.N13 PCH1.N14 PCH1.N15 PCH1.N16 PCH1.N21 PCH1.N23 PCH1.N26 PCH1.P1 PCH1.P2 PCH1.P3 PCH1.P4 PCH1.P5 PCH1.P6 PCH1.P9 PCH1.P10 PCH1.P11 PCH1.P12 PCH1.P13 PCH1.P14 PCH1.P15 PCH1.P16 PCH1.P21 PCH1.P24 PCH1.R9 PCH1.R10 PCH1.R11 PCH1.R12 PCH1.R13 PCH1.R14 PCH1.R15 PCH1.R16 PCH1.R21 PCH1.T9 PCH1.T10 PCH1.T11 PCH1.T12 PCH1.T13 PCH1.T14 PCH1.T15 PCH1.T16 PCH1.T25 PCH1.T26 PCH1.U9 PCH1.U10 PCH1.U11 PCH1.U12 PCH1.U13 PCH1.U14 PCH1.U15 PCH1.U16 PCH1.U21 PCH1.U22 PCH1.U23 PCH1.U24 PCH1.U25 PCH1.U26 PCH1.V22 PCH1.V23 PCH1.V24 PCH1.W3 PCH1.W4 PCH1.W21 PCH1.Y1 PCH1.Y2 PMBUS1.1 PQ2.S PQ5.1 PQ5.2 PQ5.3 PQ6.1 PQ6.2 PQ6.3 PQ11.1 PQ11.4 PQ12.S PR10.1 PR11.2 PR12.1 PR13.2 PR14.1 PR15.2 PR17.2 PR24.1 PR25.2 PR26.1 PR27.2 PR28.1 PR29.2 PR31.2 PR57.2 PR58.2 PR61.2 PR62.2 PR74.2 PR81.2 PR89.2 PR95.2 PR98.2 PR100.2 PR108.2 PR115.2 PR165.2 PR171.2 PR186.2 PR187.2 PR190.2 PR192.2 PR195.2 PR197.2 PR204.2 PR208.2 PR217.2 PR220.2 PR232.2 PR234.2 PR249.2 PR256.2 PR258.1 PR264.2 PR321.2 PR322.2 PR325.2 PR330.2 PR348.2 PR349.2 PR354.2 PR360.2 PR377.2 PR384.2 PR386.2 PR387.2 PR388.2 PR389.2 PR390.2 PR391.2 PR398.2 PR413.2 PR414.2 PR415.2 PR416.2 PR417.2 PR418.2 PR425.2 PT3.2 PT5.2 PT6.2 PT7.2 PT8.2 PT11.2 PT12.2 PT14.2 PT15.2 PT16.2 PT17.2 PT18.2 PT19.2 PT20.2 PT21.2 PT25.2 PT27.2 PT28.2 PT29.2 PT30.2 PT32.2 PT33.2 PT35.2 PT38.2 PT39.2 PT41.2 PT42.2 PT43.2 PT44.2 PU3.21 PU4.1 PU4.2 PU4.3 PU5.1 PU5.2 PU5.3 PU6.49 PU9.1 PU9.2 PU9.3 PU10.1 PU10.2 PU10.3 PU13.1 PU13.2 PU13.3 PU14.1 PU14.2 PU14.3 PU17.1 PU17.2 PU17.3 PU18.1 PU18.2 PU18.3 PU21.4 PU21.9 PU22.1 PU22.2 PU22.3 PU23.1 PU23.2 PU23.3 PU26.4 PU26.9 PU27.1 PU27.2 PU27.3 PU28.1 PU28.2 PU28.3 PU29.1 PU29.3 PU29.14 PU29.21 PU32.4 PU32.12 PU32.13 PU32.14 PU32.15 PU32.19 PU33.7 PU33.8 PU33.18 PU33.21 PU34.7 PU34.8 PU34.18 PU34.21 PU35.13 PU37.1 PU38.2 PU38.9 PU39.49 PU40.5 PU40.16 PU40.17 PU40.18 PU40.19 PU40.20 PU40.21 PU40.22 PU40.23 PU40.24 PU40.25 PU40.26 PU40.27 PU40.28 PU40.37 PU40.41 PU41.5 PU41.16 PU41.17 PU41.18 PU41.19 PU41.20 PU41.21 PU41.22 PU41.23 PU41.24 PU41.25 PU41.26 PU41.27 PU41.28 PU41.37 PU41.41 PU42.5 PU42.16 PU42.17 PU42.18 PU42.19 PU42.20 PU42.21 PU42.22 PU42.23 PU42.24 PU42.25 PU42.26 PU42.27 PU42.28 PU42.37 PU42.41 PU43.5 PU43.16 PU43.17 PU43.18 PU43.19 PU43.20 PU43.21 PU43.22 PU43.23 PU43.24 PU43.25 PU43.26 PU43.27 PU43.28 PU43.37 PU43.41 PU44.5 PU44.16 PU44.17 PU44.18 PU44.19 PU44.20 PU44.21 PU44.22 PU44.23 PU44.24 PU44.25 PU44.26 PU44.27 PU44.28 PU44.37 PU44.41 PU45.5 PU45.16 PU45.17 PU45.18 PU45.19 PU45.20 PU45.21 PU45.22 PU45.23 PU45.24 PU45.25 PU45.26 PU45.27 PU45.28 PU45.37 PU45.41 PU46.5 PU46.16 PU46.17 PU46.18 PU46.19 PU46.20 PU46.21 PU46.22 PU46.23 PU46.24 PU46.25 PU46.26 PU46.27 PU46.28 PU46.37 PU46.41 PU47.7 PU47.8 PU47.18 PU47.21 PU48.1 PU48.2 PU48.3 PU48.7 PU48.14 PU48.20 PU48.21 PU51.1 PU52.1 PU52.4 PU53.1 PU55.1 PU56.1 PU58.1 PU58.2 PU58.3 Q8.C Q10.G Q16.S Q22.E Q23.E Q25.1 Q25.4 Q35.E Q37.S Q41.E Q42.E Q43.E Q44.E Q50.E Q53.S Q55.S Q67.G Q72.1 Q72.4 Q78.S Q81.1 Q81.4 Q83.S Q86.1 Q86.4 R3.2 R4.2 R5.2 R6.2 R12.1 R13.1 R16.2 R24.1 R25.1 R26.1 R33.2 R52.2 R53.1 R54.1 R55.2 R56.2 R57.2 R58.2 R59.2 R70.2 R85.1 R86.1 R90.1 R102.1 R103.1 R104.1 R108.1 R114.1 R115.1 R116.1 R118.1 R123.1 R125.1 R127.1 R132.1 R134.2 R135.1 R137.1 R138.1 R142.1 R144.1 R145.1 R147.1 R149.1 R151.1 R152.1 R169.1 R175.2 R243.2 R247.2 R260.1 R272.2 R274.2 R309.2 R310.1 R311.2 R312.1 R313.1 R314.1 R319.2 R320.1 R321.2 R322.1 R323.1 R324.1 R339.1 R340.2 R341.2 R350.2 R354.1 R355.2 R356.2 R360.2 R381.2 R382.2 R387.2 R392.2 R412.2 R415.2 R421.2 R443.2 R458.1 R464.2 R475.2 R476.2 R487.1 R490.2 R504.1 R506.1 R507.1 R509.1 R515.1 R517.1 R521.1 R522.2 R523.2 R524.1 R528.1 R531.1 R534.1 R536.1 R538.1 R542.2 R544.2 R546.2 R548.2 R550.2 R553.2 R559.1 R562.2 R604.2 R610.2 R612.2 R614.2 R615.2 R618.2 R621.2 R622.2 R623.2 R624.2 R627.2 R634.2 R635.2 R636.2 R637.2 R638.2 R640.2 R641.2 R642.2 R646.2 R647.2 R648.2 R663.2 R664.2 R667.2 R678.2 R679.2 R680.2 R681.2 R682.2 R683.2 R685.2 R686.2 R689.2 R690.2 R692.2 R707.2 R708.2 R711.2 R719.1 R720.2 R722.1 R723.1 R724.1 R1201.1 R1210.2 R1213.1 R1214.1 R1215.1 R1223.2 R1224.2 R2419.1 R2431.1 R2438.2 R2505.1 R2534.2 R2577.2 R2588.2 R2615.2 R2616.2 R2617.2 R2618.2 R2619.2 R2620.2 R2640.2 R2641.2 R2660.2 R2680.1 R2685.2 R2687.2 R2689.2 R2692.1 R2693.1 R2702.2 R2707.2 R2716.2 R2739.1 R2743.2 R2750.2 R2758.2 R2761.2 R2766.2 R2779.1 R2780.1 R2785.2 R2786.2 RN2413.1(A) RN2413.2(A) RPWRC1.2 RPWRC1.4 RPWRC1.5 RPWRC1.9 RPWRC1.13 RPWRC1.14 RPWRC1.15 RPWRC1.16 RPWRC1.17 RPWRC1.19 RPWRC1.23 RPWRC1.24 RPWRC1.31 RPWRC1.32 RUSBC1.2 RUSBC1.5 RUSBC1.8 RUSBC1.11 RUSBC1.14 RUSBC1.17 RUSBC1.20 RUSBC1.23 RUSBC1.26 RUSBC1.29 RUSBC1.30 RUSBC1.31 RUSBC1.32 RUSBC1.33 RUSBC1.34 RUSBC1.35 SATAP1.2 SATAP1.4 SDRDC1.2 SDRDC1.3 SDRDC1.6 SDRDC1.9 SDRDC1.10 SDRDC1.11 SDRDC1.12 SPK1.6 SPK1.7 SPK1.8 SPR1.1 SPR2.1 SRCON1.4 SSDC1.1 SSDC1.3 SSDC1.9 SSDC1.15 SSDC1.21 SSDC1.27 SSDC1.33 SSDC1.39 SSDC1.45 SSDC1.51 SSDC1.57 SSDC1.71 SSDC1.73 SSDC1.75 SSDC1.76 SSDC1.77 SUSBC1.1 SUSBC1.7 SUSBC1.8 SUSBC1.13 SUSBC1.14 SUSBC1.16 SUSBC1.25 SUSBC1.26 TC2.2 TC4.2 TC5.2 TC6.2 TOUCH1.2 TOUCH1.6 TOUCH1.7 TYPEC1.2 TYPEC1.5 TYPEC1.8 TYPEC1.11 TYPEC1.14 TYPEC1.17 TYPEC1.20 TYPEC1.23 TYPEC1.26 TYPEC1.29 TYPEC1.32 TYPEC1.35 TYPEC1.38 TYPEC1.40 TYPEC1.41 TYPEC1.42 TYPEC1.43 TYPEC1.44 TYPEC1.45 U2.5 U3.3 U4.4 U5.1 U6.57 U7.4 U7.19 U7.20 U7.24 U7.33 U7.34 U7.39 U7.45 U7.46 U7.53 U7.54 U7.57 U8.4 U8.19 U8.20 U8.24 U8.33 U8.34 U8.39 U8.45 U8.46 U8.53 U8.54 U8.57 U10.14 U10.17 U11.2 U12.14 U12.17 U13.2 U17.9 U20.1 U20.4 U21.3 U24.1 U24.2 U26.5 U26.11 U26.20 U26.21 U28.4 U29.6 U33.11 U33.15 U36.5 U38.2 U39.11 U39.15 U40.S U43.S U44.2 U45.4 U2505.4 U2506.4 U2506.9 UC1.2 UC2.2 VRAMA1.A1 VRAMA1.A3 VRAMA1.A12 VRAMA1.A14 VRAMA1.B5 VRAMA1.B10 VRAMA1.C1 VRAMA1.C3 VRAMA1.C4 VRAMA1.C11 VRAMA1.C12 VRAMA1.C14 VRAMA1.D10 VRAMA1.E1 VRAMA1.E3 VRAMA1.E12 VRAMA1.E14 VRAMA1.F5 VRAMA1.F10 VRAMA1.G5 VRAMA1.G10 VRAMA1.H1 VRAMA1.H2 VRAMA1.H13 VRAMA1.H14 VRAMA1.K1 VRAMA1.K2 VRAMA1.K13 VRAMA1.K14 VRAMA1.L5 VRAMA1.L10 VRAMA1.M5 VRAMA1.M10 VRAMA1.N1 VRAMA1.N3 VRAMA1.N12 VRAMA1.N14 VRAMA1.P10 VRAMA1.R1 VRAMA1.R3 VRAMA1.R4 VRAMA1.R11 VRAMA1.R12 VRAMA1.R14 VRAMA1.T5 VRAMA1.T10 VRAMA1.U1 VRAMA1.U3 VRAMA1.U12 VRAMA1.U14 VRAMA2.A1 VRAMA2.A3 VRAMA2.A12 VRAMA2.A14 VRAMA2.B5 VRAMA2.B10 VRAMA2.C1 VRAMA2.C3 VRAMA2.C4 VRAMA2.C11 VRAMA2.C12 VRAMA2.C14 VRAMA2.D10 VRAMA2.E1 VRAMA2.E3 VRAMA2.E12 VRAMA2.E14 VRAMA2.F5 VRAMA2.F10 VRAMA2.G5 VRAMA2.G10 VRAMA2.H1 VRAMA2.H2 VRAMA2.H13 VRAMA2.H14 VRAMA2.K1 VRAMA2.K2 VRAMA2.K13 VRAMA2.K14 VRAMA2.L5 VRAMA2.L10 VRAMA2.M5 VRAMA2.M10 VRAMA2.N1 VRAMA2.N3 VRAMA2.N12 VRAMA2.N14 VRAMA2.P10 VRAMA2.R1 VRAMA2.R3 VRAMA2.R4 VRAMA2.R11 VRAMA2.R12 VRAMA2.R14 VRAMA2.T5 VRAMA2.T10 VRAMA2.U1 VRAMA2.U3 VRAMA2.U12 VRAMA2.U14 VRAMB1.A1 VRAMB1.A3 VRAMB1.A12 VRAMB1.A14 VRAMB1.B5 VRAMB1.B10 VRAMB1.C1 VRAMB1.C3 VRAMB1.C4 VRAMB1.C11 VRAMB1.C12 VRAMB1.C14 VRAMB1.D10 VRAMB1.E1 VRAMB1.E3 VRAMB1.E12 VRAMB1.E14 VRAMB1.F5 VRAMB1.F10 VRAMB1.G5 VRAMB1.G10 VRAMB1.H1 VRAMB1.H2 VRAMB1.H13 VRAMB1.H14 VRAMB1.K1 VRAMB1.K2 VRAMB1.K13 VRAMB1.K14 VRAMB1.L5 VRAMB1.L10 VRAMB1.M5 VRAMB1.M10 VRAMB1.N1 VRAMB1.N3 VRAMB1.N12 VRAMB1.N14 VRAMB1.P10 VRAMB1.R1 VRAMB1.R3 VRAMB1.R4 VRAMB1.R11 VRAMB1.R12 VRAMB1.R14 VRAMB1.T5 VRAMB1.T10 VRAMB1.U1 VRAMB1.U3 VRAMB1.U12 VRAMB1.U14 VRAMB2.A1 VRAMB2.A3 VRAMB2.A12 VRAMB2.A14 VRAMB2.B5 VRAMB2.B10 VRAMB2.C1 VRAMB2.C3 VRAMB2.C4 VRAMB2.C11 VRAMB2.C12 VRAMB2.C14 VRAMB2.D10 VRAMB2.E1 VRAMB2.E3 VRAMB2.E12 VRAMB2.E14 VRAMB2.F5 VRAMB2.F10 VRAMB2.G5 VRAMB2.G10 VRAMB2.H1 VRAMB2.H2 VRAMB2.H13 VRAMB2.H14 VRAMB2.K1 VRAMB2.K2 VRAMB2.K13 VRAMB2.K14 VRAMB2.L5 VRAMB2.L10 VRAMB2.M5 VRAMB2.M10 VRAMB2.N1 VRAMB2.N3 VRAMB2.N12 VRAMB2.N14 VRAMB2.P10 VRAMB2.R1 VRAMB2.R3 VRAMB2.R4 VRAMB2.R11 VRAMB2.R12 VRAMB2.R14 VRAMB2.T5 VRAMB2.T10 VRAMB2.U1 VRAMB2.U3 VRAMB2.U12 VRAMB2.U14 VRAMC1.A1 VRAMC1.A3 VRAMC1.A12 VRAMC1.A14 VRAMC1.B5 VRAMC1.B10 VRAMC1.C1 VRAMC1.C3 VRAMC1.C4 VRAMC1.C11 VRAMC1.C12 VRAMC1.C14 VRAMC1.D10 VRAMC1.E1 VRAMC1.E3 VRAMC1.E12 VRAMC1.E14 VRAMC1.F5 VRAMC1.F10 VRAMC1.G5 VRAMC1.G10 VRAMC1.H1 VRAMC1.H2 VRAMC1.H13 VRAMC1.H14 VRAMC1.K1 VRAMC1.K2 VRAMC1.K13 VRAMC1.K14 VRAMC1.L5 VRAMC1.L10 VRAMC1.M5 VRAMC1.M10 VRAMC1.N1 VRAMC1.N3 VRAMC1.N12 VRAMC1.N14 VRAMC1.P10 VRAMC1.R1 VRAMC1.R3 VRAMC1.R4 VRAMC1.R11 VRAMC1.R12 VRAMC1.R14 VRAMC1.T5 VRAMC1.T10 VRAMC1.U1 VRAMC1.U3 VRAMC1.U12 VRAMC1.U14 VRAMC2.A1 VRAMC2.A3 VRAMC2.A12 VRAMC2.A14 VRAMC2.B5 VRAMC2.B10 VRAMC2.C1 VRAMC2.C3 VRAMC2.C4 VRAMC2.C11 VRAMC2.C12 VRAMC2.C14 VRAMC2.D10 VRAMC2.E1 VRAMC2.E3 VRAMC2.E12 VRAMC2.E14 VRAMC2.F5 VRAMC2.F10 VRAMC2.G5 VRAMC2.G10 VRAMC2.H1 VRAMC2.H2 VRAMC2.H13 VRAMC2.H14 VRAMC2.K1 VRAMC2.K2 VRAMC2.K13 VRAMC2.K14 VRAMC2.L5 VRAMC2.L10 VRAMC2.M5 VRAMC2.M10 VRAMC2.N1 VRAMC2.N3 VRAMC2.N12 VRAMC2.N14 VRAMC2.P10 VRAMC2.R1 VRAMC2.R3 VRAMC2.R4 VRAMC2.R11 VRAMC2.R12 VRAMC2.R14 VRAMC2.T5 VRAMC2.T10 VRAMC2.U1 VRAMC2.U3 VRAMC2.U12 VRAMC2.U14 VRAMD1.A1 VRAMD1.A3 VRAMD1.A12 VRAMD1.A14 VRAMD1.B5 VRAMD1.B10 VRAMD1.C1 VRAMD1.C3 VRAMD1.C4 VRAMD1.C11 VRAMD1.C12 VRAMD1.C14 VRAMD1.D10 VRAMD1.E1 VRAMD1.E3 VRAMD1.E12 VRAMD1.E14 VRAMD1.F5 VRAMD1.F10 VRAMD1.G5 VRAMD1.G10 VRAMD1.H1 VRAMD1.H2 VRAMD1.H13 VRAMD1.H14 VRAMD1.K1 VRAMD1.K2 VRAMD1.K13 VRAMD1.K14 VRAMD1.L5 VRAMD1.L10 VRAMD1.M5 VRAMD1.M10 VRAMD1.N1 VRAMD1.N3 VRAMD1.N12 VRAMD1.N14 VRAMD1.P10 VRAMD1.R1 VRAMD1.R3 VRAMD1.R4 VRAMD1.R11 VRAMD1.R12 VRAMD1.R14 VRAMD1.T5 VRAMD1.T10 VRAMD1.U1 VRAMD1.U3 VRAMD1.U12 VRAMD1.U14 VRAMD2.A1 VRAMD2.A3 VRAMD2.A12 VRAMD2.A14 VRAMD2.B5 VRAMD2.B10 VRAMD2.C1 VRAMD2.C3 VRAMD2.C4 VRAMD2.C11 VRAMD2.C12 VRAMD2.C14 VRAMD2.D10 VRAMD2.E1 VRAMD2.E3 VRAMD2.E12 VRAMD2.E14 VRAMD2.F5 VRAMD2.F10 VRAMD2.G5 VRAMD2.G10 VRAMD2.H1 VRAMD2.H2 VRAMD2.H13 VRAMD2.H14 VRAMD2.K1 VRAMD2.K2 VRAMD2.K13 VRAMD2.K14 VRAMD2.L5 VRAMD2.L10 VRAMD2.M5 VRAMD2.M10 VRAMD2.N1 VRAMD2.N3 VRAMD2.N12 VRAMD2.N14 VRAMD2.P10 VRAMD2.R1 VRAMD2.R3 VRAMD2.R4 VRAMD2.R11 VRAMD2.R12 VRAMD2.R14 VRAMD2.T5 VRAMD2.T10 VRAMD2.U1 VRAMD2.U3 VRAMD2.U12 VRAMD2.U14 WEBCM1.5 WEBCM1.6 WEBCM1.7 WEBCM1.9 WEBCM1.15 WEBCM1.16 WEBCM1.17 WLAN1.1 WLAN1.7 WLAN1.18 WLAN1.23 WLAN1.24 WLAN1.29 WLAN1.30 WLAN1.33 WLAN1.36 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 WOOFC1.1 WOOFC1.7 WOOFC1.8 X2.2 X2.4 X3.2 X3.4
VBAT1: BT1.1 R246.1
VBAT1_R: D4.2 Q16.G R246.2 R247.1 R2669.1 TP32.1
VBAT_SB_N: C298.1 R248.1 U5.2
VCC3_CAM: C434.1 C435.1 C436.1 F2.2 R365.2 WEBCM1.12
VDDIO_AUDIO: C1081.1 CPU1.AM15 R2613.1 R2614.1
VDDNB_SN1: PC171.1 PR149.2
VDDP_S5_PG: PR333.2 PR334.2 PR355.2 R2537.2
VDDP_S5_PG_EC: KBC1.61 R2537.1
VDDQ_BLEED_R1: Q25.6 R400.2
VDDQ_BLEED_R2: Q25.2 Q25.3 R399.2
0D6V_S0: C166.1 C167.1 C193.1 C194.1 DIMM1.258 DIMM2.258 PG80.1 PG82.1
0D8V_PG: PR326.1 TP120.1
0D8V_VGA: C608.1 C609.1 C610.1 C611.1 C616.1 C617.1 C618.1 C619.1 C622.1 GPU1.AA34 GPU1.AA35 GPU1.AD36 GPU1.AE35 GPU1.AF35 GPU1.AG36 GPU1.AJ30 GPU1.AJ35 GPU1.AK35 GPU1.AM36 GPU1.AN35 PG192.2 PG193.2 PG195.2 PG196.2 R718.1
0D775V_S5: PG153.2 R870.1 R871.1 R2605.1
0D775V_VDDCR_SOC_S5: C135.1 C453.1 C454.1 C455.1 CPU1.AJ18 CPU1.AK18 PC62.1 R377.2 R378.2 R870.2 R871.2 R2785.1 U17.7 U17.8
1D2V_MEM_S3: C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 C134.1 C147.1 C148.1 C149.1 C150.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C163.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 CPU1.AA28 CPU1.AA34 CPU1.AA37 CPU1.AB27 CPU1.AB29 CPU1.AB31 CPU1.AB32 CPU1.AB33 CPU1.AB36 CPU1.AB39 CPU1.AC28 CPU1.AC30 CPU1.AC32 CPU1.AC35 CPU1.AC38 CPU1.AD27 CPU1.AD29 CPU1.AD31 CPU1.AD34 CPU1.AD37 CPU1.AE28 CPU1.AE30 CPU1.AE33 CPU1.AE36 CPU1.AE39 CPU1.AF27 CPU1.AF29 CPU1.AF32 CPU1.AF35 CPU1.AF38 CPU1.AG33 CPU1.AG34 CPU1.AG35 CPU1.AG37 CPU1.AH39 CPU1.K36 CPU1.K39 CPU1.L32 CPU1.L35 CPU1.L38 CPU1.M29 CPU1.M31 CPU1.M34 CPU1.M37 CPU1.N28 CPU1.N30 CPU1.N33 CPU1.N36 CPU1.N39 CPU1.P27 CPU1.P29 CPU1.P32 CPU1.P35 CPU1.P38 CPU1.R28 CPU1.R31 CPU1.R34 CPU1.R37 CPU1.T27 CPU1.T29 CPU1.T33 CPU1.T36 CPU1.T39 CPU1.U28 CPU1.U30 CPU1.U32 CPU1.U35 CPU1.U38 CPU1.V27 CPU1.V29 CPU1.V31 CPU1.V34 CPU1.V37 CPU1.W28 CPU1.W33 CPU1.W34 CPU1.W36 CPU1.W39 CPU1.Y27 CPU1.Y29 CPU1.Y31 CPU1.Y32 CPU1.Y35 CPU1.Y38 DIMM1.111 DIMM1.112 DIMM1.117 DIMM1.118 DIMM1.123 DIMM1.124 DIMM1.129 DIMM1.130 DIMM1.135 DIMM1.136 DIMM1.141 DIMM1.142 DIMM1.147 DIMM1.148 DIMM1.153 DIMM1.154 DIMM1.159 DIMM1.160 DIMM1.163 DIMM2.111 DIMM2.112 DIMM2.117 DIMM2.118 DIMM2.123 DIMM2.124 DIMM2.129 DIMM2.130 DIMM2.135 DIMM2.136 DIMM2.141 DIMM2.142 DIMM2.147 DIMM2.148 DIMM2.153 DIMM2.154 DIMM2.159 DIMM2.160 DIMM2.163 PC50.1 PC51.1 PC52.1 PC53.1 PC54.1 PC55.1 PC56.1 PC57.1 PC58.1 PC59.1 PC60.1 PC61.1 PG65.2 PG67.2 PG68.2 PG69.2 PG70.2 PG71.2 PG73.2 PG75.2 PG76.2 PG78.2 PG79.2 PG81.2 PG83.2 PG84.2 PG85.2 PG86.2 PG87.2 R8.1 R10.1 R11.1 R14.1 R107.1 R109.1 R110.1 R117.1 R119.1 R120.1 R400.1 R2499.1 RN2416.1(A) RN2416.2(A)
1D5V_DVDD_IO_S5: C310.1 C311.1 L6.1 R269.1 R2581.1 U6.19
1D05V_PCH_S0: C217.1 C218.1 C219.1 C220.1 C221.1 C222.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C247.1 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C260.1 C261.1 L4.1 L5.1 PCH1.H15 PCH1.H17 PCH1.J11 PCH1.K8 PCH1.K9 PCH1.K13 PCH1.K14 PCH1.K17 PCH1.L8 PCH1.L17 PCH1.M17 PCH1.N17 PCH1.P7 PCH1.P8 PCH1.P17 PCH1.R1 PCH1.R2 PCH1.R3 PCH1.R4 PCH1.R5 PCH1.R6 PCH1.R7 PCH1.R8 PCH1.R17 PCH1.T1 PCH1.T2 PCH1.T3 PCH1.T4 PCH1.T5 PCH1.T6 PCH1.T7 PCH1.T8 PCH1.T17 PCH1.U1 PCH1.U2 PCH1.U3 PCH1.U4 PCH1.U5 PCH1.U6 PCH1.U7 PCH1.U8 PCH1.U17 PCH1.V9 PCH1.V10 PCH1.V11 PCH1.V14 PCH1.V15 PCH1.V16 PCH1.V20 PCH1.V21 PCH1.W11 PCH1.W13 PCH1.W16
1D05V_PCH_S0_CT1: C999.1 U39.12
1D05V_PCH_S0_EN: C997.1 R2411.2 U39.3
1D05V_PCH_S0_L: C1000.1 C1001.1 L4.2 L5.2 U39.13 U39.14
1D05V_PCH_S5: C262.1 C263.1 C264.1 C996.1 PCH1.V7 PCH1.W15 PG123.2 PG124.2 PG126.2 PG127.2 PG129.2 U39.1 U39.2
1D05V_PCH_S5_PG: PR336.1 R2474.2
1D05V_PCH_S5_PG_EC: KBC1.58 R2474.1
1D05V_S0: C974.1 C975.1 C1073.1 C1074.1 CPU1.AM18 CPU1.AM19 CPU1.AM20 CPU1.AN18 CPU1.AN19 CPU1.AN20 CPU1.AP18 CPU1.AP19 CPU1.AP20 PC63.1 PC64.1 R1.1 R2.1 U36.6 U36.7 U36.8
1D05V_S0_EN: C971.1 R1217.2 U36.4
1D05V_S5: C138.1 C139.1 C970.1 CPU1.AJ16 CPU1.AJ17 PG107.2 PG108.2 PG111.2 PG113.2 PG114.2 PG115.2 PG116.2 PG117.2 PG118.2 PG119.2 R84.1 R377.1 R378.1 R2606.1 U36.1 U36.2 U36.9
1D5V_S5: L6.2 PG151.2 PG152.2 R2613.2
1D5V_S5_PG: PR214.1 TP119.1
1D05V_S5_PWRGD: PR347.2 R486.1
1D5V_VDDBT_RTC: C141.1 C142.1 C299.1 CPU1.AL15 G1.1 Q37.D R248.2 R2770.2
1D8V_HDT: C2513.1 HDT1.1 HDT1.19 Q80.S Q82.S R20.1 R2758.1 R2778.2 R2784.2 RN2.1(A) RN2.2(A) RN2.3(A) RN2.4(A)
1D8V_KBC: R2671.1 R2729.2 RN2406.1(A) RN2406.2(A) U45.8
1D8V_S0: C143.1 C144.1 C316.1 C317.1 C383.1 C384.1 C417.1 C418.1 C982.1 C983.1 CPU1.AJ20 CPU1.AK20 PC127.1 PR90.1 PR396.1 Q1.G Q71.G Q75.2 Q75.5 Q77.G Q80.D Q87.D R16.1 R18.1 R19.1 R22.1 R32.1 R83.2 R273.2 R316.2 R326.2 R1228.1 R1229.1 R2411.1 R2633.2 R2707.1 R2728.1 R2739.2 R2743.1 R2744.2 R2778.1 RN1.1(A) RN1.2(A) U6.24 U7.17 U8.17 U39.8 U39.9
1D8V_S0_CT2: C979.1 U39.10
1D8V_S0_EN: C977.1 R1218.2 U39.5
1D8V_S5: C140.1 C976.1 CPU1.AJ15 CPU1.AK15 PC65.1 PG134.2 PG135.2 PG137.2 PG138.2 PG141.2 PG142.2 PG150.2 PG154.2 PG215.2 PR215.1 Q82.D Q84.D Q88.D R244.1 R368.1 R1235.1 R2412.1 R2581.2 R2614.2 R2729.1 R2784.1 U39.6 U39.7
1D8V_S5_PG: PR210.1 PR218.2 PR337.1 PR339.1 PR362.1
1D8V_SPI: C297.1 C2517.1 Q87.S Q88.S R244.2 R2663.1 R2728.2 R2766.1 RN16.1(A) RN16.2(A) SRCON1.8 U4.8
1D8V_SPI_EN: Q86.2 Q86.3 R2765.2
1D8V_SPI_EN2: Q86.6 Q87.G R2763.2 R2764.2
1D8V_SPI_EN3: C2516.1 Q88.G R2764.1
1D8V_VGA: C593.1 C601.1 C602.1 C2515.1 GPU1.AM25 GPU1.AN25 GPU1.AN26 GPU1.AP26 GPU1.AP27 GPU1.AR27 L27.1 L28.1 PC276.1 PC409.1 PG222.2 PG223.2 PR228.1 PR229.1 PR230.1 PR239.2 PR344.1 R484.2 R489.2 R511.1 R512.1 R541.2 R543.2 R545.2 R547.2 R549.2 R551.1 R560.1 R2776.1 R2777.1
1D8V_VGA_PG: PC502.1 PR232.1 PR235.2 PR320.1 PR378.2 PR393.2 PR404.2 R492.2 R1196.2
