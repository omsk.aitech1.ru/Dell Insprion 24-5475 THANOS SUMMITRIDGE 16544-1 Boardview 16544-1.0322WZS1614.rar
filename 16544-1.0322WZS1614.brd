# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WCKB0B_1: length 29.7
  TOP w0.122: GPU1.B21 68.88,198.32 68.88,198.79 69.15,199.06 69.34,199.25 69.34,208.68 69.43,208.77 69.43,212.23 70.1,212.9 70.1,214.27 69.98,214.4 69.98,214.76 70.1,214.89 70.1,215.25 69.98,215.38 69.98,215.74 70.1,215.87 70.1,220.78 69.98,220.9 69.98,221.27 70.1,221.39 70.1,221.76 69.98,221.88 69.98,222.25 70.1,222.37 70.1,222.74 69.98,222.87 69.98,223.23 70.1,223.36 70.1,223.72 69.19,224.64 68.11,224.64 VRAMB1.D5
WCKB1_0: length 29
  TOP w0.122: GPU1.F12 v6(60.4,194.65) ; VRAMB2.D4 v6(54.7,216.1)
  L6 w0.089: v6(54.7,216.1) 54.08,216.5 53.36,216.5
  L6 w0.11: v6(60.4,194.65) 60.68,194.37 60.79,194.37 60.9,194.48 60.9,195.88 60.48,196.3 60.48,200.2 52.91,207.77 52.91,216.05 53.36,216.5
WCKB1_1: length 30.8
  TOP w0.122: VRAMB2.P4 53.62,224.84 53.01,224.84 51.46,223.3 51.46,213.33 53.42,211.38 53.42,207.14 56.19,204.36 56.19,203.56 57.68,202.07 57.68,198.98 GPU1.A8
WCKB1B_0: length 29.3
  TOP w0.122: VRAMB2.D5 53.72,216.5 53.9,216.32 v6(53.9,216.1) ; GPU1.G12 61,193.58 60.73,193.85 v6(60.4,193.85)
  L6 w0.11: v6(53.9,216.1) 53.79,216.21 53.74,216.26 53.45,216.26 53.14,215.95 53.14,215.62 53.26,215.5 53.26,215.17 53.14,215.05 53.14,214.72 53.26,214.6 53.26,214.27 53.14,214.15 53.14,213.82 53.26,213.71 53.26,213.38 53.14,213.26 53.14,207.87 53.37,207.64 53.54,207.64 53.78,207.4 53.78,207.23 54.01,207 54.18,207 54.41,206.77 54.41,206.6 54.64,206.37 54.81,206.37 55.05,206.13 55.05,205.96 58.64,202.37 58.81,202.37 59.04,202.14 59.04,201.97 59.27,201.74 59.44,201.74 59.68,201.5 59.68,201.33 59.91,201.1 60.08,201.1 60.31,200.87 60.31,200.7 60.72,200.29 60.72,196.39 61.14,195.97 61.14,194.38 60.89,194.13 60.68,194.13 v6(60.4,193.85)
WCKB1B_1: length 31.5
  TOP w0.122: GPU1.B9 57.93,198.47 57.93,202.17 56.44,203.66 56.44,204.47 53.67,207.24 53.67,211.48 51.71,213.43 51.71,214.33 51.84,214.45 51.84,214.82 51.71,214.95 51.71,215.31 51.84,215.44 51.84,215.8 51.71,215.93 51.71,216.29 51.84,216.42 51.84,216.78 51.71,216.91 51.71,217.28 51.84,217.4 51.84,217.77 51.71,217.89 51.71,218.26 51.84,218.38 51.84,218.75 51.71,218.88 51.71,219.24 51.84,219.37 51.84,219.73 51.71,219.86 51.71,220.24 51.84,220.37 51.84,220.74 51.71,220.86 51.71,221.23 51.84,221.35 51.84,221.72 51.71,221.84 51.71,222.21 51.84,222.33 51.84,222.7 51.71,222.83 51.71,223.19 53.02,224.5 VRAMB2.P5
WCKC0_0: length 31
  TOP w0.122: GPU1.H1 50.92,192.22 47.22,192.22 42.86,196.58 38.6,196.58 36.66,198.53 26.65,198.53 25.12,197 25.12,196.49 VRAMC1.D4
WCKC0_1: length 29.1
  TOP w0.122: GPU1.M6 v6(55.35,189.6) ; VRAMC1.P4 v6(33.9,195.3)
  L6 w0.089: 33.5,196.52 33.5,196.52 33.5,195.99 v6(33.9,195.3)
  L6 w0.11: 33.5,196.52 33.5,196.53 33.5,196.7 34.06,197.26 42.77,197.26 50.51,189.52 53.61,189.52 54.03,189.1 55.52,189.1 55.63,189.21 55.63,189.32 v6(55.35,189.6)
WCKC0B_0: length 31.6
  TOP w0.122: VRAMC1.D5 25.37,196.63 25.37,196.9 26.75,198.28 27.12,198.28 27.24,198.15 27.61,198.15 27.73,198.28 28.1,198.28 28.22,198.15 28.59,198.15 28.72,198.28 29.08,198.28 29.21,198.15 29.57,198.15 29.7,198.28 31.76,198.28 31.89,198.15 32.25,198.15 32.38,198.28 32.74,198.28 32.87,198.15 33.24,198.15 33.36,198.28 33.73,198.28 33.85,198.15 34.22,198.15 34.34,198.28 34.71,198.28 34.84,198.15 35.2,198.15 35.33,198.28 36.56,198.28 36.82,198.02 36.82,197.84 37.08,197.58 37.25,197.58 37.51,197.32 37.51,197.15 37.77,196.89 37.95,196.89 38.5,196.33 42.76,196.33 47.12,191.97 51.63,191.97 GPU1.J2
WCKC0B_1: length 29.4
  TOP w0.122: GPU1.M7 56.41,189 56.15,189.26 v6(56.15,189.6) ; v6(33.9,196.1) 33.69,196.1 33.5,196.29 VRAMC1.P5
  L6 w0.11: v6(33.9,196.1) 33.76,196.24 33.76,196.62 34.16,197.03 34.49,197.03 34.61,196.91 34.94,196.91 35.06,197.03 35.39,197.03 35.51,196.91 35.84,196.91 35.96,197.03 36.29,197.03 36.41,196.91 36.74,196.91 36.86,197.03 37.19,197.03 37.31,196.91 37.64,196.91 37.76,197.03 38.09,197.03 38.21,196.91 38.54,196.91 38.66,197.03 38.99,197.03 39.11,196.91 39.44,196.91 39.55,197.03 39.88,197.03 40,196.91 40.33,196.91 40.45,197.03 40.78,197.03 40.9,196.91 41.23,196.91 41.35,197.03 41.68,197.03 41.8,196.91 42.13,196.91 42.25,197.03 42.67,197.03 50.42,189.28 53.52,189.28 53.94,188.86 55.62,188.86 55.87,189.11 55.87,189.32 v6(56.15,189.6)
WCKC1_0: length 29.3
  TOP w0.122: VRAMC2.P4 25.1,181.99 25.1,181.99 25.1,180.62 26.07,179.66 37.34,179.66 38.1,180.42 50.86,180.42 50.99,180.55 51.04,180.6 GPU1.AA1
WCKC1_1: length 26.1
  TOP w0.122: GPU1.AA7 v6(56.15,181.2) ; v6(33.9,183.2) VRAMC2.D4
  L6 w0.089: v6(33.9,183.2) 33.9,182.97 34.3,182.57 34.3,182.14
  L6 w0.11: v6(56.15,181.2) 56.15,180.68 55.94,180.47 51.73,180.47 51.59,180.61 45.06,180.61 44.93,180.74 34.95,180.74 34.3,181.4 34.3,182.14
WCKC1B_0: length 29.7
  TOP w0.122: GPU1.AA2 51.7,181.1 51.19,181.1 50.76,180.67 38,180.67 37.24,179.91 35.56,179.91 35.44,180.03 35.07,180.03 34.94,179.91 34.58,179.91 34.45,180.03 34.09,180.03 33.96,179.91 29.12,179.91 28.99,180.03 28.63,180.03 28.5,179.91 28.13,179.91 28.01,180.03 27.64,180.03 27.52,179.91 27.15,179.91 27.03,180.03 26.66,180.03 26.53,179.91 26.17,179.91 25.35,180.73 25.35,181.85 VRAMC2.P5
WCKC1B_1: length 26.5
  TOP w0.122: GPU1.AA8 57.19,180.6 56.95,180.84 v6(56.95,181.2) ; VRAMC2.D5 v6(33.9,182.4)
  L6 w0.11: v6(56.95,181.2) 56.82,181.2 56.38,180.77 56.38,180.59 56.03,180.24 51.64,180.24 51.5,180.38 44.96,180.38 44.83,180.51 34.86,180.51 34.07,181.3 34.07,182.23 v6(33.9,182.4)
WCKD0_0: length 28
  TOP w0.122: GPU1.AK4 v6(53.55,171.6) ; v6(33.9,158.3) VRAMD1.P4
  L6 w0.11: v6(33.9,158.3) 33.49,158.71 33.49,159.24 33.5,159.25 33.5,159.84 35.36,161.7 39.4,161.7 48.23,170.53 48.37,170.67 52.41,170.67 53.15,171.41 53.36,171.41 v6(53.55,171.6)
WCKD0_1: length 32.6
  TOP w0.122: GPU1.AN2 51.74,169.34 48.11,169.34 42.24,163.47 39.16,163.47 37.2,161.51 26.57,161.51 25.13,160.08 25.13,159.46 VRAMD1.D4
WCKD0B_0: length 28.4
  TOP w0.122: v6(54.45,171.6) 54.45,171.75 GPU1.AK5 ; VRAMD1.P5 v6(33.9,159.1)
  L6 w0.11: v6(54.45,171.6) 54.03,171.18 53.24,171.18 52.51,170.44 50.26,170.44 50.14,170.32 49.81,170.32 49.69,170.44 49.36,170.44 49.25,170.32 48.92,170.32 48.8,170.44 48.47,170.44 39.5,161.47 39.05,161.47 38.93,161.35 38.6,161.35 38.48,161.47 38.15,161.47 38.03,161.35 37.7,161.35 37.58,161.47 37.25,161.47 37.13,161.35 36.8,161.35 36.68,161.47 35.46,161.47 35,161.01 35,160.84 34.77,160.61 34.6,160.61 34.37,160.38 34.37,160.21 34.13,159.98 33.96,159.98 33.73,159.74 33.73,159.27 v6(33.9,159.1)
WCKD0B_1: length 32.9
  TOP w0.122: VRAMD1.D5 25.38,159.62 25.38,159.98 26.67,161.26 27.04,161.26 27.16,161.14 27.53,161.14 27.65,161.26 28.02,161.26 28.14,161.14 28.51,161.14 28.63,161.26 29,161.26 29.13,161.14 29.49,161.14 29.62,161.26 33.81,161.26 33.93,161.14 34.3,161.14 34.43,161.26 34.79,161.26 34.92,161.14 35.28,161.14 35.41,161.26 35.77,161.26 35.9,161.14 36.26,161.14 36.39,161.26 37.31,161.26 39.27,163.22 42.35,163.22 48.21,169.09 51.84,169.09 52.12,169.37 52.67,169.37 GPU1.AN3
WCKD1_0: length 18.1
  TOP w0.122: VRAMD2.D4 v6(52.8,151.9) ; GPU1.AW11 v6(59.2,164.45)
  L6 w0.089: 53.9,151.5 53.43,151.5 53.03,151.9 v6(52.8,151.9)
  L6 w0.11: v6(59.2,164.45) 58.71,163.96 58.71,159.7 55.38,156.37 55.38,152.35 54.52,151.5 53.9,151.5 53.9,151.5
WCKD1_1: length 23.3
  TOP w0.122: VRAMD2.P4 54,143.1 55.5,143.1 56.3,143.9 56.3,154.85 59.33,157.88 59.33,161.74 59.79,162.2 GPU1.BB11
WCKD1B_0: length 18.4
  TOP w0.122: GPU1.AV11 59.35,165.35 v6(59.2,165.35) ; VRAMD2.D5 v6(53.6,151.9)
  L6 w0.11: v6(59.2,165.35) 58.74,164.89 58.74,164.32 58.48,164.06 58.48,159.8 57.05,158.37 56.88,158.37 56.65,158.14 56.65,157.97 56.41,157.73 56.25,157.73 56.01,157.5 56.01,157.33 55.78,157.1 55.61,157.1 55.38,156.86 55.38,156.7 55.14,156.46 55.14,155.15 55.02,155.03 55.02,154.7 55.14,154.58 55.14,154.25 55.02,154.13 55.02,153.8 55.14,153.68 55.14,153.35 55.02,153.23 55.02,152.9 55.14,152.78 55.14,152.45 54.42,151.73 53.77,151.73 v6(53.6,151.9)
WCKD1B_1: length 23.7
  TOP w0.122: GPU1.BA11 59.8,163.1 59.36,162.66 59.36,162.13 59.08,161.85 59.08,157.98 56.05,154.95 56.05,154.13 55.92,154.01 55.92,153.64 56.05,153.51 56.05,153.15 55.92,153.02 55.92,152.66 56.05,152.53 56.05,152.17 55.92,152.04 55.92,151.68 56.05,151.55 56.05,147.82 55.92,147.7 55.92,147.33 56.05,147.21 56.05,146.84 55.92,146.72 55.92,146.35 56.05,146.22 56.05,145.86 55.92,145.73 55.92,145.37 56.05,145.24 56.05,144 55.4,143.35 54.15,143.35 VRAMD2.P5
WEA0B: length 32
  TOP w0.13: v6(81.45,184.8) 81,184.35 GPU1.V34 ; v6(101.3,190) VRAMA1.L12
  BOTTOM w0.13: v6(101.3,190) 101.3,189.18 100.78,188.66 100.78,188.18 100.92,188.04 100.92,186.16 100.7,185.94 100.34,185.94 100.16,186.12 100.16,186.54 99.96,186.74 99.55,186.74 99.42,186.61 99.42,186.09 99.29,185.96 99.02,185.96 98.89,186.09 98.89,186.61 98.76,186.74 98.49,186.74 98.36,186.61 98.36,186.09 98.23,185.96 97.96,185.96 97.83,186.09 97.83,186.61 97.7,186.74 97.43,186.74 97.3,186.61 97.3,186.09 97.17,185.96 96.9,185.96 96.77,186.09 96.77,186.61 96.64,186.74 96.37,186.74 96.24,186.61 96.24,185.93 96.11,185.8 95.84,185.8 95.71,185.93 95.71,186.39 95.58,186.52 94.57,186.52 92.68,184.62 88.6,184.62 88.06,184.08 82.17,184.08 v6(81.45,184.8)
WEA1B: length 40.3
  TOP w0.13: VRAMA2.G12 v6(84.5,218.5) ; GPU1.H30 77.95,192.6 v6(78.4,193.05)
  BOTTOM w0.089: 78.66,197.84 78.8,197.7 78.8,193.45 v6(78.4,193.05)
  BOTTOM w0.13: 78.66,197.84 77.99,198.51 77.99,205.18 78.52,205.71 78.52,205.89 78.22,206.2 78.22,206.38 78.41,206.57 78.59,206.57 78.9,206.27 79.08,206.27 79.27,206.46 79.27,206.64 78.97,206.94 78.97,207.13 79.16,207.32 79.34,207.32 79.65,207.02 79.83,207.02 80.02,207.21 80.02,207.39 79.72,207.69 79.72,207.88 79.91,208.07 80.09,208.07 80.4,207.77 80.58,207.77 80.77,207.96 80.77,208.14 80.47,208.44 80.47,208.63 80.66,208.82 80.84,208.82 81.14,208.52 81.33,208.52 81.52,208.71 81.52,208.89 81.22,209.19 81.22,209.38 81.41,209.57 81.59,209.57 81.89,209.27 82.08,209.27 82.46,209.64 83.4,209.64 83.94,210.19 83.94,211.46 83.08,212.32 81.68,212.32 81.38,212.62 81.38,217.88 82,218.5 v6(84.5,218.5)
WEB0B: length 38
  TOP w0.13: VRAMB1.L12 73.97,219.3 v6(74,219.3) ; v6(73.6,192.25) 73.45,192.25 GPU1.J25
  BOTTOM w0.089: v6(73.6,192.25) 73.2,192.65 73.2,196.76 73.44,197
  BOTTOM w0.13: v6(74,219.3) 74.9,219.3 75.42,218.78 76.75,218.78 77.52,218.01 77.52,213.16 76.81,212.45 75.33,212.45 75.2,212.32 75.2,212.07 75.35,211.92 76.81,211.92 76.94,211.79 76.94,211.53 76.74,211.33 75.33,211.33 75.18,211.18 75.18,210.95 75.33,210.8 75.74,210.8 75.87,210.67 75.87,210.46 74.78,209.37 74.68,209.37 73.84,208.53 73.84,198.59 73.44,198.19 73.44,197
WEB1B: length 40.8
  TOP w0.13: VRAMB2.G12 v6(47.5,218.5) ; v6(62.8,189.85) 62.95,189.85 GPU1.M15
  BOTTOM w0.089: 61.69,197.85 62,197.54 62,190.65 v6(62.8,189.85)
  BOTTOM w0.13: 61.69,197.85 60.28,199.26 60.28,199.59 59.99,199.88 59.51,199.88 49.4,209.99 49.39,209.99 49.06,210.33 49.06,210.33 47.3,212.09 47.06,212.09 44.5,214.64 44.5,218.13 44.87,218.5 v6(47.5,218.5)
WEBCAM_DET: length 201.6
  TOP w0.114: KBC1.34 104.45,44.22 105.28,43.38 PC67.2 R367.2 104.27,42.95 v1(104.44,43.13) ; v1(228.1,50.18) WEBCM1.1
  L4 w0.114: v1(228.1,50.18) 228.12,50.2 228.12,50.9 218.69,60.33 218.69,65.48 217.3,66.88 216.57,66.88 216.56,66.88 213.01,66.88 212.02,67.88 203.69,67.88 202.51,66.7 202.51,65.76 201.98,65.23 199.72,65.23 198.68,66.27 193.95,66.27 v1(193.04,67.18) ; v1(173.88,16.91) 171.33,16.91 169.71,18.53 169.71,19.22 165.35,23.58 157.05,23.58 156.51,23.04 v1(153.67,23.04)
  L6 w0.102: v1(193.04,67.18) 193.04,65.66 190.2,62.81 190.2,59.74 187.73,57.28 187.73,43.01 189.18,41.57 189.18,34.15 175.63,20.6 174.96,20.6 174.14,19.78 174.14,18.08 173.88,17.81 v1(173.88,16.91) ; v1(153.67,23.04) 153.47,23.04 152.55,23.95 152.55,26.82 150.67,28.7 150.67,28.91 150.19,29.39 150.19,29.44 149.5,30.12 148.92,30.12 148.59,30.45 145.3,30.45 141.12,34.63 141.12,37.19 140.08,38.23 139.57,38.23 133.58,44.22 112.37,44.22 112.22,44.37 105.69,44.37 v1(104.44,43.13)
  BOTTOM w0.114: v2(192.46,66.6) v1(193.04,67.18)
WEC0B: length 40.7
  TOP w0.13: v6(60.15,187.2) 60.15,187.05 GPU1.R12 ; v6(31.5,202.5) VRAMC1.L12
  BOTTOM w0.089: v6(60.15,187.2) 59.8,187.55 59.64,187.55 59.19,188 52.21,188 52.05,188.16
  BOTTOM w0.13: 52.05,188.16 51.69,188.52 51.69,188.53 50.49,189.72 50.39,189.72 50.12,189.99 50.12,190.49 40.06,200.55 40.06,200.56 39.72,200.89 39.72,200.89 35.9,204.71 35.9,204.89 35.29,205.5 32,205.5 31.5,205 v6(31.5,202.5)
WEC1B: length 35.8
  TOP w0.13: v6(57.75,176.4) 58.2,176.85 GPU1.AE9 ; VRAMC2.G12 v6(30.7,176)
  BOTTOM w0.089: v6(57.75,176.4) 57.35,176.8 51.75,176.8 51.51,176.56
  BOTTOM w0.13: v6(30.7,176) 30.7,175.1 31.22,174.58 31.22,173.54 31.86,172.9 37.26,172.9 37.55,173.19 37.55,174.67 37.68,174.8 37.93,174.8 38.08,174.65 38.08,173.19 38.21,173.06 38.47,173.06 41.57,176.16 51.11,176.16 51.51,176.56
WED0B: length 38.3
  TOP w0.13: v6(56.95,171.6) 56.95,171.75 GPU1.AK8 ; VRAMD1.L12 v6(31.5,165.5)
  BOTTOM w0.089: v6(56.95,171.6) 56.55,171.2 52.3,171.2 52.16,171.34
  BOTTOM w0.13: v6(31.5,165.5) 31.5,168.41 31.71,168.62 37.38,168.62 37.68,168.32 37.68,166.92 38.54,166.06 39.81,166.06 40.36,166.6 40.36,167.52 41.66,168.82 41.66,169.01 41.36,169.3 41.36,169.48 41.64,169.76 41.82,169.76 42.12,169.47 42.3,169.47 42.58,169.74 42.58,169.93 42.28,170.22 42.28,170.4 42.56,170.68 42.74,170.68 43.04,170.39 43.22,170.39 43.5,170.66 43.5,170.85 43.2,171.14 43.2,171.32 43.48,171.6 43.66,171.6 43.96,171.31 44.14,171.31 44.85,172.01 51.49,172.01 51.88,171.62 52.16,171.34
WED1B: length 32
  TOP w0.13: GPU1.AP18 65.65,169 v6(65.2,168.55) ; VRAMD2.G12 v6(60,148.7)
  BOTTOM w0.089: 65.58,161.84 65.91,162.17 65.91,167.84 v6(65.2,168.55)
  BOTTOM w0.13: 65.58,161.84 65.58,156.79 63.48,154.7 63.48,154.42 63.61,154.29 64.07,154.29 64.2,154.16 64.2,153.89 64.07,153.76 63.39,153.76 63.26,153.63 63.26,153.36 63.39,153.23 63.91,153.23 64.04,153.1 64.04,152.83 63.91,152.7 63.39,152.7 63.26,152.57 63.26,152.3 63.39,152.17 63.91,152.17 64.04,152.04 64.04,151.77 63.91,151.64 63.39,151.64 63.26,151.51 63.26,151.24 63.39,151.11 63.91,151.11 64.04,150.98 64.04,150.71 63.91,150.58 63.39,150.58 63.26,150.45 63.26,150.04 63.46,149.84 63.88,149.84 64.06,149.66 64.06,149.3 63.84,149.08 61.96,149.08 61.82,149.22 61.34,149.22 61.05,148.93 60.23,148.93 v6(60,148.7)
WOOF_ASEL_1: length 4.8
  TOP w0.114: PR30.2 v3(198.04,31.75) 197.55,31.26 PR31.1 197,30.81 197.36,30.45 197.36,30.07 197.16,29.87 U8.18
WOOF_AVDD2_1: length 1.2
  TOP w0.203: v1(196.06,30.23) 195.96,30.12 U8.21
  vias: v2(195.61,30.96)
WOOF_BST_A1: length 10
  TOP w0.114: U8.2 199.96,23.4 200.86,22.5 201.9,22.5 v1(202.29,22.89)
  L3 w0.114: v1(202.29,22.89) 202.79,22.38 v1(202.79,19.18)
  BOTTOM w0.114: C395.1 202.54,19.43 v1(202.79,19.18) ; v2(203.25,22.71) 203.07,22.89 v1(202.29,22.89)
WOOF_BST_B1: length 7.2
  TOP w0.114: U8.50 195.96,20.32 v1(195.76,20.12)
  BOTTOM w0.114: C396.2 194.23,18.19 193.52,18.19 v2(193.37,18.34) 193.37,18.72 194.51,19.86 195.5,19.86 v1(195.76,20.12)
WOOF_BST_B_C1: length 4.5
  BOTTOM w0.114: R321.1 193.07,16.31 192.79,16.59 v2(192.79,17.02) 193.32,17.55 C393.2
WOOF_BST_C1: length 3.4
  TOP w0.114: C397.1 195.27,19.13 195.27,20.34 195.56,20.63 U8.49
WOOF_BST_C_C1: length 3.3
  TOP w0.114: R322.2 v3(196.29,16.03) 196.29,16.93 C394.1
WOOF_BST_D1: length 5.3
  TOP w0.114: C398.2 190.25,20.72 v3(190.25,21.08) 190.93,21.77 190.93,22.76 191.58,23.4 U8.41
WOOF_DET_C: length 192
  TOP w0.114: WOOFC1.6 202.5,7 204.39,8.89 R2598.1 205.96,7.89 v1(205.64,7.57) ; KBC1.27 103.74,48.94 103.98,49.19 v1(104.32,49.19)
  L3 w0.114: v1(169.25,18.82) 170.59,17.48 173.96,17.48 175.18,16.26 178.26,16.26 179.6,14.91 181.64,14.91 185.29,11.25 188.76,11.25 192.44,7.57 v1(205.64,7.57)
  L6 w0.102: v1(104.32,49.19) 105.76,49.19 107.08,50.52 109.38,50.52 110.04,51.18 111.95,51.18 113.46,52.7 113.46,53.77 114.73,55.04 117.11,55.04 119.8,57.73 121.43,57.73 125.71,62.01 125.92,62.01 127.25,63.35 131.23,63.35 136.59,68.71 137.27,68.71 147.5,68.71 148.24,69.44 163.42,69.44 163.67,69.7 179.5,69.7 182.68,66.52 182.68,48.29 177.34,42.95 177.34,38.19 175.74,36.59 175.74,27.3 169.25,20.81 v1(169.25,18.82)
  BOTTOM w0.114: v2(206.21,8.14) v1(205.64,7.57)
WOOF_GVDD_CD1: length 4.3
  TOP w0.114: U8.40 191.42,23.8 190.32,22.71 v3(190.32,22.45) 189.51,21.64 C410.1
WOOF_I2C_SCL1: length 8.1
  TOP w0.114: v1(201.8,28.73) 201.8,28.63 201.84,28.59 R2516.2 201.14,27.24 201.14,26.59 200.36,25.8 U8.8
  BOTTOM w0.114: R2518.2 203.48,28.64 203.48,29.34 v2(203.38,29.44) 202.77,29.44 202.56,29.23 202.53,29.23 202.03,28.73 v1(201.8,28.73)
WOOF_I2C_SDA1: length 7.2
  TOP w0.114: R2515.2 201.82,26.56 200.89,25.63 v1(200.89,25.58) 200.71,25.4 U8.7
  BOTTOM w0.114: R2517.2 203.04,24.74 v2(202.71,24.74) 202.21,24.74 201.37,25.58 v1(200.89,25.58)
WOOF_ISENSEP_L1: length 4.4
  TOP w0.114: PR29.1 192.53,30.96 v3(192.63,30.86) 193.15,30.86 193.29,31 PR23.2 193.99,30.63 193.99,30.42 194.36,30.05 U8.25
WOOF_ISENSEP_R1: length 6.9
  TOP w0.114: PR28.2 187.7,29.39 v3(188.09,29.39) 188.42,29.39 189.44,28.37 PR20.2 189.89,28.37 190.38,28.85 192.43,28.85 192.6,29.03 U8.28
WOOF_IVSENSE_L1: length 6.3
  TOP w0.114: U8.26 193.96,29.84 193.64,30.16 192.49,30.16 191.76,30.9 PR27.1 191.49,30.33 191.06,29.9 190.76,29.9 v3(190.73,29.93) 190.47,30.19 PR22.2
WOOF_IVSENSE_R1: length 4.7
  TOP w0.114: U8.29 191.46,28.2 191.4,28.26 v3(190.62,28.26) 189.71,27.35 PR26.2 PR19.2
WOOF_L+_C: length 29.4
  TOP w0.508: PR21.1 188.56,31.79 v1(189.13,32.36)
  L3 w0.254: v4(202.51,9.75) 202.51,9.98 192.56,19.94 192.56,29.21 190.22,31.55 189.94,31.55 v1(189.13,32.36)
  vias: v2(199.01,12.06) v4(203.71,9.7)
WOOF_L-_C: length 29.1
  TOP w0.508: v1(189.97,32.51) 190.09,32.39 190.09,32.38 190.47,32.01 PR22.1
  L3 w0.254: v1(189.97,32.51) 189.97,32.51 193.07,29.42 193.07,20.35 202.11,11.3 v4(203.05,11.3)
  BOTTOM w0.508: v2(203.73,11.99) v4(203.05,11.3)
WOOF_LDO_1D5_1: length 3.8
  TOP w0.203: U8.22 195.56,29.9
  TOP w0.254: 195.56,29.9 195.53,29.93 195.53,30.45 195.91,30.84 C413.1 195.2,32.05 v3(194.84,32.05)
WOOF_OUT_A1: length 1.7
  TOP w0.203: v4(198.58,20.7) 198.58,20.93 197.96,21.55 U8.55
  vias: v2(198.63,18.41) v4(198.63,19.76)
WOOF_OUT_A1_L: length 25.7
  TOP w0.508: PR23.1 193.62,32.64 v1(193.78,32.79)
  L3 w0.254: v4(202.56,13.08) 202.17,12.69 201.71,12.69 193.57,20.83 193.57,30.3 193.32,30.56 193.32,32.33 v1(193.78,32.79)
  vias: v2(201.42,13.84) v4(203.58,13.16)
WOOF_OUT_A_C1: length 3.2
  BOTTOM w0.508: v2(202.77,17.86) 202.41,18.21 C392.1
  BOTTOM w0.635: R320.2 201.29,16.89 201.46,17.05 C392.1
WOOF_OUT_B1: length 1.7
  TOP w0.203: v4(197.36,20.73) 196.76,21.33 U8.52
  vias: v2(197.36,18.29) v4(197.36,19.81)
WOOF_OUT_C1: length 1.8
  TOP w0.203: U8.47 194.76,21.53 193.93,20.7
  vias: v3(192.86,18.54)
WOOF_OUT_C1_L: length 20.8
  TOP w0.508: v1(187.78,28.19) 187.96,28.37 PR20.1
  L3 w0.254: v4(194.31,11.94) 194.31,17.17 188.86,22.62 188.86,26.89 187.78,27.97 v1(187.78,28.19)
  BOTTOM w0.508: v2(194.06,11.05) 194.06,11.68 v4(194.31,11.94)
WOOF_OUT_D1: length 1.3
  TOP w0.203: 193.12,21.06 193.56,21.5 U8.44
  vias: v3(192.1,20.5)
WOOF_OUT_D_C1: length 2.5
  TOP w0.508: v3(188.34,17.14) 189.33,17.14 R319.1
  TOP w0.635: C391.2 189.29,18.05 189.48,17.86 R319.1
WOOF_R+_C: length 16.5
  TOP w0.508: v1(186.84,24.28) PR18.1
  L3 w0.254: v4(192.28,11.68) 192.18,11.79 192.18,17.75 187.84,22.09 187.84,23.93 187.49,24.28 v1(186.84,24.28)
  vias: v2(193.29,9.78) v4(192.28,10.67) v4(198.5,10.16) v4(199.39,9.65)
WOOF_R-_C: length 20.9
  TOP w0.508: v1(187.4,26.01) 187.73,26.34 PR19.1
  L3 w0.254: v1(187.4,26.01) 187.73,26.01 188.35,25.39 188.35,22.4 192.68,18.06 192.68,12.34 193.7,11.33 195.45,11.33 v4(195.94,11.81)
  vias: v3(197.89,11.71)
WOOF_VREF2: length 6.6
  TOP w0.114: U8.23 195.16,30.75 194.73,31.17 194.56,31.17 194.23,31.5 194.23,32.45 194.34,32.56 194.34,33.03 194.01,33.36 193.95,33.36 C414.1 192.6,33.7 v3(192.58,33.68)
WOOF_VSENSEN_L1: length 7.2
  TOP w0.114: PR21.2 189.45,30.46 PR25.1 189.44,29.43 v3(189.46,29.42) 189.66,29.21 192.05,29.21 192.63,29.79 192.98,29.79 192.98,29.8 193.34,29.8 193.56,29.57 U8.27
WOOF_VSENSEN_R1: length 6.3
  TOP w0.114: U8.30 191.79,27.8 191.54,27.56 190.7,27.56 190.47,27.32 190.47,25.75 v3(190.37,25.65) 190.04,25.32 PR24.2 189.09,24.92 188.96,24.79 PR18.2
X32K_RTC: length 4.5
  TOP w0.114: R2522.1 108.13,74.83 107.96,74.66 C2510.1 107.67,75.13 107.26,75.54 v3(107.01,75.54) 105.9,74.43 X100.1
XIN_OSC: length 7.3
  TOP w0.114: R563.1 92.08,157.86 v3(91.32,158.62) 90.35,159.59 90.35,161.65 GPU1.BA43
XTL_32K_X1_CPU: length 16.1
  TOP w0.114: CPU1.AW5 150.62,177.62 148.02,177.62 146.86,176.47 146.86,173.94 143.5,170.57 C18.2 141.56,170.57 R45.1 141.02,170.59 140.74,170.87 X1.1
XTL_32K_X2_CPU: length 16.9
  TOP w0.114: CPU1.AW6 150.84,177.16 148.33,177.16 148.05,176.88 148.05,176.74 147.52,176.2 147.52,173.65 143.36,169.49 142.56,169.49 C17.2 142.35,169.7 R45.2 140.12,168.28 X1.2
XTL_32K_XI_RTC: length 14.9
  TOP w0.114: X100.2 106.37,77.17 106.82,76.72 C2509.1 107.71,76.61 R2523.2 110.03,76.61 110.67,75.97 U2505.1 112.17,75.97 113.92,74.22 113.92,73.33 v1(113.77,73.18)
  BOTTOM w0.114: v5(113.77,72.19) 113.77,72.19 v1(113.77,73.18) 113.59,73.36 111.43,73.36 111.32,73.46 U2506.1
XTL_32K_XO_RTC: length 11.3
  TOP w0.114: R2522.2 R2523.1 110.65,74.7 U2505.2 111.73,74.7 112.9,73.53 v1(112.9,72.75)
  BOTTOM w0.114: U2506.2 110.35,74.36 110.19,74.19 110.19,73.05 110.62,72.62 v5(111.47,72.62) 112.78,72.62 v1(112.9,72.75)
XTL_48M_X1_CPU: length 27.1
  TOP w0.114: CPU1.AJ1 161,182.51 160.12,183.39 150.75,183.39 149.61,182.25 145.34,182.25 142.95,179.86 142.95,176.76 142.33,176.13 R81.1 141.47,176.13 C22.1 140.16,175.97 X2.3
XTL_48M_X2_CPU: length 30.4
  TOP w0.114: X2.1 139.23,177.01 C23.1 141.33,177.02 R81.2 142.28,178.88 141.84,179.32 v3(141.84,179.67) 141.84,179.69 145.08,182.93 149.22,182.93 150.27,183.97 160.81,183.97 162,182.78 CPU1.AH1
ZQ_A0: length 3.8
  TOP w0.114: VRAMA1.J13 v6(102.9,189.2)
  BOTTOM w0.114: R680.1 104.92,189.02 v2(104.87,189.08) 104.43,189.08 103.94,189.57 103.36,189.57 102.98,189.2 v6(102.9,189.2)
ZQ_A1: length 3.4
  TOP w0.114: VRAMA2.J13 v6(83.7,220.9)
  BOTTOM w0.114: v6(83.7,220.9) 82.83,221.77 v2(82.83,222.12) 82.83,222.71 83.25,223.13 R681.1
ZQ_B0: length 6.3
  TOP w0.114: v6(74.8,220.9) 74.77,220.9 VRAMB1.J13
  BOTTOM w0.114: v6(74.8,220.9) 75.21,220.49 76.99,220.49 77.03,220.52 78.75,220.52 R641.1 79.12,220.15 79.12,219.46 v2(79.43,219.15)
ZQ_B1: length 2.9
  TOP w0.114: VRAMB2.J13 v6(46.7,220.9)
  BOTTOM w0.114: v6(46.7,220.9) 46.66,220.9 v2(45.72,221.84) 45.02,221.84 R637.1
ZQ_C0: length 7.1
  TOP w0.114: VRAMC1.J13 29.1,203.3 v6(29.1,203.31)
  BOTTOM w0.089: v6(29.1,203.31) 28.69,202.9 28.13,202.9 28.13,202.89 27.34,202.89 27.1,202.66 27.1,201.45 R685.1
  BOTTOM w0.114: R685.1 25.15,199.49 v2(25.15,199.16)
ZQ_C1: length 4.6
  TOP w0.114: v6(29.1,175.2) VRAMC2.J13
  BOTTOM w0.114: v6(29.1,175.2) 28.7,174.8 28.47,174.8 28.47,174.79 28.13,174.79 27.81,175.11 v2(27.01,175.11) 26.92,175.03 R708.1
ZQ_D0: length 3.4
  TOP w0.114: v6(29.1,166.3) VRAMD1.J13
  BOTTOM w0.114: v6(29.1,166.3) 28.22,167.18 v2(27.94,167.18) 27.94,168.02 R636.1
ZQ_D1: length 4.4
  TOP w0.114: VRAMD2.J13 v6(60.8,147.1)
  BOTTOM w0.089: v6(60.8,147.1) 61.2,146.7 61.2,145.95
  BOTTOM w0.114: R664.1 60.11,144.08 v2(60.92,144.88) 61.2,145.16 61.2,145.95

## Copper pours and planes (outline as drawn)
1V_VDDC_VGA on TOP: 92.71,131.7 89.53,134.87 86.87,134.87 86.23,134.24 86.23,132.72 85.85,132.33 82.68,132.33 80.14,134.87 75.95,134.87 74.17,133.1 65.91,133.1 64.14,134.87 61.21,134.87 59.69,133.35 54.74,133.35 53.21,134.87 50.55,134.87 48.9,133.22 42.67,133.22 42.29,133.6 42.29,134.49 41.91,134.87 38.73,134.87 37.72,133.86 35.69,133.86 34.92,134.62 34.92,139.32 36.02,140.41 36.02,149.81 37.21,151 45.44,151 46.2,150.24 46.2,141.35 48.49,139.06 67.61,139.06 67.97,139.42 67.97,140.69 66.98,141.68 66.98,142.88 67.11,143 69.22,143 69.48,143.27 70.37,143.27 70.51,143.13 70.51,141.38 70.82,141.07 72.09,141.07 72.89,141.87 72.9,141.87 73.52,142.49 75.18,142.49 75.69,141.99 77.22,141.99 77.98,142.75 77.98,143.51 78.41,143.94 81.36,143.94 82.42,142.88 87.38,142.88 88.04,143.54 88.04,153.64 88.32,153.92 91.95,153.92 92.2,153.67 92.2,146.3 92.71,145.8 95.89,145.8 98.68,143 101.35,143 103.12,141.22 103.12,135.64 102.36,134.87 99.06,134.87 98.81,134.62 98.81,131.95 98.55,131.7
1V_VDDC_VGA on TOP: 78.61,145.92 77.98,146.56 77.98,152.4 79.63,154.05 82.68,154.05 82.8,153.92 82.8,146.3 82.42,145.92
1V_VDDC_VGA on BOTTOM: 78.94,146.15 78.21,146.89 78.21,150.83 78.11,150.93 78.11,152.78 78.49,153.16 82.42,153.16 82.55,153.03 82.55,146.91 81.79,146.15 ; 4 cut-outs
1V_VDDC_VGA on BOTTOM: 88.04,146.84 87.88,146.99 87.88,153.29 88.01,153.42 91.82,153.42 92.2,153.03 92.2,147.47 92.1,147.37 91.29,147.37 90.75,146.84
1V_VDDC_VGA on BOTTOM: outline of 110 points within 63.18,172.14 77.89,187.02 ; 44 cut-outs
1V_VDDC_VGA on L3: 90.83,168.5 91.02,168.31 91.02,159.81 90.02,158.8 90.02,154.38 92.68,151.71 93.57,151.71 94.08,151.21 94.08,145.94 95.42,144.6 95.42,141.47 93.9,139.95 37.22,139.95 36.07,141.1 36.07,150.88 38.61,153.42 38.61,178.56 45.15,185.1 62.17,185.1 62.81,185.75 65.1,185.75 65.75,185.1 67.27,185.1 67.89,185.72 69.72,185.72 69.82,185.62 69.82,185.25 69.98,185.1 70.93,185.1 71.63,185.8 73.91,185.8 74.04,185.67 74.04,185.1 78.3,185.1 79.12,184.28 79.12,180.97 81.28,178.82 81.28,168.91 81.69,168.5 ; 1 cut-out
1V_VDDC_VGA on L4: 64.44,186.61 64.69,186.61 65.51,185.8 67.72,185.8 67.96,186.04 71.87,186.04 72.47,186.64 72.64,186.64 75.51,183.77 76.43,183.77 78.23,181.97 78.23,181.86 78.36,181.74 87.63,181.74 90.81,178.56 90.81,168.4 91.19,168.02 91.19,161.44 95.15,157.48 95.15,152.98 104.39,143.74 104.39,135.03 102.34,132.97 102.23,132.97 101.09,131.83 92.71,131.83 91.82,132.72 86.87,132.72 86.49,132.33 83.06,132.33 82.68,132.72 72.64,132.72 72.01,133.35 72.01,136.78 73.53,138.3 73.53,144.45 72.67,145.31 72.67,152.37 71.25,153.8 68.33,153.8 66.17,151.64 66.17,148.07 64.52,146.42 64.52,140.62 67.87,137.28 67.87,134.24 67.44,133.81 67.16,133.81 67.15,133.8 48.26,133.8 47.79,133.33 35.53,133.33 32.22,136.63 32.22,150.82 33.62,152.22 37.13,152.22 38.59,153.69 38.59,178.55 45.15,185.1 62.93,185.1 ; 1 cut-out
1V_VDDC_VGA on L5GND: 75.16,139.99 75.02,140.13 75.02,150.45 72.93,152.54 71.02,152.54 70.73,152.83 70.73,153.83 69.94,154.61 69.94,157.76 70.8,158.62 70.8,160.53 71.18,160.91 71.18,170.23 70.49,170.93 69.83,170.93 69.58,171.17 69.58,172.21 68.84,172.96 66.63,172.96 66.31,173.28 66.31,173.87 65.89,174.28 65.18,174.28 64.22,175.24 64.22,187.25 64.42,187.44 73.73,187.44 78.43,182.74 78.86,182.74 79.16,182.45 79.16,182.14 79.7,181.6 80.57,181.6 80.82,181.34 85.72,181.34 86.05,181.01 90.37,181.01 90.87,180.52 90.87,171.27 90.61,171.02 90.61,170.23 91,169.85 91,159.84 89.98,158.83 89.98,154.33 92.63,151.68 93.52,151.68 94.04,151.15 94.04,145.92 95.36,144.6 95.36,141.48 93.88,139.99
1V_VDDC_VGA on L6: 77.67,184.28 77.67,173.99 82.55,169.11 90.25,169.11 91.21,168.15 91.21,155.07 93.99,152.29 93.99,147.18 94.49,146.69 95.25,146.69 95.96,147.4 99.09,147.4 103.99,142.49 103.99,135.4 100.06,131.47 93.12,131.47 91.72,132.87 87.35,132.87 86.87,132.38 83.06,132.38 82.47,132.97 72.14,132.97 71.93,133.17 71.93,136.45 74.98,139.5 74.98,145.97 76.07,147.07 76.07,151.13 72.97,154.23 72.97,171.83 72.67,172.14 72.29,172.14 71.65,172.77 69.14,172.77 68.91,172.54 66.8,172.54 66.17,173.18 66.17,173.74 65.79,174.12 64.77,174.12 64.14,174.75 64.14,185.67 64.39,185.93 75.18,185.93 76.2,184.91 77.04,184.91
1V_VDDCI_VGA on TOP: 109.09,208.79 108.33,209.55 108.33,221.11 110.67,223.44 115.62,223.44 117.86,225.68 122.56,225.68 123.06,225.17 123.06,219.96 121.16,218.06 121.16,216.79 120.78,216.41 119.76,216.41 119.13,215.77 119.13,215.39 118.87,215.14 115.19,215.14 114.68,214.63 114.68,211.71 111.76,208.79 ; 5 cut-outs
1V_VDDCI_VGA on BOTTOM: 115.65,219.1 115.49,219.25 115.49,223.06 115.9,223.47 119.43,223.47 119.79,223.11 119.79,219.71 119.18,219.1
1V_VDDCI_VGA on L3: 111.46,220.65 112.52,219.58 112.52,210.57 110.74,208.79 107.7,208.79 101.09,202.18 95.63,202.18 88.52,195.07 88.52,190.75 83.06,185.29 76.07,185.29 75.37,185.99 63.13,185.99 62.36,186.77 62.36,200.91 71.65,210.21 90.83,210.21 91.69,211.07 95.63,211.07 96.77,212.22 96.77,216.15 101.27,220.65
1V_VDDCI_VGA on L4: 71.65,210.21 90.83,210.21 91.69,211.07 95.63,211.07 96.77,212.22 96.77,216.15 101.35,220.73 111.35,220.73 112.53,219.54 112.53,211.9 110.34,209.7 106.86,209.7 105.92,208.76 105.92,202.69 103.71,200.48 96.11,200.48 91.82,196.19 91.82,185.42 88.75,182.35 78.46,182.35 76.38,184.43 76.17,184.43 74.52,186.08 73.81,186.08 73.28,186.61 73.28,186.69 72.9,187.07 72.39,187.07 72.01,186.69 72.01,186.44 71.75,186.18 71.25,186.18 70.99,186.44 70.99,186.69 70.74,186.94 68.2,186.94 67.82,186.56 67.82,186.44 67.44,186.06 66.67,186.06 65.79,186.94 64.26,186.94 63.5,186.18 62.94,186.18 62.36,186.77 62.36,200.91
1V_VDDCI_VGA on L5GND: 62.59,172.96 62.05,173.49 61.6,173.49 61.48,173.61 61.48,188.03 61.98,188.53 64.26,188.53 64.43,188.36 64.43,187.99 63.84,187.4 63.84,175.08 65.02,173.9 65.73,173.9 65.93,173.71 65.93,173.19 65.7,172.96
1V_VDDCI_VGA on L6: 75.44,186.18 76.33,185.29 77.09,185.29 77.22,185.42 77.22,186.94 76.2,187.96 72.14,187.96 71.4,188.7 62.46,188.7 62.1,188.34 62.1,181.99 61.47,181.36 61.47,178.56 62.1,177.93 62.1,173.23 62.99,172.34 65.41,172.34 65.91,172.85 65.91,173.61 65.66,173.86 64.64,173.86 63.75,174.75 63.75,185.93 64.01,186.18
1V_VDDCR_CPU on TOP: 158.23,199.9 157.72,200.41 157.72,202.22 158.29,202.79 163.45,202.79 163.46,202.81 165.34,202.81 166.07,203.53 166.07,206.97 166.52,207.43 168.92,207.43 170.56,205.79 170.56,203.2 170.87,202.9 176.91,202.9 177.62,202.18 179.86,202.18 180.47,202.79 180.47,202.82 180.85,203.2 181.86,203.2 182.25,203.58 182.25,207.01 182.68,207.44 185.67,207.44 186.82,206.3 186.82,204.47 188.72,202.56 195.78,202.56 196.82,203.61 198.98,203.61 199.14,203.76 199.14,207.01 199.64,207.52 202.44,207.52 202.95,207.01 202.95,203.1 202.97,203.07 202.97,200.81 202.06,199.9
1V_VDDCR_CPU on TOP: 161.93,155.6 161.58,155.96 161.58,156.42 161.85,156.7 161.85,157.53 160.64,158.75 160.64,161.34 161.07,161.78 161.07,166.4 158.78,168.68 158.78,169.8 158.22,170.36 158.22,172.72 158.78,173.28 158.78,173.48 159.57,174.27 168.76,174.27 168.77,174.26 168.83,174.32 172.87,174.32 173.43,174.88 173.91,174.88 174.27,174.52 174.27,173.91 171.62,171.26 171.62,171.03 171.78,170.87 171.78,170.56 171.6,170.38 171.35,170.38 171.3,170.43 170.81,170.43 170.47,170.09 170.47,166.93 170.05,166.51 170.05,165.8 170.47,165.38 170.47,164.63 170.31,164.47 169.29,164.47 169.04,164.72 169.04,168.38 168.81,168.61 167.64,168.61 167.39,168.35 167.39,160.45 167.11,160.17 166.57,160.17 166.34,159.94 166.34,159.38 166.19,159.23 165.71,159.23 164.59,158.12 164.59,157.41 163.58,156.39 163.1,156.39 162.31,155.6 ; 9 cut-outs
1V_VDDCR_CPU on BOTTOM: 181.36,199.77 180.72,200.41 180.72,205.23 182.25,206.76 186.69,206.76 187.32,206.12 187.32,204.09 188.34,203.07 196.47,203.07 196.85,203.45 202.69,203.45 203.07,203.07 203.07,201.42 201.42,199.77
1V_VDDCR_CPU on BOTTOM: outline of 97 points within 155.19,156.29 180.97,182.25 ; 51 cut-outs
1V_VDDCR_CPU on L4: 169.8,206.12 170.69,205.23 170.69,203.33 170.94,203.07 177.16,203.07 177.93,202.31 179.71,202.31 181.1,203.71 181.1,206.12 181.48,206.5 186.56,206.5 186.87,206.2 186.87,204.47 188.75,202.59 196.52,202.59 198.4,204.47 198.4,205.46 198.81,205.87 201.68,205.87 203.45,204.09 203.45,199.26 201.42,197.23 201.42,183.13 199.31,181.03 178.26,181.03 178.09,180.86 178.09,180.84 177.88,180.62 177.88,176.3 175.67,174.09 173.28,174.09 172.77,173.58 172.77,172.39 171.81,171.42 171.81,170.21 169.95,168.35 169.95,157 169.04,156.08 162.69,156.08 162.31,156.46 162.31,157.61 161.67,158.24 161.29,158.24 161.16,158.37 161.16,158.88 160.58,159.46 155.88,159.46 155.19,160.15 155.19,162.81 154.56,163.45 152.53,163.45 152.27,163.7 152.27,169.42 156.84,173.99 158.62,173.99 161.39,176.76 162.84,176.76 163.17,177.09 163.17,178.69 162.86,178.99 162.51,178.99 161.29,180.21 161.29,181.74 161.04,181.99 161.04,183.67 155.7,189 155.7,198.73 156.29,199.31 156.31,199.31 157.56,200.56 157.56,202.29 157.58,202.29 158.37,203.07 163.7,203.07 163.83,203.2 163.83,205.87 164.08,206.12
1V_VDDCR_CPU on L5GND: outline of 82 points within 151.24,156.15 203.42,206.49 ; 3 cut-outs
1V_VDDCR_CPU on L6: 197.23,203.58 202.31,203.58 202.82,203.07 202.82,201.29 201.47,199.95 158.24,199.95 157.73,200.46 157.73,202.18 158.5,202.95 164.47,202.95 164.85,203.33 164.85,204.98 165.99,206.12 170.56,206.12 170.94,205.74 170.94,204.09 172.09,202.95 177.16,202.95 177.67,202.44 180.21,202.44 180.85,203.07 185.17,203.07 185.67,203.58 185.67,206.38 186.18,206.88 186.69,206.88 187.45,206.12 187.45,203.71 188.98,202.18 195.83,202.18
1V_VDDCR_SOC on TOP: 220.73,159.13 220.09,159.77 209.93,159.77 209.68,160.02 207.9,160.02 207.65,159.77 203.2,159.77 203.19,159.78 203.03,159.78 202.72,160.1 202.72,162.61 203.23,163.12 207.19,163.12 208.28,164.21 208.28,169.16 208.15,169.29 208.15,172.21 208.53,172.59 211.07,172.59 212.72,170.94 215.65,170.94 216.79,172.09 223.27,172.09 224.28,171.07 227.84,171.07 228.52,170.38 228.52,160.32 227.33,159.13
1V_VDDCR_SOC on TOP: 131.83,204.6 131.7,204.72 131.7,207.01 132.08,207.39 132.72,207.39 133.1,207.01 133.1,204.85 132.84,204.6
1V_VDDCR_SOC on TOP: 176.99,156.26 176.1,157.16 176.1,157.86 175.13,158.83 175.13,160.27 174.57,160.83 174.55,160.81 173.91,160.81 173.79,160.93 173.79,168.22 172.33,169.69 172,169.69 171.78,169.9 171.78,170.26 173.1,171.58 173.1,172.26 175.04,174.2 175.04,174.5 175.27,174.73 178.54,174.73 178.72,174.55 180.4,174.55 181.67,173.28 181.67,171 181.26,170.59 181.26,166.75 179.91,165.41 179.91,162.23 179.33,161.65 179.33,156.87 178.72,156.26 ; 9 cut-outs
1V_VDDCR_SOC on TOP: 170.94,161.29 170.69,161.54 170.69,162.69 170.94,162.94 170.94,163.83 171.07,163.96 171.83,163.96 171.96,163.83 171.96,163.32 171.5,162.86 171.5,162.03 171.83,161.7 171.83,161.47 171.65,161.29
1V_VDDCR_SOC on BOTTOM: 218.06,165.86 217.3,166.62 207.65,166.62 203.07,171.2 203.07,172.34 203.58,172.85 222.76,172.85 223.9,171.7 223.9,167.64 222.63,166.37 220.6,166.37 220.09,165.86
1V_VDDCR_SOC on BOTTOM: 171.32,160.15 171.2,160.27 171.2,160.91 170.61,161.49 170.61,162.61 171.2,163.19 171.2,163.83 171.32,163.96 171.96,163.96 172.09,163.83 172.09,163.07 171.53,162.51 171.53,161.98 172.09,161.42 172.09,160.27 171.96,160.15
1V_VDDCR_SOC on BOTTOM: outline of 85 points within 172.34,156 191.9,180.97 ; 67 cut-outs
1V_VDDCR_SOC on L4: 177.67,155.96 178.64,155.96 179.86,157.18 179.86,165.51 180.47,166.12 181.74,166.12 181.99,165.86 181.99,165.35 182.25,165.1 183.13,165.1 183.9,165.86 194.44,165.86 195.96,164.34 198.5,164.34 202.56,160.27 227.61,160.27 229.54,162.2 229.54,170.43 227.97,172.01 209.65,172.01 208.79,172.87 208.79,175.26 204.09,179.96 189.48,179.96 188.72,180.72 179.32,180.72 178.18,179.58 178.18,176.02 176.15,173.99 174.62,173.99 171.96,171.32 171.96,169.29 170.43,167.77 170.43,157.61 170.81,157.23 176.4,157.23
1V_VDDCR_SOC on L5GND: 177.6,156.04 176.41,157.24 170.73,157.24 170.4,157.57 170.4,168.58 172.02,170.2 172.02,171.29 173.09,172.36 173.09,173.5 173.51,173.93 175.77,173.93 178.24,176.4 178.24,179.75 179.15,180.66 188.26,180.66 189.28,179.64 204.34,179.64 208.75,175.23 208.75,172.9 209.65,172 227.91,172 229.5,170.41 229.5,162.26 227.56,160.31 202.49,160.31 198.43,164.38 196.01,164.38 194.29,166.1 181.3,166.1 179.84,164.65 179.84,157.33 179.68,157.16 179.19,157.16 178.85,156.82 178.85,156.34 178.56,156.04
5V_CODEC_S0 on BOTTOM: 195.07,43.81 194.82,44.07 194.82,45.72 194.94,45.85 194.94,46.74 194.69,46.99 194.69,49.91 194.82,50.04 195.71,50.04 195.83,49.91 195.83,48.77 196.47,48.13 196.47,46.13 197.23,45.36 197.23,43.92 197.13,43.81 ; 2 cut-outs
5V_S0 on TOP: 136.19,11.25 135.56,11.89 135.56,13.13 135.89,13.46 136.45,13.46 136.65,13.67 137.21,13.67 137.36,13.51 137.36,11.4 137.21,11.25
5V_S0 on TOP: 86.49,13.08 84.89,14.68 84.89,16.59 85.19,16.89 89.69,16.89 90.04,16.54 90.04,14.48 89.79,14.22 89.79,13.34 89.53,13.08
5V_S0 on BOTTOM: 92.2,2.54 89.03,5.71 89.03,5.77 85.98,8.81 85.98,14.73 86.49,15.24 88.77,15.24 89.83,14.19 89.83,10.55 90.93,9.45 90.93,7.49 93.73,4.7 114.68,4.7 116.61,6.63 121.13,6.63 124.61,10.11 130.07,10.11 130.18,10.21 130.18,10.22 130.25,10.3 131.97,10.3 132.33,10.67 132.33,11.05 132.78,11.49 133.92,11.49 134.24,11.81 134.24,12.98 134.42,13.16 137.39,13.16 137.67,12.88 137.67,12.47 137.68,12.46 137.68,12.05 137.92,11.81 139.98,11.81 141.12,10.67 142.49,10.67 143.26,9.91 149.73,9.91 151.65,11.82 153.43,11.82 159,17.4 160.63,17.4 160.87,17.64 165.85,17.64 166.09,17.4 173.1,17.4 173.74,18.03 176.66,18.03 177.04,17.65 177.04,16.26 175.32,14.54 167.96,14.54 167,13.59 167,12.83 166.56,12.38 165.54,12.38 165.1,12.83 163.5,12.83 159.44,8.76 141.99,8.76 141.76,8.99 136.75,8.99 136.42,8.66 133.35,8.66 133.35,7.59 128.55,2.79 115.82,2.79 115.81,2.78 114.97,2.78 114.73,2.54 ; 1 cut-out
5V_S0 on BOTTOM: 183.51,22.73 183.2,23.05 183.2,28.64 184.78,30.23 184.78,31.5 186.06,32.77 186.06,33.66 192.15,39.75 192.15,40.77 192.28,40.89 193.98,40.89 194.08,40.79 194.08,40.06 194.31,39.83 194.49,39.83 194.5,39.81 195.77,39.81 196.15,39.43 196.15,38.16 196.72,37.59 196.72,35.18 195.83,34.29 194.56,34.29 194.44,34.42 189.1,34.42 187.58,32.89 187.58,32.51 186.18,31.11 186.18,29.72 184.53,28.07 184.53,26.54 184.51,26.52 184.51,23.42 183.82,22.73 ; 1 cut-out
5V_S0 on L6: 174.93,18.21 177.37,18.21 177.55,18.03 177.55,16.79 177.24,16.48 177.23,16.48 176.23,15.48 174.84,15.48 174.64,15.68 174.64,16.73 174.75,16.84 174.75,18.03
5V_S0 on L6: 183.62,24.61 184.45,24.61 184.84,24.23 184.84,23.44 183.95,22.56 183.95,22.53 183.36,21.95 182.47,21.95 182.32,22.1 182.32,23.32
5V_S5 on TOP: 220.42,16.38 220.32,16.48 220.32,17.4 219.77,17.95 219.77,19.37 219.96,19.56 219.96,20.07 220.14,20.24 220.47,20.24 220.68,20.04 220.68,19.53 221.25,18.96 221.25,18.12 221.16,18.03 221.16,16.46 221.08,16.38
5V_S5 on TOP: 176.02,7.49 174.9,8.61 174.9,12.34 176.45,13.89 177.98,13.89 179.2,15.11 180.09,15.11 180.72,15.75 184.66,15.75 184.91,15.49 184.91,14.73 184.66,14.48 183.77,14.48 183.26,13.97 181.74,13.97 179.58,11.81 177.98,11.81 176.78,10.62 176.78,7.62 176.66,7.49
5V_S5 on TOP: 100.97,33.27 100.71,33.53 100.71,36.7 101.47,37.47 101.47,39.12 101.22,39.37 101.22,39.62 100.97,39.88 100.33,39.88 100.2,40.01 100.2,40.39 100.46,40.64 102.49,40.64 103,40.13 103,39.37 103.63,38.73 103.63,36.45 102.36,35.18 102.36,34.16 101.47,33.27 ; 2 cut-outs
5V_S5 on TOP: 121.03,198.88 120.9,199.01 120.9,199.64 121.28,200.03 122.68,200.03 122.94,199.77 122.94,199.26 122.56,198.88
5V_S5 on TOP: 210.03,215.37 209.93,215.47 209.93,216.53 210.82,217.42 210.82,217.93 209.55,219.2 209.55,220.17 210.19,220.8 211.15,220.8 211.25,220.7 211.25,219.15 211.96,218.44 211.96,216.28 211.53,215.85 211.53,215.6 211.3,215.37 ; 1 cut-out
5V_S5 on TOP: 139.06,31.24 138.81,31.5 138.81,37.06 139.12,37.36 140.82,37.36 141.1,37.08 141.1,31.37 140.97,31.24
5V_S5 on TOP: 80.9,82.55 80.14,83.31 80.14,100.97 80.77,101.6 85.85,101.6 86.74,100.71 86.74,100.08 86.36,99.69 82.42,99.69 81.53,98.81 81.53,88.9 83.19,87.25 88.77,87.25 88.8,87.27 89.89,86.18 94.56,86.18 96.57,84.18 96.57,83.36 96.44,83.24 95.63,83.24 94.83,84.04 93.73,84.04 93.41,83.72 85.72,83.72 84.56,82.55
5V_S5 on TOP: 138.4,11.33 138,11.73 138,12.45 138.33,12.78 138.68,12.78 138.86,12.95 138.86,13.51 139.04,13.69 139.88,13.69 140.54,13.03 140.54,11.66 140.21,11.33
5V_S5 on BOTTOM: 179.1,5.71 178.82,5.99 178.82,8.13 180.39,8.13 180.64,7.87 180.64,7.39 180.9,7.14 181.69,7.14 181.91,7.37 181.91,7.82 182.09,8 182.42,8 182.75,7.67 182.75,6.02 182.45,5.71
5V_S5 on BOTTOM: 139.06,31.24 138.81,31.5 138.81,31.52 138.61,31.72 138.61,37.41 138.66,37.47 138.66,38.25 135.25,41.66 135.13,41.66 135,41.78 135,48.9 133.48,50.42 133.48,51.31 133.73,51.56 135.13,51.56 136.65,50.04 136.65,42.16 140.59,38.23 140.59,37.77 141.1,37.26 141.1,31.37 140.97,31.24
5V_S5 on L3: 139.19,37.47 140.84,37.47 141.1,37.21 141.1,33.15 140.84,32.89 139.57,32.89 139.06,33.4 139.06,37.34
5V_S5 on L3: 182.88,10.64 185.06,10.64 185.55,10.16 185.55,7.29 184.62,6.36 182.51,6.36 182.42,6.27 176.07,6.27 174.88,7.47 174.88,10.34 174.4,10.82 173.99,10.82 171.64,13.17 167.65,13.17 166.98,13.84 165.99,13.84 165.35,13.21 164.08,13.21 164.06,13.18 163.7,13.18 163.7,13.08 163.32,12.7 163.32,12.06 163.83,11.56 166.37,11.56 167.44,10.49 167.44,9.14 167.89,8.69 167.89,4.57 167.77,4.45 167.39,4.45 167.34,4.39 166.01,4.39 165.77,4.64 165.77,6.29 165.51,6.55 162.18,6.55 161.67,7.06 161.67,9.4 160.15,10.92 160.15,13.21 164.11,17.17 168.4,17.17 169.67,15.9 172.11,15.9 173.66,14.35 175.08,14.35 175.92,13.51 177.72,13.51 177.75,13.49 180.04,13.49
5V_S5 on L3: 103.12,83.82 104.01,83.82 107.19,80.64 108.97,80.64 112.27,77.34 112.27,72.77 117.09,67.94 119.89,67.94 123.06,64.77 123.06,62.23 124.84,60.45 126.62,60.45 127.25,59.82 127.25,58.55 127.13,58.42 124.59,58.42 121.67,61.34 121.67,62.87 119.63,64.9 116.33,64.9 110.11,71.12 110.11,74.12 109.68,74.55 108.05,74.55 107,75.6 107,78.3 106.55,78.74 102.23,78.74 101.6,79.38 101.6,82.3
5V_S5 on L4: 97.92,83.82 102.87,83.82 103.38,83.31 103.38,82.68 102.87,82.17 96.9,82.17 96.01,83.06 96.01,83.77 95.78,84 95.78,84.4 95.96,84.58 97.16,84.58
5V_S5 on L4: 108.08,111 104.14,107.06 94.61,107.06 88.27,100.71 88.01,100.71 87.12,99.82 85.98,99.82 85.6,100.2 85.6,102.74 91.44,108.58 103.63,108.58 106.87,111.82 106.87,123.25 107.57,123.95 109.86,123.95 110.11,123.7 110.11,122.81 108.08,120.78
5V_S5 on L4: 134.24,50.67 133.99,50.42 131.32,50.42 130.24,51.5 130.24,55.05 129.03,56.26 126.49,56.26 125.22,57.53 125.22,59.56 126.24,60.58 127.89,60.58 128.14,60.83 128.14,61.21 128.4,61.47 130.18,61.47 131.76,59.88 133.67,59.88 134.24,59.31
5V_S5 on L6: 133.2,13.97 133.2,36.32 134.47,37.59 140.13,37.59 140.39,37.34 140.59,37.34 140.84,37.08 140.84,25.78 139.17,24.1 139.17,18.19 140.91,16.45 140.97,16.45 141.03,16.51 142.49,16.51 144.02,14.99 144.91,14.99 146.69,13.21 147.45,13.21 148.72,14.48 149.73,14.48 152.02,16.76 155.07,16.76 155.19,16.64 158.5,16.64 158.52,16.61 159.79,16.61 159.8,16.6 160.67,16.6 161.95,15.32 164.92,15.32 165.86,14.38 165.86,13.46 165.1,12.7 163.47,12.7 162.99,12.22 156.36,12.22 155.07,10.92 152.55,10.92 151.28,9.65 140.11,9.65 138.96,10.79 138.43,10.79 138.42,10.78 136.39,10.78
5V_USB_CHAR_REAR on TOP: 95.25,22.99 93.22,25.02 93.22,28.57 90.04,31.75 90.04,39.12 91.31,40.39 96.01,40.39 96.39,40.01 96.39,38.1 96.27,37.97 95.89,37.97 94.61,36.7 94.61,31.24 95,30.86 95,28.19 95.38,27.81 95.38,25.27 96.01,24.64 96.52,24.64 96.9,24.26 96.9,23.5 96.39,22.99 ; 1 cut-out
5V_USB_CHAR_REAR on TOP: 155.19,10.67 154.81,11.05 154.81,14.1 154.79,14.1 153.62,15.27 153.62,15.52 153.06,16.08 153.01,16.08 152.81,16.28 152.81,19.79 152.65,19.94 152.65,20.57 153.92,21.84 158.62,21.84 159.89,20.57 159.89,10.92 159.64,10.67 ; 1 cut-out
5V_USB_CHAR_REAR on TOP: 158.24,4.7 157.99,4.95 157.99,5.46 158.12,5.59 159.64,5.59 159.89,5.33 159.89,4.95 159.64,4.7
5V_USB_CHAR_REAR on L3: 157.91,11.81 159.13,11.81 160.5,10.44 160.5,5.03 159.92,4.45 157.23,4.45 156.62,5.05 156.62,10.52
5V_USB_CHAR_REAR on L4: 134.62,17.19 134.62,15.01 134.54,14.94 134.54,13.44 134.77,13.21 139.57,13.21 141.86,15.49 150.11,15.49 150.13,15.51 151.32,15.51 152.44,16.62 153.35,16.62 154.71,17.98 154.71,19.71 154.2,20.22 152.93,20.22 152.73,20.02 152.73,19.48 152.88,19.33 152.88,18.54 152.25,17.91 137.26,17.91 136.87,17.51 134.94,17.51
5V_USB_CHAR_SIDE on TOP: 226.06,25.15 225.93,25.27 225.93,26.54 226.19,26.8 228.85,26.8 228.98,26.67 228.98,25.27 228.85,25.15
5V_USB_CHAR_SIDE on TOP: 223.75,16.38 223.61,16.52 223.61,18.07 224.28,18.75 224.28,19.91 224.66,20.29 225.17,20.29 225.45,20.57 226.06,20.57 226.39,20.24 226.39,19.33 224.74,17.68 224.74,16.66 224.46,16.38 ; 2 cut-outs
5V_USB_CHAR_SIDE on BOTTOM: 225.68,19.94 225.43,20.19 225.43,21.08 225.81,21.46 225.81,23.11 224.88,24.04 224.88,25.44 226.11,26.67 226.69,26.67 227.34,26.02 227.34,20.57 226.71,19.94
12V_FAN on TOP: 11.05,175.9 10.29,176.66 10.29,178.56 10.41,178.69 12.57,178.69 13.08,178.18 15.88,178.18 16.26,178.56 19.56,178.56 19.81,178.31 19.81,177.04 19.56,176.78 13.84,176.78 12.95,175.9
12V_FAN on BOTTOM: 10.92,176.02 10.67,176.28 10.67,178.31 10.92,178.56 13.21,178.56 13.84,179.2 17.65,179.2 17.78,179.07 17.78,178.44 17.27,177.93 16,177.93 14.1,176.02 ; 1 cut-out
12V_S0 on TOP: 12.95,180.47 12.45,180.97 10.67,180.97 9.91,181.74 9.91,182.88 10.03,183.01 13.21,183.01 13.59,183.39 14.22,183.39 14.35,183.26 14.35,182.75 14.99,182.12 19.43,182.12 19.68,181.86 19.68,180.59 19.56,180.47 ; 4 cut-outs
12V_S0 on BOTTOM: 15.11,179.71 14.1,180.72 14.1,182.25 14.22,182.37 16,182.37 17.78,180.59 17.78,179.96 17.53,179.71 ; 1 cut-out
19V_AMP_AVDD on BOTTOM: 187.35,22.48 187.07,22.76 187.07,25.4 187.2,25.53 187.71,25.53 188.62,26.44 190.6,26.44 190.75,26.29 190.75,24.89 190.2,24.33 190.2,23.14 189.53,22.48 ; 2 cut-outs
19V_AMP_AVDD on L6: 189.36,26.29 189.36,23.24 191.59,21.01 204.27,21.01 206.76,23.5 206.76,24.26 206.12,24.89 206.12,25.91 205.1,26.92 204.09,26.92 203.58,27.43 203.58,30.35 202.18,31.75 198.37,31.75 197.36,30.73 197.36,30.48 196.72,29.84 192.91,29.84
19V_AMP_PVDD on TOP: 206.63,19.81 206.5,19.94 206.5,20.42 206.58,20.5 207.1,20.5 208.58,21.98 209.99,21.98 210.06,21.92 210.06,20.52 209.98,20.45 208.94,20.45 208.69,20.19 207.54,20.19 207.16,19.81
19V_AMP_PVDD on TOP: 214,16.13 213.87,16.26 213.87,17.14 212.98,18.03 212.98,18.29 213.15,18.46 213.49,18.46 213.96,17.98 216.38,17.98 216.64,18.24 216.64,20.32 216.31,20.65 215.16,20.65 215.11,20.7 215.11,21.97 215.26,22.12 216.59,22.12 217.07,21.64 218.67,21.64 218.72,21.59 218.72,18.36 218.73,18.35 218.59,18.21 218.59,16.36 218.36,16.13 ; 2 cut-outs
19V_AMP_PVDD on TOP: 191.64,21.21 191.4,21.46 191.4,22.6 191.74,22.95 193.15,22.95 193.22,22.89 193.22,21.49 193.14,21.41 192.1,21.41 191.9,21.21
19V_AMP_PVDD on TOP: 199.57,17.09 199.14,17.53 196.98,17.53 196.34,18.16 196.34,19.15 196.44,19.25 197.15,19.25 197.46,18.95 199.54,18.95 199.8,19.2 199.8,21.29 199.47,21.62 198.32,21.62 198.27,21.67 198.27,22.58 198.32,22.63 198.53,22.63 198.73,22.83 198.73,23.06 198.75,23.09 199.75,23.09 201.4,21.44 202.72,21.44 202.78,21.37 202.78,19.94 202.36,19.52 202.36,18.8 202.55,18.61 202.55,17.18 202.46,17.09 ; 2 cut-outs
19V_AMP_PVDD on BOTTOM: 186.69,16.64 186.51,16.81 186.51,18.97 186.83,19.29 186.83,19.6 186.84,19.61 186.84,21.31 187.43,21.89 189.76,21.89 190.93,23.06 191.95,23.06 192.02,22.99 192.02,22.73 192.15,22.61 196.09,22.61 196.47,22.99 200.28,22.99 200.91,22.35 204.34,22.35 204.98,21.72 207.52,21.72 208.05,21.18 214.71,21.18 215.16,21.64 216.28,21.64 216.31,21.62 218.08,21.62 218.72,20.98 218.72,19.25 218.59,19.13 217.25,19.13 216.89,19.48 216.89,19.86 216.33,20.42 212.67,20.42 212.32,20.07 212.32,19.53 211.53,18.75 208.03,18.75 206.81,17.53 204.09,17.53 203.45,18.16 203.45,19.43 202.69,20.19 200.53,20.19 199.14,21.59 196.72,21.59 195.58,20.45 194.54,20.45 190.73,16.64 ; 18 cut-outs
19V_AMP_PVDD on L4: 218.69,19.05 216.28,16.64 207.39,16.64 206.76,17.27 193.29,17.27 191.9,18.67 187.53,18.67 186.84,19.35 186.84,21.69 187.25,22.1 199.52,22.1 200.79,20.83 203.43,20.83 204.32,19.94 205.92,19.94 206.93,20.95 208.28,20.95 208.91,20.32 212.09,20.32 212.47,19.94 212.47,19.56 211.96,19.05 211.96,18.29 212.09,18.16 215.77,18.16 216.15,18.54 216.15,19.05 216.17,19.06 216.17,20.43 216.99,21.26 218.11,21.26 218.69,20.68
19V_DCBATOUT on TOP: 127,106.17 126.49,106.68 126.49,108.33 127.25,109.09 129.16,109.09 129.41,108.84 129.41,106.68 128.91,106.17
19V_DCBATOUT on TOP: 81.79,101.98 78.41,105.36 30.53,105.36 29.34,106.55 29.34,108.97 29.97,109.6 37.82,109.6 37.83,109.59 38.85,109.59 39.12,109.86 41.27,109.86 41.91,109.22 42.8,109.22 42.82,109.19 49.81,109.19 50.5,109.88 52.93,109.88 53.8,109.02 58.95,109.02 59.09,108.88 68.35,108.88 68.36,108.88 69.34,108.88 69.55,109.09 85.34,109.09 85.6,108.84 89.15,108.84 92.46,105.54 95.63,105.54 95.89,105.79 98.17,105.79 98.3,105.66 98.3,104.39 96.14,102.23 95.12,102.23 94.87,101.98
19V_DCBATOUT on TOP: 2.39,176 1.96,176.43 1.96,224.25 2.18,224.48 7.97,224.48 17.81,234.31 219.56,234.31 219.56,234.29 220.83,234.29 221.44,233.68 221.44,229.69 221.11,229.36 208.15,229.36 207.65,228.85 207.65,221.49 207.39,221.23 206.25,221.23 205.74,221.74 205.74,228.35 204.72,229.36 195.2,229.36 194.06,228.22 187.96,228.22 186.82,229.36 177.55,229.36 177.19,229.72 172.01,229.72 171.65,229.36 162.46,229.36 162.26,229.57 155.78,229.57 153.29,227.08 153.29,226.64 153.21,226.57 150.24,226.57 149.73,227.08 149.73,228.35 149.28,228.8 121.59,228.8 121.03,229.36 117.22,229.36 116.67,228.82 116.67,225.72 115.27,224.31 106.02,224.31 101.85,228.47 44.58,228.47 40.39,224.28 26.04,224.28 24.38,225.93 14.73,225.93 13.27,224.47 13.27,223.33 4.75,214.81 4.75,206.94 5.31,206.38 5.31,182.01 5.33,181.99 5.33,180.97 7.24,179.07 7.24,176.53 6.71,176 ; 4 cut-outs
19V_DCBATOUT on TOP: 233.17,92.46 232.66,92.96 232.66,127.51 232.28,127.89 232.16,127.89 231.65,128.4 231.65,200.18 229.84,201.98 227.97,201.98 227.97,201.9 227.23,201.9 227.2,201.93 226.21,201.93 226.03,202.11 226.03,204.42 227.08,205.46 227.08,222.38 227.84,223.14 232.82,223.14 233.43,222.53 233.43,222.5 234.44,221.49 234.44,102.23 234.31,102.11 234.31,92.71 234.06,92.46
19V_DCBATOUT on TOP: 217.22,199.21 216.97,199.47 216.97,200.36 217.22,200.61 219.1,200.61 219.1,201.45 219.3,201.65 220.12,201.65 220.4,201.37 220.4,199.47 220.14,199.21
19V_DCBATOUT on TOP: 149.25,3.78 148.34,4.7 148.34,7.62 147.52,8.43 147.52,8.86 147.4,8.99 147.4,11.2 147.45,11.25 148.44,11.25 149.09,10.6 151.04,10.6 151.87,9.78 151.87,5.05 150.6,3.78
19V_DCBATOUT on TOP: 219.35,57.4 218.95,57.81 218.95,60.71 220.09,61.85 225.68,61.85 226.36,61.16 226.36,57.86 225.91,57.4 ; 2 cut-outs
19V_DCBATOUT on BOTTOM: 182.63,11.43 181.48,12.57 181.48,14.35 184.15,17.02 184.15,18.92 184.4,19.18 185.67,19.18 185.93,18.92 185.93,15.62 184.91,14.61 184.15,14.61 183.39,13.84 183.39,11.81 183.01,11.43 ; 3 cut-outs
