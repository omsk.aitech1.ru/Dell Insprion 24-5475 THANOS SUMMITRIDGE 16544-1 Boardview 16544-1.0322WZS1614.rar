# Allegro board 16544-1.0322WZS1614.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PU21  ISL6208BCRZ-GP-U  [DFN8G2-G1710-U1H40]  214.83 202.64 270 top
PU22  TPCA8059-H-GP  [PPAK-8P-1-UH40]  212.67 184.76 270 bottom
PU23  TPCA8059-H-GP  [PPAK-8P-1-UH40]  212.67 184.76 90 top
PU24  TPH6R003NL-GP  [PPAK-8P-1-UH40]  225.68 193.9 270 bottom
PU25  TPH6R003NL-GP  [PPAK-8P-1-UH40]  225.68 193.9 90 top
PU26  ISL6208BCRZ-GP-U  [DFN8G2-G1710-U1H40]  221.13 204.88 0 top
PU27  TPCA8059-H-GP  [PPAK-8P-1-UH40]  227.69 184.84 90 bottom
PU28  TPCA8059-H-GP  [PPAK-8P-1-UH40]  227.69 184.84 270 top
PU29  RT8231AGQW-GP  [QFN20-G1D75H32]  224.41 139.7 270 top
PU32  AOZ2262QI-10-GP-U  [QFN22G4-G2PH42]  151.26 214.88 270 bottom
PU33  SY8288RAC-GP  [QFN20Z3-G1H36]  147.02 17.12 90 top
PU34  SY8288RAC-GP  [QFN20Z3-G1H36]  134.62 108.15 90 top
PU35  SY8246ADNC-1-GP  [DFN12G4030-G360175H34]  10.67 197.87 0 bottom
PU37  APL5930KAI-TRG-1-GP  [SOIC8-G3530H63]  135.86 127.18 90 top
PU38  APL5337KAI-TRG-2-GP  [SOIC8-G3530H63]  125.09 205.87 180 top
PU39  ISL69147IRAZ-T-2-GP  [QFN48J6-G4D55H40]  114.8 148.74 90 top
PU40  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  100.41 118.47 90 top
PU41  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  63.37 118.49 90 top
PU42  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  88.87 118.47 90 top
PU43  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  52.25 118.49 90 top
PU44  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  77.77 118.47 90 top
PU45  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  41.15 118.49 90 top
PU46  ISL99140IRZ-T-GP  [QFN40G6-G3P-2H32]  138.99 222.61 180 top
PU47  SY8286RAC-GP  [QFN20Z3-G1D1H36]  115.21 206.2 270 bottom
PU48  RT8231AGQW-GP  [QFN20-G1D75H32]  9.86 211.2 90 top
PU51  APL5930KAI-TRG-1-GP  [SOIC8-G3530H63]  138.94 69.72 180 top
PU52  2N7002KDW-1-GP  [SOT-363H44]  144.5 215.01 90 bottom
PU53  APL5930KAI-TRG-1-GP  [SOIC8-G3530H63]  139.83 206.76 90 top
PU55  APL5930KAI-TRG-1-GP  [SOIC8-G3530H63]  101.66 161.37 270 top
PU56  APL5930KAI-TRG-1-GP  [SOIC8-G3530H63]  133.22 60.07 90 top
PU57  TPH6R003NL-GP  [PPAK-8P-1-UH40]  19.61 221.49 90 top
PU58  TPCA8059-H-GP  [PPAK-8P-1-UH40]  21.64 213.21 270 top
Q1  DMN5L06K-7-GP  [SOT23DGS2D4H48]  211.16 154.51 0 top
Q8  LMBT3906LT1G-1-GP  [SOT23CBE2D4H44]  113.07 56.96 270 bottom
Q9  DMP2130L-7-GP  [SOT23DGS2D4H48]  99.82 78.08 90 top
Q10  2N7002K-2-GP  [SOT23DGS2D4H44]  97.59 74.4 90 top
Q13  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  98.83 45.36 0 bottom
Q14  2N7002K-2-GP  [SOT23DGS2D4H44]  107.25 48.58 0 bottom
Q15  2N7002KDW-1-GP  [SOT-363H44]  116.27 50.28 180 bottom
Q16  2N7002K-2-GP  [SOT23DGS2D4H44]  183.01 26.14 0 top
Q21  2N7002K-2-GP  [SOT23DGS2D4H44]  92.81 64.77 90 top
Q22  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  97.02 64.7 180 top
Q23  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  208.52 146.52 0 top
Q25  2N7002KDW-1-GP  [SOT-363H44]  214.64 143.04 90 top
Q26  2N7002K-2-GP  [SOT23DGS2D4H44]  200.96 63.91 90 top
Q34  DMP2130L-7-GP  [SOT23DGS2D4H48]  107.59 89.89 90 top
Q35  MMBT3904-4-GP  [SOT23CBE2D4H44]  117.35 104.17 270 top
Q36  LMBT3906LT1G-1-GP  [SOT23CBE2D4H44]  113.61 82.09 270 top
Q37  2N7002K-2-GP  [SOT23DGS2D4H44]  130.33 46.13 270 top
Q41  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  100.09 216.27 0 top
Q42  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  101.16 221.42 0 top
Q43  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  103.66 215.11 0 top
Q44  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  100.99 216.2 0 bottom
Q50  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  119.43 128.04 0 top
Q53  2N7002K-2-GP  [SOT23DGS2D4H44]  128.27 167.39 270 top
Q54  AO3413L-GP  [SOT23DGS2D8H50]  127.89 160.71 90 top
Q55  2N7002K-2-GP  [SOT23DGS2D4H44]  101.6 204.11 90 top
Q67  2N7002K-2-GP  [SOT23DGS2D4H44]  97.28 51.64 180 top
Q68  2N7002K-2-GP  [SOT23DGS2D4H44]  198.2 52.78 180 bottom
Q71  DMN5L06K-7-GP  [SOT23DGS2D4H48]  125.09 42.55 180 bottom
Q72  2N7002KDW-1-GP  [SOT-363H44]  130.94 154.58 180 top
Q75  PJT138KA-GP  [SOT-363H44]  194.41 170.61 270 bottom
Q76  2N7002KDW-1-GP  [SOT-363H44]  122.8 169.16 90 top
Q77  DMN5L06K-7-GP  [SOT23DGS2D4H48]  199.14 182.63 0 top
Q78  2N7002K-2-GP  [SOT23DGS2D4H44]  122.53 46.24 0 top
Q80  AO3409-GP  [SOT23DGS2D8H50]  212.47 148.84 180 bottom
Q81  2N7002KDW-1-GP  [SOT-363H44]  213.36 140.97 270 bottom
Q82  PJA3404-R1-00001-GP  [SOT23DGS2D4H44]  210.95 154.69 180 bottom
Q83  2N7002K-2-GP  [SOT23DGS2D4H44]  124.52 131.44 270 top
Q84  AO3409-GP  [SOT23DGS2D8H50]  124.82 135.29 0 top
Q85  DMN5L06K-7-GP  [SOT23DGS2D4H48]  128.47 133.8 180 top
Q86  PJT138KA-GP  [SOT-363H44]  124.54 111.84 270 top
Q87  AO3409-GP  [SOT23DGS2D8H50]  122.15 115.86 0 top
Q88  PJA3404-R1-00001-GP  [SOT23DGS2D4H44]  125.83 115.89 180 top
R1  196R2F-GP  [R402H16]  146.56 173.41 270 bottom
R2  1KR2F-3-GP  [R402H16]  146.56 174.45 270 bottom
R3  196R2F-GP  [R402H16]  170.66 175.87 0 bottom
R4  200R2F-L-GP  [R402H16]  174.47 174.75 180 bottom
R5  200R2F-L-GP  [R402H16]  151.26 175.39 90 bottom
R6  1KR2F-3-GP  [R402H16]  153.03 177.37 270 bottom
R8  1KR2J-1-GP  [R402H16]  185.9 129.81 270 top
R10  39D2R2F-L-GP  [R402H16]  168.16 147.56 270 bottom
R11  39D2R2F-L-GP  [R402H16]  168.09 145.65 270 bottom
R12  40D2R2F-GP  [R402H16]  161.33 128.01 180 top
R13  40D2R2F-GP  [R402H16]  160.18 128.01 180 top
R14  470R2F-GP  [R402H16]  188.05 127.7 90 top
R15  0R0402-PAD-2-GP  [0R0402-PAD-1]  188.96 128.8 270 top
R16  100KR2J-1-GP  [R402H16]  209.8 151.99 270 top
R17  10KR2J-3-GP  [R402H16]  211.08 157.05 90 top
R18  300R2J-4-GP  [R402H16]  214.76 150.9 90 top
R19  300R2J-4-GP  [R402H16]  214.76 149.12 90 top
R20  1KR2J-1-GP  [R402H16]  214.55 153.23 270 top
R21  1KR2J-1-GP  [R402H16]  195.68 164 270 top
R22  1KR2J-1-GP  [R402H16]  195.94 170.1 270 top
R23  10KR2J-3-GP  [R402H16]  139.32 146.05 90 top
R24  2KR2F-3-GP  [R402H16]  195.45 173.81 270 top
R25  150R2F-1-GP  [R402H16]  195.45 174.82 270 top
R26  100KR2J-1-GP  [R402H16]  195.4 175.92 270 top
R27  10R2F-L-GP  [R402H14]  195.78 165.16 90 top
R28  10R2F-L-GP  [R402H14]  195.73 166.21 90 top
R29  0R0402-PAD-1-GP  [0R0402-PAD]  198.5 167.33 270 bottom
R30  0R0402-PAD-1-GP  [0R0402-PAD]  196.24 168.05 90 bottom
R31  0R0402-PAD-1-GP  [0R0402-PAD]  196.22 166.98 90 bottom
R32  1KR2F-3-GP  [R402H16]  198.87 167.8 180 top
R33  1KR2F-3-GP  [R402H16]  200.13 167.79 180 bottom
R34  10KR2J-3-GP  [R402H16]  137.01 153.97 270 bottom
R35  10KR2J-3-GP  [R402H16]  148.34 62.1 180 top
R36  10KR2J-3-GP  [R402H16]  151.38 62.1 180 top
R37  10KR2J-3-GP  [R402H16]  154.94 156.82 90 bottom
R38  8K2R2J-3-GP  [R402H16]  134.8 150.11 0 top
R39  10KR2J-3-GP  [R402H16]  155.5 160.3 180 bottom
R40  10KR2J-3-GP  [R402H16]  154.81 62.1 180 top
R43  10KR2J-3-GP  [R402H16]  138.75 158.99 90 bottom
R44  10KR2J-3-GP  [R402H16]  148.33 182.11 90 bottom
R45  20MR2J-GP  [R402H16]  141.54 170.14 0 top
R52  10KR2J-3-GP  [R402H16]  145.11 155.32 90 bottom
R53  1KR2J-1-GP  [R402H16]  134.25 172.28 90 top
R54  1KR2J-1-GP  [R402H16]  136.75 173.41 0 top
R55  10KR2J-3-GP  [R402H16]  143.69 175.56 90 bottom
R56  10KR2J-3-GP  [R402H16]  131.13 169.56 270 top
R57  15KR2J-1-GP  [R402H16]  152.72 180.67 270 bottom
R58  15KR2J-1-GP  [R402H16]  151.13 176.71 90 bottom
R59  15KR2J-1-GP  [R402H16]  151.26 174.37 90 bottom
R61  33R2J-2-GP  [R402H16]  135.71 173.41 0 top
R64  33R2J-2-GP  [R402H16]  134.25 173.32 90 top
R65  33R2J-2-GP  [R402H16]  131.12 170.6 90 top
R69  33R2J-2-GP  [R402H16]  138.4 149.48 0 bottom
R70  10KR2J-3-GP  [R402H16]  150.95 161.59 90 bottom
R79  10KR2J-3-GP  [R402H16]  157.07 159.66 90 bottom
R80  10KR2J-3-GP  [R402H16]  137.01 155.02 270 bottom
R81  1MR2F-GP  [R402H16]  142.28 176.58 180 top
R82  10KR2J-3-GP  [R402H16]  153.42 57.4 0 bottom
R83  10KR2J-3-GP  [R402H16]  145.77 167.47 90 bottom
R84  1KR2F-3-GP  [R402H16]  160.47 173.94 0 bottom
R85  11K8R2F-GP  [R402H16]  154.72 171.49 90 bottom
R86  200R2F-L-GP  [R402H16]  161.8 184.28 180 bottom
R90  1KR2F-3-GP  [R402H16]  160.02 184.53 90 bottom
R92  33R2J-2-GP  [R402H16]  135.51 155.32 90 top
R93  33R2J-2-GP  [R402H16]  139.06 154.69 90 top
R94  33R2J-2-GP  [R402H16]  131.98 100.74 180 top
R95  33R2J-2-GP  [R402H16]  133.07 94.74 90 bottom
R96  33R2J-2-GP  [R402H16]  133.3 100.74 180 top
R98  0R2J-2-GP  [R402H16]  145.26 109.42 180 bottom
R99  0R2J-2-GP  [R402H16]  145.21 107.44 0 bottom
R100  0R2J-2-GP  [R402H16]  172.7 104.69 180 bottom
R102  0R0402-PAD-2-GP  [0R0402-PAD-1]  146.33 109.42 0 bottom
R103  0R0402-PAD-2-GP  [0R0402-PAD-1]  146.3 107.42 180 bottom
R104  0R0402-PAD-2-GP  [0R0402-PAD-1]  173.76 104.68 0 bottom
R107  1KR2F-3-GP  [R402H16]  179.58 105.03 90 bottom
R108  1KR2F-3-GP  [R402H16]  177.93 104.78 0 bottom
R109  240R2F-1-GP  [R402H16]  192.93 113.7 270 bottom
R110  240R2F-1-GP  [R402H16]  192.94 108.64 270 bottom
R111  0R2J-2-GP  [R402H16]  161.54 84.96 0 top
R112  0R0402-PAD-2-GP  [0R0402-PAD-1]  159.26 85.47 0 top
R113  0R2J-2-GP  [R402H16]  171.96 86.23 0 top
R114  0R0402-PAD-2-GP  [0R0402-PAD-1]  161.16 86.61 90 top
R115  0R2J-2-GP  [R402H16]  158.12 85.47 180 top
R116  0R0402-PAD-2-GP  [0R0402-PAD-1]  169.8 86.23 180 top
R117  1KR2F-3-GP  [R402H16]  175.9 86.23 180 top
R118  1KR2F-3-GP  [R402H16]  172.97 86.23 180 top
R119  240R2F-1-GP  [R402H16]  192.34 96.86 180 bottom
R120  240R2F-1-GP  [R402H16]  192.34 94.96 0 bottom
R121  10KR2J-3-GP  [R402H16]  138.56 156.46 0 top
R122  200KR2J-L1-GP  [R402H16]  168.28 58.67 0 top
R123  1KR2J-1-GP  [R402H16]  169.42 58.67 0 top
R124  10KR2J-3-GP  [R402H16]  147.85 162.05 180 bottom
R125  1KR2J-1-GP  [R402H16]  175.64 57.15 270 top
R126  200KR2J-L1-GP  [R402H16]  175.64 56.01 270 top
R127  1KR2J-1-GP  [R402H16]  174.32 54.64 180 bottom
R128  10KR2J-3-GP  [R402H16]  141.68 149 0 top
R129  200KR2J-L1-GP  [R402H16]  174.73 53.14 90 bottom
R130  10KR2J-3-GP  [R402H16]  139.32 145.03 270 top
R131  10KR2J-3-GP  [R402H16]  147.91 179.37 0 bottom
R132  1KR2J-1-GP  [R402H16]  174.12 55.37 0 top
R133  200KR2J-L1-GP  [R402H16]  175.64 54.86 270 top
R134  100KR2J-1-GP  [R402H16]  139.32 144.02 270 top
R135  1KR2J-1-GP  [R402H16]  173.74 50.67 270 bottom
R136  200KR2J-L1-GP  [R402H16]  174.85 51.71 90 bottom
R137  2KR2J-1-GP  [R402H16]  149.02 179.35 180 bottom
R138  1KR2J-1-GP  [R402H16]  172.34 48.39 270 bottom
R139  200KR2J-L1-GP  [R402H16]  174.68 48.11 90 bottom
R140  200KR2J-L1-GP  [R402H16]  154.43 57.4 180 bottom
R141  200KR2J-L1-GP  [R402H16]  153.67 62.1 0 top
R142  1KR2J-1-GP  [R402H16]  152.53 62.1 0 top
R143  200KR2J-L1-GP  [R402H16]  152.4 57.4 180 bottom
R144  2KR2J-1-GP  [R402H16]  141.45 158.01 90 top
R145  1KR2J-1-GP  [R402H16]  174.45 33.3 270 top
R146  200KR2J-L1-GP  [R402H16]  156.46 57.4 180 bottom
R147  20KR2J-L2-GP  [R402H16]  158.24 59.69 0 top
R148  200KR2J-L1-GP  [R402H16]  155.45 57.4 180 bottom
R149  20KR2J-L2-GP  [R402H16]  157.1 59.69 0 top
R150  200KR2J-L1-GP  [R402H16]  174.68 49.38 90 bottom
R151  1KR2J-1-GP  [R402H16]  170.56 58.67 0 top
R152  12K1R2F-L1-GP  [R402H16]  161.54 59.69 0 top
R153  10KR2J-3-GP  [R402H16]  160.02 30.68 0 bottom
R154  4K7R2J-2-GP  [R402H16]  164.47 62.87 0 top
R155  200KR2J-L1-GP  [R402H16]  149.48 62.1 0 top
R156  200KR2J-L1-GP  [R402H16]  149.91 64.06 0 top
R157  200KR2J-L1-GP  [R402H16]  151.38 57.4 180 bottom
R158  200KR2J-L1-GP  [R402H16]  151.05 64.06 0 top
R159  4K7R2J-2-GP  [R402H16]  175.9 32.87 180 top
R160  0R2J-2-GP  [R402H16]  147.02 35.43 270 bottom
R161  0R0402-PAD-2-GP  [0R0402-PAD-1]  166.12 39.37 270 bottom
R162  0R0402-PAD-2-GP  [0R0402-PAD-1]  147.02 36.58 270 bottom
R163  10KR2J-3-GP  [R402H16]  175.64 53.21 270 top
R164  0R0402-PAD-2-GP  [0R0402-PAD-1]  175.64 52.2 270 top
R169  12K1R2F-L1-GP  [R402H16]  159.38 34.8 180 bottom
R170  1MR2J-1-GP  [R402H16]  169.29 30.23 0 top
R171  100KR2F-L1-GP  [R402H16]  118.08 64.52 180 top
R172  10KR2F-2-GP  [R402H16]  122.24 64.41 270 top
R173  0R0402-PAD-1-GP  [0R0402-PAD]  117.53 62.57 0 bottom
R175  200KR2J-L1-GP  [R402H16]  116.52 62.57 0 bottom
R177  100KR2F-L1-GP  [R402H16]  120.03 64.53 180 top
R178  100KR2F-L1-GP  [R402H16]  122.29 62.24 90 top
R179  1KR2J-1-GP  [R402H16]  116.42 61.07 90 bottom
R181  10KR2F-2-GP  [R402H16]  115.95 58.24 270 bottom
R182  0R2J-2-GP  [R402H16]  115.52 56.57 180 bottom
R183  -  [0R0603-PAD]  116.83 65.94 180 top
R184  2D2R3-1-U-GP  [R603H22]  97.16 56.39 270 top
R191  330KR2J-L1-GP  [R402H16]  101.19 75.04 180 top
R193  1KR2J-1-GP  [R402H16]  101.14 73 180 top
R194  20KR2F-L-GP  [R402H16]  100.04 75.04 180 top
R199  10KR2F-2-GP  [R402H16]  96.95 76.81 270 top
R204  0R2J-2-GP  [R402H16]  99.85 51.1 90 bottom
R228  NTC-100K-8-GP  [NTC-603H38]  99.75 49.17 90 top
R230  -  [0R0402-PAD]  108.61 46.16 90 bottom
R231  18K7R2F-GP  [R402H16]  111.73 53.51 180 bottom
R232  0R2J-2-GP  [R402H16]  105.93 51.47 0 bottom
R233  2KR2F-3-GP  [R402H16]  109.63 49.86 180 bottom
R235  0R0402-PAD-2-GP  [0R0402-PAD-1]  109.86 78.36 0 top
R237  0R0402-PAD-1-GP  [0R0402-PAD]  117.98 58.27 90 bottom
R239  100KR2J-1-GP  [R402H16]  122.45 48.64 90 top
R243  1KR2J-1-GP  [R402H16]  140.56 100.31 90 top
R244  0R2J-2-GP  [R402H16]  133.07 87.15 180 top
R246  1KR2J-1-GP  [R402H16]  179.14 23.44 180 top
R247  10MR2J-L-GP  [R402H16]  180.22 23.43 0 top
R248  1KR2J-1-GP  [R402H16]  128.57 43.69 90 top
R251  2K2R2J-2-GP  [R402H16]  10.29 167.26 90 top
R253  100R2F-L1-GP-U  [R402H14]  12.32 167.26 270 top
R254  4K7R2J-2-GP  [R402H16]  14.61 175.01 270 top
R257  20KR2J-L2-GP  [R402H16]  14.61 176.15 90 top
R258  0R0402-PAD-2-GP  [0R0402-PAD-1]  16.89 174.88 90 top
R260  8K2R2F-1-GP  [R402H16]  16.89 175.9 270 top
R269  0R3J-0-U-GP  [R603H22]  212.57 37.8 180 bottom
R271  1KR3F-GP  [R603H22]  206.63 46.99 0 bottom
R272  10KR3J-L1-GP  [R603H22]  204.15 44.17 90 bottom
R273  0R3J-0-U-GP  [R603H22]  198.73 34.14 90 bottom
R274  1KR3F-GP  [R603H22]  198.32 40.61 270 bottom
R275  22R3F-GP  [R603H22]  209.02 38.15 90 top
R277  0R2J-2-GP  [R402H16]  193.13 39.42 270 top
R278  22R3F-GP  [R603H22]  210.25 35.77 90 top
R282  100KR3F-GP  [R603H22]  203.08 34.35 0 top
R283  2K2R3F-GP  [R603H22]  207.02 35.71 270 bottom
R284  2K2R3F-GP  [R603H22]  207.04 36.93 270 bottom
R286  0R2J-2-GP  [R402H16]  199.78 34.35 0 top
R289  2D2R2J-GP  [R402H16]  204.36 49.53 180 top
R290  2D2R2J-GP  [R402H16]  202.69 50.02 90 top
R291  100KR3F-GP  [R603H22]  204.55 34.85 180 top
R293  200KR3F-GP  [R603H22]  206.98 34.82 0 top
R294  100KR3F-GP  [R603H22]  205.79 33.48 0 top
R297  33R3F-L-GP  [R603H22]  201.88 33.57 0 top
R298  33R3F-L-GP  [R603H22]  197.74 35.1 270 top
R301  33R3F-L-GP  [R603H22]  194.06 36.98 270 top
R302  33R3F-L-GP  [R603H22]  193.83 38.15 270 top
R304  22KR3F-GP  [R603H22]  220.98 42.51 180 bottom
R305  22KR3F-GP  [R603H22]  218.95 38.73 90 bottom
R309  10R3J-3-GP  [R603H22]  206.02 15.75 0 top
R310  10R3J-3-GP  [R603H22]  218.39 14.81 0 bottom
R311  10R3J-3-GP  [R603H22]  209.63 13.87 180 bottom
R312  10R3J-3-GP  [R603H22]  211.99 14.53 180 top
R313  22K1R2F-L-GP  [R402H16]  215.71 23.65 270 bottom
R314  0R2J-2-GP  [R402H16]  220.57 24.21 270 top
R315  0R0402-PAD-2-GP  [0R0402-PAD-1]  219.07 23.64 0 top
R316  -  [0R0603-PAD]  210.34 28.3 180 bottom
R319  10R3J-3-GP  [R603H22]  189.48 16.54 0 top
R320  10R3J-3-GP  [R603H22]  202.06 16.51 90 bottom
R321  10R3J-3-GP  [R603H22]  194.51 15.54 180 bottom
R322  10R3J-3-GP  [R603H22]  197.05 14.73 270 top
R323  22K1R2F-L-GP  [R402H16]  199.06 25.15 270 bottom
R324  0R2J-2-GP  [R402H16]  203.78 25.78 90 top
R325  0R2J-2-GP  [R402H16]  202.31 24.43 0 top
R326  0R3J-0-U-GP  [R603H22]  197.51 28.88 270 bottom
R332  0R0402-PAD-2-GP  [0R0402-PAD-1]  223.65 20.45 180 top
R333  0R0402-PAD-2-GP  [0R0402-PAD-1]  224.03 7.32 270 top
R335  0R0402-PAD-2-GP  [0R0402-PAD-1]  226.31 11.91 180 top
R336  10KR2J-3-GP  [R402H16]  220.88 11.02 0 top
R337  0R0402-PAD-2-GP  [0R0402-PAD-1]  225.07 12.19 0 top
R338  0R0402-PAD-2-GP  [0R0402-PAD-1]  220.47 12.6 270 top
R339  100KR2J-1-GP  [R402H16]  221.95 11.02 180 top
R340  51KR2F-L-GP  [R402H16]  222.53 21.56 180 top
R341  22K1R2F-L-GP  [R402H16]  221.39 21.56 180 top
R342  0R2J-2-GP  [R402H16]  179.45 12.19 90 bottom
R343  0R0402-PAD-2-GP  [0R0402-PAD-1]  177.93 12.57 180 bottom
R345  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.41 37.08 0 top
R346  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.17 46.86 180 top
R347  10KR2J-3-GP  [R402H16]  172.49 11.76 0 bottom
R349  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.1 46.86 180 top
R350  15KR2F-GP  [R402H16]  174.47 11.73 180 bottom
R351  10KR2J-3-GP  [R402H16]  99.9 46.99 90 top
R352  0R0402-PAD-2-GP  [0R0402-PAD-1]  96.09 46.86 180 top
R353  0R0402-PAD-2-GP  [0R0402-PAD-1]  103.05 43.43 90 top
R354  100KR2J-1-GP  [R402H16]  99.9 45.97 270 top
R355  51KR2F-L-GP  [R402H16]  98.93 37.72 0 top
R356  22K1R2F-L-GP  [R402H16]  100.46 37.85 270 top
R357  0R2J-2-GP  [R402H16]  182.6 8.41 270 top
R358  0R0402-PAD-2-GP  [0R0402-PAD-1]  180.19 9.8 270 top
R359  10KR2J-3-GP  [R402H16]  180.7 6.68 270 top
R360  15KR2F-GP  [R402H16]  180.7 5.11 0 top
R365  0R3J-0-U-GP  [R603H22]  223.37 68.4 0 top
R366  0R3J-0-U-GP  [R603H22]  221.34 57.1 0 top
R367  10KR2J-3-GP  [R402H16]  104.27 41.73 180 top
R368  10KR2F-2-GP  [R402H16]  134.16 153.85 180 top
R369  10KR2F-2-GP  [R402H16]  129.79 151.31 90 top
R372  24K9R2F-L-GP  [R402H16]  118.77 66.6 90 top
R374  0R2J-2-GP  [R402H16]  209.52 226.8 0 top
R375  100KR2J-1-GP  [R402H16]  215.95 228.27 270 top
R377  0R3J-0-U-GP  [R603H22]  136.91 202.18 0 top
R378  0R3J-0-U-GP  [R603H22]  138.3 202.18 0 top
R379  100KR2F-L1-GP  [R402H16]  128.91 202.44 180 top
R380  100KR2J-1-GP  [R402H16]  24.66 125.68 270 bottom
R381  10KR3J-L1-GP  [R603H22]  33.8 112.96 90 top
R382  56KR3F-GP  [R603H22]  25.28 116.17 270 top
R383  1K5R2J-3-GP  [R402H16]  99.82 68.2 180 top
R384  33R2J-2-GP  [R402H16]  99.82 70.1 0 top
R385  10KR2J-3-GP  [R402H16]  94.46 61.95 270 top
R386  100KR2J-1-GP  [R402H16]  91.87 62.38 90 top
R387  15KR2F-GP  [R402H16]  94.34 60.48 90 top
R388  10KR2J-3-GP  [R402H16]  207.31 141.88 270 top
R389  10KR2J-3-GP  [R402H16]  209.34 149.24 270 top
R390  10KR2J-3-GP  [R402H16]  211.58 142.75 270 top
R391  -  [0R0402-PAD]  205.19 143.87 90 top
R392  1KR2J-1-GP  [R402H16]  207.22 142.96 90 top
R393  10KR2J-3-GP  [R402H16]  218.67 135.08 90 top
R396  0R0402-PAD-2-GP  [0R0402-PAD-1]  227.58 148.59 0 top
R399  10KR2J-3-GP  [R402H16]  217.93 143.26 270 top
R400  10R6J-1-GP  [R1206H28]  213.87 139.06 180 top
R403  10KR2F-2-GP  [R402H16]  17.43 132.13 270 top
R406  -  [0R0805-PAD]  88.16 17.25 180 top
R407  -  [0R0805-PAD]  86.13 17.25 180 top
R412  0R2J-2-GP  [R402H16]  197.94 57.78 90 top
R414  10KR2J-3-GP  [R402H16]  198.09 63.96 90 top
R415  100KR2J-1-GP  [R402H16]  201.02 61.42 270 top
R416  10KR2J-3-GP  [R402H16]  204.44 64.82 180 top
R417  -  [0R0402-PAD]  203.38 64.82 180 top
R419  -  [0R0805-PAD]  189.97 64.47 90 top
R421  10KR2J-3-GP  [R402H16]  189.15 39.01 270 top
R430  10KR2J-3-GP  [R402H16]  99.82 61.59 90 top
R431  0R0402-PAD-2-GP  [0R0402-PAD-1]  102.16 87.88 0 top
R432  0R0402-PAD-2-GP  [0R0402-PAD-1]  101.14 87.88 0 top
R433  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.13 87.88 0 top
R434  0R0402-PAD-2-GP  [0R0402-PAD-1]  99.11 87.88 0 top
R435  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.07 87.88 0 top
R436  0R2J-2-GP  [R402H16]  106.83 87.58 90 top
R437  0R0402-PAD-2-GP  [0R0402-PAD-1]  104.93 89.23 0 top
R438  0R0402-PAD-2-GP  [0R0402-PAD-1]  110.11 86.64 90 top
R439  0R2J-2-GP  [R402H16]  111.91 89.99 0 top
R440  10KR2J-3-GP  [R402H16]  111.84 103.38 180 top
R442  1KR2F-3-GP  [R402H16]  113.79 103.89 0 top
R443  10KR2J-3-GP  [R402H16]  125.4 97.79 0 top
R451  10KR2F-2-GP  [R402H16]  11.02 136.35 270 top
R452  33R2J-2-GP  [R402H16]  11.02 135.33 90 top
R453  4K7R2J-2-GP  [R402H16]  116.43 83.92 90 top
R454  -  [0R0402-PAD]  122.05 85.98 90 top
R455  10KR2F-2-GP  [R402H16]  110.16 80.7 0 top
R456  10KR2J-3-GP  [R402H16]  130.99 53.37 180 top
R457  1KR2J-1-GP  [R402H16]  110.79 82.6 0 top
R458  10KR2J-3-GP  [R402H16]  129.03 78.99 270 top
R459  1KR2J-1-GP  [R402H16]  116.15 81.61 180 top
R464  10KR2J-3-GP  [R402H16]  127.94 45.85 0 top
R475  200R2F-L-GP  [R402H16]  76.01 170.79 90 bottom
R476  1KR2F-3-GP  [R402H16]  108.24 206.6 90 top
R478  4K7R2F-GP  [R402H16]  97.78 208.24 0 bottom
R479  4K7R2F-GP  [R402H16]  96.71 208.24 0 bottom
R480  10KR2F-2-GP  [R402H16]  103.67 224.29 0 top
R481  10KR2F-2-GP  [R402H16]  101.61 205.37 270 bottom
R482  10KR2F-2-GP  [R402H16]  95.67 208.24 0 bottom
R483  10KR2F-2-GP  [R402H16]  100.49 224.52 180 top
R484  1KR2F-3-GP  [R402H16]  101.97 223.89 90 top
R485  0R0402-PAD-2-GP  [0R0402-PAD-1]  103.47 222.34 180 top
R486  5K1R2-GP  [R402H16]  99.43 224.52 0 top
R487  1KR2F-3-GP  [R402H16]  101.23 218.68 270 top
R489  1KR2F-3-GP  [R402H16]  103.59 215.56 180 bottom
R490  1KR2F-3-GP  [R402H16]  103.87 218.1 180 top
R491  10KR2F-2-GP  [R402H16]  104.74 223.1 180 top
R492  20KR2F-L-GP  [R402H16]  102.23 213.23 180 bottom
R494  10KR2F-2-GP  [R402H16]  95.5 166.31 180 top
R495  100KR2F-L1-GP  [R402H16]  93.97 165.8 270 top
R496  0R0402-PAD-2-GP  [0R0402-PAD-1]  94.02 166.87 90 top
R504  10KR2F-2-GP  [R402H16]  79.12 164.21 270 bottom
R505  5K1R2-GP  [R402H16]  105.28 204.71 180 bottom
R506  5K1R2-GP  [R402H16]  104.22 204.71 180 bottom
R507  5K1R2-GP  [R402H16]  94.81 204.69 0 top
R508  5K1R2-GP  [R402H16]  94.32 205.17 270 bottom
R509  5K1R2-GP  [R402H16]  106.85 204.14 270 bottom
R510  5K1R2-GP  [R402H16]  106.85 205.21 90 bottom
R511  10KR2F-2-GP  [R402H16]  74.64 160.62 90 bottom
R512  10KR2F-2-GP  [R402H16]  75.27 159.12 180 bottom
R513  33R2F-3-GP  [R402H16]  74.23 159.12 0 bottom
R514  33R2F-3-GP  [R402H16]  73.19 160.11 180 bottom
R515  5K1R2-GP  [R402H16]  110.74 162.43 90 top
R516  5K1R2-GP  [R402H16]  110.74 161.42 270 top
R517  5K1R2-GP  [R402H16]  119.89 158.37 90 top
R518  5K1R2-GP  [R402H16]  119.89 159.51 270 top
R519  5K11R2F-L1-GP  [R402H16]  96.9 204.36 180 bottom
R520  5K1R2-GP  [R402H16]  113.57 189.46 90 top
R521  5K1R2-GP  [R402H16]  112.12 188.7 180 top
R522  10KR2F-2-GP  [R402H16]  95.85 204.36 180 top
R523  1KR2J-1-GP  [R402H16]  96.89 204.36 180 top
R524  5K1R2-GP  [R402H16]  112.03 191.21 0 top
R525  5K1R2-GP  [R402H16]  113.54 190.53 90 top
R526  10KR2F-2-GP  [R402H16]  95.85 204.36 0 bottom
R527  5K1R2-GP  [R402H16]  114.23 187.98 180 top
R528  5K1R2-GP  [R402H16]  112.41 186.69 0 top
R531  5K1R2-GP  [R402H16]  102.36 212.6 270 top
R532  5K1R2-GP  [R402H16]  100.88 208.22 180 bottom
R533  5K1R2-GP  [R402H16]  109.39 165.9 90 top
R534  5K1R2-GP  [R402H16]  107.48 165.9 90 top
R535  5K1R2-GP  [R402H16]  98.82 208.24 180 bottom
R536  5K1R2-GP  [R402H16]  99.44 212.72 270 top
R538  0R0402-PAD-2-GP  [0R0402-PAD-1]  62.34 185.84 180 bottom
R541  5K1R2-GP  [R402H16]  32.68 136.44 0 top
R542  5K1R2-GP  [R402H16]  32.68 136.93 180 bottom
R543  5K1R2-GP  [R402H16]  31.53 136.41 0 top
R544  5K1R2-GP  [R402H16]  31.53 136.92 180 bottom
R545  5K1R2-GP  [R402H16]  30.39 136.39 0 top
R546  5K1R2-GP  [R402H16]  30.39 136.89 180 bottom
R547  5K1R2-GP  [R402H16]  29.1 136.39 0 top
R548  5K1R2-GP  [R402H16]  29.09 136.89 180 bottom
R549  5K1R2-GP  [R402H16]  27.95 136.39 0 top
R550  5K1R2-GP  [R402H16]  27.95 136.89 180 bottom
R551  5K1R2-GP  [R402H16]  26.76 136.39 180 top
R552  5K1R2-GP  [R402H16]  113.27 165.34 0 top
R553  5K1R2-GP  [R402H16]  26.76 136.89 180 bottom
R559  0R2F-1-GP  [R402H16]  113.39 161.82 180 top
R560  5K1R2-GP  [R402H16]  97.41 149.61 180 top
R561  33R2F-3-GP  [R402H16]  95.5 154.43 270 top
R562  5K1R2-GP  [R402H16]  96.39 149.61 0 top
R563  0R2J-2-GP  [R402H16]  92.08 156.97 0 top
R584  100KR2J-1-GP  [R402H16]  130.68 164.47 180 top
R586  0R5J-5-GP  [R805H24]  128.02 163.5 90 top
R602  4K7R2J-2-GP  [R402H16]  114.27 123.61 90 top
R603  2K2R2J-2-GP  [R402H16]  116.35 124.61 180 top
R604  100KR2F-L1-GP  [R402H16]  118.92 124.16 90 top
R610  120R2F-GP  [R402H16]  93.79 204.33 180 top
R611  40D2R2F-GP  [R402H16]  78.32 186.59 90 bottom
R612  120R2F-GP  [R402H16]  62.01 188.22 180 bottom
R613  40D2R2F-GP  [R402H16]  66.99 188.68 180 bottom
R614  100R2J-2-GP  [R402H14]  77.84 187.6 270 bottom
R615  100R2J-2-GP  [R402H14]  68.34 187.23 270 bottom
R616  49D9R2F-GP  [R402H16]  41.9 207.92 90 top
R617  10R2F-L-GP  [R402H14]  42.82 206.36 0 top
R618  5K1R2-GP  [R402H16]  43.87 206.39 180 top
R619  40D2R2F-GP  [R402H16]  62.74 183.3 180 bottom
R620  40D2R2F-GP  [R402H16]  62.42 175.65 0 bottom
R621  120R2F-GP  [R402H16]  60.41 187.97 90 bottom
R622  120R2F-GP  [R402H16]  68.08 172.58 90 bottom
R623  100R2J-2-GP  [R402H14]  62.72 181.41 180 bottom
R624  100R2J-2-GP  [R402H14]  63.46 175.65 180 bottom
R625  49D9R2F-GP  [R402H16]  47.99 158.15 270 bottom
R626  10R2F-L-GP  [R402H14]  48.91 160.8 0 bottom
R627  5K1R2-GP  [R402H16]  50.03 160.84 180 bottom
R628  60D4R2F-GP  [R402H16]  26.24 161.52 180 bottom
R629  60D4R2F-GP  [R402H16]  27.3 161.52 180 bottom
R630  60D4R2F-GP  [R402H16]  51.37 223.27 270 bottom
R631  60D4R2F-GP  [R402H16]  51.37 222.25 270 bottom
R632  60D4R2F-GP  [R402H16]  69.97 223.73 90 bottom
R633  60D4R2F-GP  [R402H16]  69.97 222.7 90 bottom
R634  1KR2F-3-GP  [R402H16]  28.32 160.85 180 bottom
R635  1KR2F-3-GP  [R402H16]  51.37 221.23 270 bottom
R636  120R2F-GP  [R402H16]  27.85 168.37 90 bottom
R637  120R2F-GP  [R402H16]  44.37 221.64 90 bottom
R638  1KR2F-3-GP  [R402H16]  30.55 154.98 270 bottom
R639  1KR2F-3-GP  [R402H16]  58.03 219.67 180 bottom
R640  1KR2F-3-GP  [R402H16]  69.66 221.68 90 bottom
R641  120R2F-GP  [R402H16]  79.31 220.4 270 bottom
R642  1KR2F-3-GP  [R402H16]  63.78 219.73 180 bottom
R643  2K37R2F-GP  [R402H16]  77.75 222.59 0 bottom
R644  2K37R2F-GP  [R402H16]  44.5 225.61 270 bottom
R645  2K37R2F-GP  [R402H16]  25.98 169.62 180 bottom
R646  5K49R2F-GP  [R402H16]  79.33 221.46 270 bottom
R647  5K49R2F-GP  [R402H16]  27.85 170.37 90 bottom
R648  5K49R2F-GP  [R402H16]  43.62 222.68 270 bottom
R661  60D4R2F-GP  [R402H16]  55.94 144.4 90 bottom
R662  60D4R2F-GP  [R402H16]  55.94 145.41 90 bottom
R663  1KR2F-3-GP  [R402H16]  53.92 144.18 180 bottom
R664  120R2F-GP  [R402H16]  60.11 143.42 180 bottom
R665  1KR2F-3-GP  [R402H16]  49.48 148.55 0 bottom
R666  2K37R2F-GP  [R402H16]  63.1 143.31 90 bottom
R667  5K49R2F-GP  [R402H16]  63.58 145.87 180 bottom
R672  60D4R2F-GP  [R402H16]  88.35 223.38 270 bottom
R673  60D4R2F-GP  [R402H16]  104.53 193.95 0 bottom
R674  60D4R2F-GP  [R402H16]  105.56 193.94 0 bottom
R675  60D4R2F-GP  [R402H16]  88.35 222.35 270 bottom
R676  60D4R2F-GP  [R402H16]  26.67 198.69 180 bottom
R677  60D4R2F-GP  [R402H16]  27.69 198.69 180 bottom
R678  1KR2F-3-GP  [R402H16]  103.5 193.95 0 bottom
R679  1KR2F-3-GP  [R402H16]  90.87 222.04 180 bottom
R680  120R2F-GP  [R402H16]  106.22 189.02 270 bottom
R681  120R2F-GP  [R402H16]  83.35 223.58 0 bottom
R682  1KR2F-3-GP  [R402H16]  28.7 198.69 180 bottom
R683  1KR2F-3-GP  [R402H16]  101.52 200.52 90 bottom
R684  1KR2F-3-GP  [R402H16]  95.03 219.35 180 bottom
R685  120R2F-GP  [R402H16]  26.85 200.75 270 bottom
R686  1KR2F-3-GP  [R402H16]  30.33 191.97 270 bottom
R687  2K37R2F-GP  [R402H16]  105.89 186.8 0 bottom
R688  2K37R2F-GP  [R402H16]  81.09 225.3 270 bottom
R689  5K49R2F-GP  [R402H16]  104.08 186.44 270 bottom
R690  5K49R2F-GP  [R402H16]  81.88 222.28 0 bottom
R691  2K37R2F-GP  [R402H16]  25.22 203.7 90 bottom
R692  5K49R2F-GP  [R402H16]  28.32 204.53 180 bottom
R705  60D4R2F-GP  [R402H16]  27.43 180.02 0 bottom
R706  60D4R2F-GP  [R402H16]  26.42 180.02 0 bottom
R707  1KR2F-3-GP  [R402H16]  28.45 180.02 0 bottom
R708  120R2F-GP  [R402H16]  25.01 175.03 90 bottom
R709  1KR2F-3-GP  [R402H16]  30.31 186.3 270 bottom
R710  2K37R2F-GP  [R402H16]  25.98 171.9 0 bottom
R711  5K49R2F-GP  [R402H16]  27.87 173.47 90 bottom
R718  200R2F-L-GP  [R402H16]  81.4 170.53 180 bottom
R719  200R2F-L-GP  [R402H16]  84.41 164.28 90 bottom
R720  150R2F-1-GP  [R402H16]  72.39 162.48 180 bottom
R721  33R2J-2-GP  [R402H16]  226.16 150.11 180 top
R722  10KR2J-3-GP  [R402H16]  228.35 151.36 270 top
R723  10KR2J-3-GP  [R402H16]  227.94 153.54 180 top
R724  10KR2J-3-GP  [R402H16]  229.08 154.43 180 top
R725  33R2J-2-GP  [R402H16]  214.6 155.27 270 top
R861  0R0402-PAD-2-GP  [0R0402-PAD-1]  141.35 11.18 180 top
R870  0R3J-0-U-GP  [R603H22]  135.51 202.44 0 top
R871  0R3J-0-U-GP  [R603H22]  134.24 202.44 0 top
R872  10R3J-3-GP  [R603H22]  187.78 22.23 0 bottom
R873  0R0402-PAD-2-GP  [0R0402-PAD-1]  222.12 8.43 270 top
R1129  8K2R2J-3-GP  [R402H16]  130.81 161.67 270 top
R1195  39K2R2F-L-GP  [R402H16]  131.32 160.15 0 top
R1196  8K25R2F-1-GP  [R402H16]  108.92 203.94 90 top
R1197  15KR2F-GP  [R402H16]  105.71 205.64 0 top
R1198  3KR2F-GP  [R402H16]  105.99 204.09 90 top
R1200  1K5R2F-2-GP  [R402H16]  105.84 207.19 270 top
R1201  10KR2F-2-GP  [R402H16]  104.04 204.9 0 top
R1202  0R2J-2-GP  [R402H16]  107.49 202.82 270 top
R1210  100KR2F-L1-GP  [R402H16]  79.25 166.12 270 bottom
R1213  200R2F-L-GP  [R402H16]  152.02 179.58 270 bottom
R1214  200R2F-L-GP  [R402H16]  157.23 177.55 270 bottom
R1215  200R2F-L-GP  [R402H16]  156.72 183.9 270 bottom
R1217  1KR2J-1-GP  [R402H16]  122.17 196.6 180 top
R1218  0R0402-PAD-2-GP  [0R0402-PAD-1]  146.3 41.43 180 bottom
R1219  0R0402-PAD-2-GP  [0R0402-PAD-1]  195.37 59.62 270 top
R1220  0R0402-PAD-2-GP  [0R0402-PAD-1]  195.37 60.76 90 top
R1222  24K9R2F-L-GP  [R402H16]  114.03 67.03 180 top
R1223  NTC-100K-8-GP  [NTC-603H38]  203.63 209.7 180 top
R1224  NTC-100K-8-GP  [NTC-603H38]  158.45 71.35 0 top
R1225  33R2J-2-GP  [R402H16]  11.01 134.31 270 top
R1226  4K7R2J-2-GP  [R402H16]  11.51 136.78 0 bottom
R1227  0R2J-2-GP  [R402H16]  208.49 157.82 270 top
R1228  0R2J-2-GP  [R402H16]  202.64 155.44 90 top
R1229  0R2J-2-GP  [R402H16]  202.28 153.78 0 top
R1230  0R2J-2-GP  [R402H16]  205.19 152.1 270 top
R1231  1KR2J-1-GP  [R402H16]  201.91 152.31 270 top
R1232  1KR2J-1-GP  [R402H16]  203.55 151.62 0 top
R1233  0R0402-PAD-2-GP  [0R0402-PAD-1]  207.68 153.82 180 top
R1235  1KR2J-1-GP  [R402H16]  147.17 157.2 270 bottom
R2411  1KR2J-1-GP  [R402H16]  146.3 41.27 0 top
R2412  -  [0R0603-PAD]  122.55 55.64 270 top
R2413  -  [0R0603-PAD]  96.42 63.17 180 bottom
R2414  -  [0R0603-PAD]  100.15 80.7 90 top
R2416  0R0402-PAD-2-GP  [0R0402-PAD-1]  97 54.03 270 top
R2419  -  [0R0402-PAD]  115.04 63.73 90 bottom
R2425  0R2J-2-GP  [R402H16]  122.38 54.41 90 top
R2431  1KR2J-1-GP  [R402H16]  122.48 42.67 270 top
R2432  0R0402-PAD-2-GP  [0R0402-PAD-1]  121.64 56.03 0 bottom
R2433  0R0402-PAD-2-GP  [0R0402-PAD-1]  96.44 48.77 270 top
R2435  0R2J-2-GP  [R402H16]  122.18 56.81 270 top
R2437  0R0402-PAD-2-GP  [0R0402-PAD-1]  96.77 57.53 90 top
R2438  100KR2J-1-GP  [R402H16]  102.59 51.14 270 bottom
R2439  0R0402-PAD-2-GP  [0R0402-PAD-1]  99.82 62.83 90 top
R2440  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.12 58.6 90 top
R2454  0R0402-PAD-2-GP  [0R0402-PAD-1]  112.45 64.72 180 top
R2457  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.23 60.86 90 top
R2459  0R0402-PAD-2-GP  [0R0402-PAD-1]  113.79 42.47 90 top
R2461  0R2J-2-GP  [R402H16]  107.24 59.87 180 bottom
R2466  0R0402-PAD-1-GP  [0R0402-PAD]  122.45 49.66 90 top
R2469  -  [0R0402-PAD]  109.02 57.33 90 bottom
R2470  0R2J-2-GP  [R402H16]  122.15 57.86 90 bottom
R2472  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.45 41.63 270 top
R2474  0R0402-PAD-2-GP  [0R0402-PAD-1]  116.54 43 90 top
R2476  33R2J-2-GP  [R402H16]  178.08 54.71 270 top
R2477  0R2J-2-GP  [R402H16]  196.3 55.34 270 top
R2478  0R0402-PAD-2-GP  [0R0402-PAD-1]  196.89 56.64 270 top
R2479  0R0402-PAD-2-GP  [0R0402-PAD-1]  196.98 60.18 0 top
R2481  10KR2J-3-GP  [R402H16]  86.97 55.32 90 top
R2482  10KR2J-3-GP  [R402H16]  112.85 9.17 90 bottom
R2483  10KR2J-3-GP  [R402H16]  147.24 5.38 90 top
R2484  10KR2J-3-GP  [R402H16]  84.23 30.68 270 top
R2485  10KR2J-3-GP  [R402H16]  164.34 10.57 180 bottom
R2491  10KR2J-3-GP  [R402H16]  221.23 11.18 90 bottom
R2492  10KR2J-3-GP  [R402H16]  224.61 24.28 0 top
R2495  10KR2J-3-GP  [R402H16]  9.58 140.03 0 top
R2497  0R0402-PAD-2-GP  [0R0402-PAD-1]  99.9 48.01 90 top
R2498  0R0402-PAD-2-GP  [0R0402-PAD-1]  219.84 11.02 0 top
R2499  470R2F-GP  [R402H16]  185.9 128.78 270 top
R2500  0R0402-PAD-2-GP  [0R0402-PAD-1]  184.32 128.34 180 top
R2501  2K2R2J-2-GP  [R402H16]  15.58 136.55 270 bottom
R2505  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.64 139.54 180 bottom
R2506  0R2J-2-GP  [R402H16]  205.1 150.39 90 top
R2511  0R2J-2-GP  [R402H16]  218.9 26.49 270 top
R2512  0R2J-2-GP  [R402H16]  218.9 27.63 270 top
R2513  0R0402-PAD-2-GP  [0R0402-PAD-1]  218.9 25.71 90 bottom
R2514  0R0402-PAD-2-GP  [0R0402-PAD-1]  218.9 26.85 90 bottom
R2515  0R2J-2-GP  [R402H16]  202.26 26.82 270 top
R2516  0R2J-2-GP  [R402H16]  202.29 27.89 270 top
R2517  0R2J-2-GP  [R402H16]  203.95 24.27 180 bottom
R2518  0R2J-2-GP  [R402H16]  203.05 27.76 0 bottom
R2522  -  [0R0402-PAD]  108.61 75.28 180 top
R2523  20MR2J-GP  [R402H16]  109.63 76.17 180 top
R2534  16K2R2F-GP  [R402H16]  93.17 159.05 90 top
R2536  0R0402-PAD-2-GP  [0R0402-PAD-1]  123.11 51.74 90 top
R2537  0R0402-PAD-2-GP  [0R0402-PAD-1]  116.48 41.83 270 top
R2539  0R0402-PAD-2-GP  [0R0402-PAD-1]  108.14 80.55 180 top
R2558  -  [0R0603-PAD]  118.41 93.09 270 bottom
R2559  0R2J-2-GP  [R402H16]  199.6 177.52 90 top
R2577  10KR2F-2-GP  [R402H16]  113.79 121.92 0 top
R2579  0R2J-2-GP  [R402H16]  81.26 162.8 270 bottom
R2580  10KR2F-2-GP  [R402H16]  13.49 144.51 270 top
R2581  0R3J-0-U-GP  [R603H22]  209.85 41.78 90 top
R2582  -  [0R0603-PAD]  193.65 41.12 0 bottom
R2585  100KR3F-GP  [R603H22]  193.27 34.82 270 top
R2586  0R0402-PAD-2-GP  [0R0402-PAD-1]  190.78 34.06 270 top
R2587  0R0402-PAD-2-GP  [0R0402-PAD-1]  184.4 28.7 90 top
R2588  100KR3F-GP  [R603H22]  185.43 31.35 270 top
R2589  10KR2J-3-GP  [R402H16]  222.55 75.95 180 top
R2594  D2R5F-1-GP  [R805H24]  216.84 11.43 180 top
R2595  D2R5F-1-GP  [R805H24]  214.91 11.43 180 top
R2596  D2R5F-1-GP  [R805H24]  201.26 12.3 180 top
R2598  10KR2J-3-GP  [R402H16]  206.4 8.89 90 top
R2599  10KR2J-3-GP  [R402H16]  111.84 85.5 90 top
R2600  0R0402-PAD-2-GP  [0R0402-PAD-1]  117.2 87.35 0 top
R2601  0R2J-2-GP  [R402H16]  114.94 103.89 0 top
R2602  0R0402-PAD-2-GP  [0R0402-PAD-1]  208.43 227.71 180 top
R2603  0R0402-PAD-2-GP  [0R0402-PAD-1]  116.26 127.23 0 top
R2604  10KR2J-3-GP  [R402H16]  221.72 9.53 90 top
R2605  0R3J-0-U-GP  [R603H22]  131.44 208.79 0 top
R2606  0R3J-0-U-GP  [R603H22]  129.41 208.15 90 top
R2613  0R2J-2-GP  [R402H16]  143.23 167.36 180 bottom
R2614  0R0402-PAD-2-GP  [0R0402-PAD-1]  144.28 167.37 180 bottom
R2615  0R0402-PAD-2-GP  [0R0402-PAD-1]  200.58 57.63 270 top
R2616  0R0402-PAD-2-GP  [0R0402-PAD-1]  204.49 60.77 0 bottom
R2617  0R0402-PAD-2-GP  [0R0402-PAD-1]  197.1 47.62 180 top
R2618  0R0402-PAD-2-GP  [0R0402-PAD-1]  198.02 52.65 270 top
R2619  0R0402-PAD-2-GP  [0R0402-PAD-1]  200.79 59.28 180 top
R2620  0R0402-PAD-2-GP  [0R0402-PAD-1]  203.42 60.77 0 bottom
R2621  4K7R2F-GP  [R402H16]  212.72 56.01 90 top
R2622  4K7R2F-GP  [R402H16]  214.64 60.73 0 top
R2623  0R0402-PAD-2-GP  [0R0402-PAD-1]  213.63 60.73 180 top
R2624  0R0402-PAD-2-GP  [0R0402-PAD-1]  214.11 57.93 270 top
R2625  0R2J-2-GP  [R402H16]  204.72 55.37 270 top
R2626  0R2J-2-GP  [R402H16]  207.26 55.37 0 top
R2627  10KR2F-2-GP  [R402H16]  208.91 64.77 0 top
R2628  0R2J-2-GP  [R402H16]  206.76 63.53 0 top
R2629  0R0402-PAD-2-GP  [0R0402-PAD-1]  207.79 63.53 180 top
R2630  1KR2F-3-GP  [R402H16]  198.58 48.9 90 bottom
R2631  10KR2J-3-GP  [R402H16]  117.93 56.13 90 bottom
R2632  10KR2J-3-GP  [R402H16]  148.32 180.82 90 bottom
R2633  10KR2J-3-GP  [R402H16]  133.92 161.32 90 top
R2634  10KR2F-2-GP  [R402H16]  110.77 140.43 180 top
R2635  4K99R2F-L-GP  [R402H16]  96.27 162.28 90 bottom
R2636  4K7R2F-GP  [R402H16]  120.47 166.7 180 top
R2637  47KR2J-2-GP  [R402H16]  119.35 166.73 180 top
R2638  4K7R2F-GP  [R402H16]  122.68 165.74 180 top
R2639  47KR2J-2-GP  [R402H16]  123.83 165.74 180 top
R2640  10KR2F-2-GP  [R402H16]  105.64 147.15 270 top
R2641  10KR2F-2-GP  [R402H16]  106.49 150.8 180 top
R2642  10KR2F-2-GP  [R402H16]  13.44 155.9 270 top
R2643  10KR2F-2-GP  [R402H16]  13.44 156.92 270 top
R2644  0R0402-PAD-2-GP  [0R0402-PAD-1]  177.62 37.49 90 top
R2645  0R0402-PAD-2-GP  [0R0402-PAD-1]  177.62 36.47 90 top
R2646  0R2J-2-GP  [R402H16]  177.34 41.66 90 top
R2647  0R2J-2-GP  [R402H16]  177.34 40.64 90 top
R2648  0R2J-2-GP  [R402H16]  174.55 38.73 90 top
R2649  0R2J-2-GP  [R402H16]  174.55 37.72 90 top
R2650  0R0402-PAD-2-GP  [0R0402-PAD-1]  123.93 172.19 270 bottom
R2651  0R0402-PAD-2-GP  [0R0402-PAD-1]  123.93 173.2 270 bottom
R2652  0R0402-PAD-2-GP  [0R0402-PAD-1]  151.56 184.89 270 bottom
R2653  0R0402-PAD-2-GP  [0R0402-PAD-1]  151.56 183.85 270 bottom
R2656  0R0402-PAD-2-GP  [0R0402-PAD-1]  166.75 29.84 270 top
R2657  0R0402-PAD-2-GP  [0R0402-PAD-1]  166.75 30.86 270 top
R2659  0R2J-2-GP  [R402H16]  181.74 16.48 90 top
R2660  15KR2F-GP  [R402H16]  185.45 18.49 180 top
R2661  10KR2J-3-GP  [R402H16]  184.43 18.49 0 top
R2662  0R2J-2-GP  [R402H16]  223.32 73.15 90 top
R2663  10KR2F-2-GP  [R402H16]  138.63 97.13 90 bottom
R2664  33R2J-2-GP  [R402H16]  138.22 98.59 0 bottom
R2665  33R2J-2-GP  [R402H16]  140.01 101.46 270 top
R2666  33R2J-2-GP  [R402H16]  130.81 100.74 180 top
R2667  0R3J-0-U-GP  [R603H22]  10.82 140.82 0 bottom
R2668  -  [0R0603-PAD]  10.79 143.61 180 bottom
R2669  1MR2F-GP  [R402H16]  124.84 58.88 270 top
R2670  10MR2F-GP  [R402H16]  124.84 60.02 90 top
R2671  4K7R2J-2-GP  [R402H16]  126.62 74.8 90 top
R2672  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.28 61.16 270 top
R2673  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.17 58.83 270 top
R2674  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.17 59.89 270 top
R2675  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.22 53.39 270 top
R2676  0R2J-2-GP  [R402H16]  122.15 59.94 90 bottom
R2677  0R2J-2-GP  [R402H16]  122 53.87 0 bottom
R2678  0R2J-2-GP  [R402H16]  122.28 61.16 90 bottom
R2679  0R2J-2-GP  [R402H16]  122.15 58.9 90 bottom
R2680  100KR2J-1-GP  [R402H16]  188.8 176.89 180 bottom
R2682  33R2J-2-GP  [R402H16]  145.52 36.07 0 bottom
R2684  10KR2J-3-GP  [R402H16]  139.83 166.5 270 bottom
R2685  10KR2J-3-GP  [R402H16]  139.83 166.5 270 top
R2686  10KR2J-3-GP  [R402H16]  139.83 165.46 270 bottom
R2687  10KR2J-3-GP  [R402H16]  139.83 165.46 270 top
R2688  10KR2J-3-GP  [R402H16]  128.04 157.05 270 top
R2689  10KR2J-3-GP  [R402H16]  127.94 148.84 270 top
R2690  0R3J-0-U-GP  [R603H22]  209.55 36.96 90 top
R2691  33R2J-2-GP  [R402H16]  212.6 37.34 180 top
R2692  1KR2J-1-GP  [R402H16]  213.11 38.86 270 top
R2693  1KR2J-1-GP  [R402H16]  132.56 172.21 0 top
R2694  0R2J-2-GP  [R402H16]  120.93 45.8 180 bottom
R2695  0R2J-2-GP  [R402H16]  119.91 45.8 180 bottom
R2696  0R0402-PAD-2-GP  [0R0402-PAD-1]  21.31 130.58 90 bottom
R2697  0R0402-PAD-2-GP  [0R0402-PAD-1]  21.31 131.6 90 bottom
R2698  0R2J-2-GP  [R402H16]  130.05 14.12 90 top
R2699  0R2J-2-GP  [R402H16]  127.89 12.19 0 top
R2700  0R0402-PAD-2-GP  [0R0402-PAD-1]  129.34 12.98 90 top
R2701  0R0402-PAD-2-GP  [0R0402-PAD-1]  126.26 11.89 90 top
R2702  5K1R2-GP  [R402H16]  79.12 171.63 0 bottom
R2706  10KR2J-3-GP  [R402H16]  127.89 44.83 270 bottom
R2707  100KR2J-1-GP  [R402H16]  130.43 41.66 180 bottom
R2708  0R2J-2-GP  [R402H16]  127.89 43.81 90 bottom
R2709  0R0402-PAD-2-GP  [0R0402-PAD-1]  14 141.97 0 top
R2710  0R0402-PAD-2-GP  [0R0402-PAD-1]  12.95 141.94 0 top
R2711  0R0402-PAD-2-GP  [0R0402-PAD-1]  15.59 135.48 270 bottom
R2712  10KR2J-3-GP  [R402H16]  21.56 134.04 90 bottom
R2713  0R0402-PAD-2-GP  [0R0402-PAD-1]  15.57 137.59 90 bottom
R2714  10KR2J-3-GP  [R402H16]  142.04 158.04 0 bottom
R2715  100KR2F-L1-GP  [R402H16]  130 156.95 90 top
R2716  100KR2F-L1-GP  [R402H16]  128.3 151.76 180 top
R2717  10KR2F-2-GP  [R402H16]  127.94 155.5 0 top
R2718  0R2J-2-GP  [R402H16]  203.12 34.68 0 bottom
R2719  0R0402-PAD-2-GP  [0R0402-PAD-1]  204.19 34.67 0 bottom
R2720  0R2J-2-GP  [R402H16]  18.11 109.96 180 top
R2721  0R2J-2-GP  [R402H16]  118.34 49.2 180 bottom
R2722  0R2J-2-GP  [R402H16]  18.97 143.74 0 top
R2723  0R2J-2-GP  [R402H16]  20.52 143.74 0 top
R2724  0R2J-2-GP  [R402H16]  21.56 143.74 0 top
R2725  0R2J-2-GP  [R402H16]  15.54 132.08 270 top
R2726  0R2J-2-GP  [R402H16]  14.05 132.51 180 top
R2727  0R2J-2-GP  [R402H16]  13 132.51 180 top
R2728  0R2J-2-GP  [R402H16]  132 88.44 270 bottom
R2729  0R0402-PAD-2-GP  [0R0402-PAD-1]  126.31 76.46 0 top
R2730  0R3J-0-U-GP  [R603H22]  194.67 53.54 270 bottom
R2731  -  [0R0603-PAD]  193.14 52.25 90 bottom
R2732  0R0402-PAD-2-GP  [0R0402-PAD-1]  112.34 161.82 180 top
R2733  10KR2J-3-GP  [R402H16]  122.45 50.7 270 top
R2734  0R0402-PAD-2-GP  [0R0402-PAD-1]  120.78 103.26 180 top
R2735  0R0402-PAD-2-GP  [0R0402-PAD-1]  119.74 103.28 180 top
R2737  D2R5F-1-GP  [R805H24]  195.61 10.46 270 top
R2738  10R3J-3-GP  [R603H22]  189 22.2 0 bottom
R2739  100KR2J-1-GP  [R402H16]  196.67 173.89 270 bottom
R2740  5K1R2-GP  [R402H16]  73.1 155.19 180 bottom
R2741  5K1R2-GP  [R402H16]  74.14 155.19 180 bottom
R2742  10KR2J-3-GP  [R402H16]  201.95 181.61 90 top
R2743  100KR2J-1-GP  [R402H16]  197.8 179.76 270 top
R2744  10KR2J-3-GP  [R402H16]  198.74 178.54 270 top
R2745  0R0402-PAD-2-GP  [0R0402-PAD-1]  110.28 103.5 90 top
R2746  10KR2J-3-GP  [R402H16]  113.72 42.62 90 bottom
R2747  10KR2J-3-GP  [R402H16]  139.82 214.81 90 top
R2748  0R0402-PAD-2-GP  [0R0402-PAD-1]  81.27 161.7 270 bottom
R2749  0R2J-2-GP  [R402H16]  81.27 160.66 270 bottom
R2750  100KR2F-L1-GP  [R402H16]  92.96 161.59 90 top
R2751  100KR2J-1-GP  [R402H16]  125.26 46.99 270 top
R2752  10KR2F-2-GP  [R402H16]  208.8 224.82 270 top
R2753  10KR2J-3-GP  [R402H16]  109.52 72.66 180 top
R2754  10KR2J-3-GP  [R402H16]  116.21 78.46 270 top
R2755  10KR2J-3-GP  [R402H16]  214 143.64 90 bottom
R2756  1KR2J-1-GP  [R402H16]  214 144.78 90 bottom
R2757  100KR2J-1-GP  [R402H16]  216.53 140.84 90 bottom
R2758  1KR2J-1-GP  [R402H16]  209.42 150.5 90 bottom
R2759  10KR2J-3-GP  [R402H16]  128.22 130.67 180 top
R2760  10KR2J-3-GP  [R402H16]  127.89 137.79 90 top
R2761  2K2R2J-2-GP  [R402H16]  18.67 140.46 180 bottom
R2762  0R0402-PAD-2-GP  [0R0402-PAD-1]  139.79 159.77 90 top
R2763  10KR2J-3-GP  [R402H16]  120.9 112.78 90 top
R2764  1KR2J-1-GP  [R402H16]  129.02 116.31 90 top
R2765  100KR2J-1-GP  [R402H16]  120.9 111.66 90 top
R2766  1KR2J-1-GP  [R402H16]  121.04 118.57 270 top
R2767  0R2J-2-GP  [R402H16]  121.82 150 0 top
R2768  0R2J-2-GP  [R402H16]  123.37 146.49 0 top
R2769  0R2J-2-GP  [R402H16]  124.27 142.01 90 top
R2770  0R2J-2-GP  [R402H16]  130.99 51.47 0 top
R2771  0R2J-2-GP  [R402H16]  105.71 63.61 0 top
R2772  10KR2J-3-GP  [R402H16]  104.44 63.74 0 top
R2773  0R3J-0-U-GP  [R603H22]  17.34 179.47 180 bottom
R2774  0R3J-0-U-GP  [R603H22]  226.41 18.51 180 bottom
R2775  0R2J-2-GP  [R402H16]  187.35 18.47 0 top
R2776  10KR2J-3-GP  [R402H16]  33.72 137.25 0 bottom
R2777  10KR2J-3-GP  [R402H16]  33.09 134.9 90 top
R2778  0R2J-2-GP  [R402H16]  212.81 149.76 270 top
R2779  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.49 43.74 270 top
R2780  100KR2J-1-GP  [R402H16]  106.49 55.19 90 bottom
R2781  10KR2J-3-GP  [R402H16]  131.73 177.35 180 top
R2782  10KR2J-3-GP  [R402H16]  129.41 162.7 0 bottom
R2783  10KR2J-3-GP  [R402H16]  130.51 162.7 0 bottom
R2784  0R2J-2-GP  [R402H16]  225.43 157.61 0 top
R2785  100KR2J-1-GP  [R402H16]  133.15 198.15 270 top
R2786  100KR2J-1-GP  [R402H16]  122.3 212.6 270 top
RN1  SRN1KJ-7-GP  [SMD-ARES4H18]  196.32 167.77 90 top
RN2  SRN1KJ-4-GP  [ARES8-CN24H20]  214.86 147.01 270 top
RN3  SRN2K2J-1-GP  [ARES2H16]  92.46 71.12 180 top
RN4  SRN2K2J-1-GP  [ARES2H16]  138.84 151.59 270 top
RN5  SRN2K2J-1-GP  [ARES2H16]  126.56 172.64 90 top
RN6  SRN10KJ-5-GP  [ARES2H18]  138.68 147.57 270 top
RN7  SRN2K2J-1-GP  [ARES2H16]  157.99 57.02 180 bottom
RN8  SRN4K7J-8-GP  [SMD-ARES4H18]  153.16 28.83 0 top
RN9  SRN4K7J-8-GP  [SMD-ARES4H18]  151.16 27.71 0 top
RN10  SRN4K7J-8-GP  [SMD-ARES4H18]  155.19 28.83 0 top
RN12  SRN4K7J-8-GP  [SMD-ARES4H18]  116.13 54.05 0 bottom
RN15  SRN2K2J-1-GP  [ARES2H16]  113.25 53.43 0 bottom
RN16  SRN10KJ-5-GP  [ARES2H18]  137.67 101.09 0 bottom
RN17  SRN10KJ-5-GP  [ARES2H18]  212.31 146.4 0 top
RN19  SRN4K7J-8-GP  [SMD-ARES4H18]  157.23 28.83 0 top
RN42  SRN33J-5-GP-U  [SMD-ARES4H18]  136.3 97.36 180 bottom
RN43  SRN33J-5-GP-U  [SMD-ARES4H18]  134.09 97.38 180 bottom
RN44  SRN10KJ-5-GP  [ARES2H18]  97.16 53.39 270 bottom
RN45  SRN10KJ-5-GP  [ARES2H18]  93.01 58.22 90 top
RN46  SRN4K7J-8-GP  [SMD-ARES4H18]  120.45 49.2 270 bottom
RN48  SRN0J-6-GP  [SMD-ARES4H20]  106.43 80.93 0 top
RN2402  SRN10KJ-5-GP  [ARES2H18]  132.97 145.8 270 top
RN2404  SRN10KJ-5-GP  [ARES2H18]  148.92 160.02 90 bottom
RN2405  SRN10KJ-5-GP  [ARES2H18]  151.74 157.91 90 bottom
RN2406  SRN4K7J-8-GP  [SMD-ARES4H18]  125.96 64.36 0 top
RN2407  SRN10KJ-5-GP  [ARES2H18]  129.15 172.2 180 top
RN2408  SRN10KJ-5-GP  [ARES2H18]  128.96 174.76 270 top
RN2410  SRN33J-5-GP-U  [SMD-ARES4H18]  123.78 160.85 270 top
RN2411  SRN33J-5-GP-U  [SMD-ARES4H18]  111.2 164.36 270 top
RN2412  SRN10KJ-5-GP  [ARES2H18]  175.15 35.17 90 top
RN2413  SRN1KJ-7-GP  [SMD-ARES4H18]  215.1 157.06 270 top
RN2414  SRN10KJ-5-GP  [ARES2H18]  172.38 38.7 270 bottom
RN2415  SRN2K2J-1-GP  [ARES2H16]  200.72 50.46 180 top
RN2416  SRN1KJ-7-GP  [SMD-ARES4H18]  172.38 147.49 270 bottom
RPWRC1  BAOT-CONN30A-GP  [WTB1030PDSHF]  162.5 4 180 top
RUSBC1  ACES-CON30-31-GP  [111H30-100000-G4-R]  82 42 90 top
SATAP1  CLX-CON5-S13-GP  [CI2505P1V0B-R0-NH]  81 20 90 top
SDRDC1  ACES-CON10-58-GP  [50450-01071-001]  230 16.5 90 top
SPK1  ACES-CON6-66-GP  [50288-00641-001]  216 5 0 top
SPR1  SPRING-58-GP  [SPR1337H524]  233 82 270 top
SPR2  SPRING-58-GP  [SPR1337H524]  225 82 270 top
SRCON1  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  136.57 94.25 270 top
SSDC1  SKT-NGFF75P-109-GP  [40-42269-067B12HF]  106.5 96 0 top
SUSBC1  BAOT-CONN24A-1-GP  [WTB1024PDSHF]  231 30 90 top
TC2  ST100U6D3VBM-7GP  [CT3528H79]  88.8 21.23 90 top
TC4  ST150U6D3VBM-GP  [CT3528H83]  99.87 208.43 90 top
TC5  ST470U2VDM-19-GP  [CT7343H87]  17.78 169.42 0 top
TC6  ST470U2VDM-19-GP  [CT7343H87]  28.22 149.15 90 top
TOUCH1  JWT-CON5-51-GP  [A1002WV0-5PS-5E-1]  186 3 0 top
TP1  TPAD26-OP-GP  [TPAD26-OP]  180.54 159.51 90 bottom
TP2  TPAD26-OP-GP  [TPAD26-OP]  179.35 160.41 90 bottom
TP3  TPAD26-OP-GP  [TPAD26-OP]  175.99 155 90 bottom
TP4  TPAD26-OP-GP  [TPAD26-OP]  188.27 171.58 270 bottom
TP5  TPAD26-OP-GP  [TPAD26-OP]  183.79 177.28 90 bottom
TP6  TPAD26-OP-GP  [TPAD26-OP]  186.25 176.7 90 bottom
TP7  TPAD26-OP-GP  [TPAD26-OP]  167.71 152.59 90 bottom
TP8  TPAD26-OP-GP  [TPAD26-OP]  170.74 152.73 90 bottom
TP9  TPAD26-OP-GP  [TPAD26-OP]  157.98 175.01 90 bottom
TP10  TPAD26-OP-GP  [TPAD26-OP]  189.89 168.37 270 bottom
TP12  -  [TPAD30]  141.88 160.45 0 top
TP13  TPAD26-OP-GP  [TPAD26-OP]  167.39 54.89 180 bottom
TP14  TPAD26-OP-GP  [TPAD26-OP]  168.05 53.04 180 bottom
TP15  TPAD26-OP-GP  [TPAD26-OP]  168.91 55.78 180 bottom
TP16  TPAD26-OP-GP  [TPAD26-OP]  170.81 53.98 180 bottom
TP17  TPAD26-OP-GP  [TPAD26-OP]  155.6 50.75 180 bottom
TP18  -  [TPAD30]  156.26 30.96 0 top
TP19  -  [TPAD30]  155.37 31.88 0 top
TP20  -  [TPAD30]  157.18 31.88 0 top
TP21  -  [TPAD30]  158.09 30.96 0 top
TP22  TPAD26-OP-GP  [TPAD26-OP]  155.19 35.18 180 bottom
TP23  TPAD26-OP-GP  [TPAD26-OP]  153.9 35.23 180 bottom
TP24  TPAD26-OP-GP  [TPAD26-OP]  153.43 36.69 180 bottom
TP25  TPAD26-OP-GP  [TPAD26-OP]  155.5 39.29 180 bottom
TP26  TPAD26-OP-GP  [TPAD26-OP]  159.38 37.34 180 bottom
TP27  TPAD26-OP-GP  [TPAD26-OP]  157.05 38.99 180 bottom
TP28  TPAD26-OP-GP  [TPAD26-OP]  157.48 40.34 180 bottom
TP29  -  [TPAD30]  159 31.85 0 top
TP30  -  [TPAD30]  159.59 30.66 0 top
TP31  TPAD26-OP-GP  [TPAD26-OP]  158.39 32.11 180 bottom
TP32  TPAD26-OP-GP  [TPAD26-OP]  181.25 22.08 180 bottom
TP33  -  [TPAD30]  226.49 15.72 90 top
TP34  TPAD26-OP-GP  [TPAD26-OP]  96.04 45.36 270 bottom
TP38  -  [TPAD30]  192.58 42.29 90 top
TP39  TPAD26-OP-GP  [TPAD26-OP]  88.54 182.25 270 bottom
TP40  TPAD26-OP-GP  [TPAD26-OP]  89.81 182.75 270 bottom
TP41  TPAD26-OP-GP  [TPAD26-OP]  81.46 174.37 270 bottom
TP42  TPAD26-OP-GP  [TPAD26-OP]  76.44 158.46 90 bottom
TP43  TPAD26-OP-GP  [TPAD26-OP]  74.03 161.96 180 bottom
TP44  TPAD26-OP-GP  [TPAD26-OP]  69.43 169.76 270 bottom
TP45  TPAD26-OP-GP  [TPAD26-OP]  68.16 170.6 270 bottom
TP46  TPAD26-OP-GP  [TPAD26-OP]  79.69 181.66 180 bottom
TP47  -  [TPAD30]  26.53 138.01 270 top
TP48  -  [TPAD30]  27.86 137.95 270 top
TP49  -  [TPAD30]  29.2 137.98 270 top
TP50  -  [TPAD30]  30.49 137.96 180 top
TP51  -  [TPAD30]  31.85 138 270 top
TP52  -  [TPAD30]  33.89 137.13 270 top
TP55  TPAD26-OP-GP  [TPAD26-OP]  67.3 161.46 270 bottom
TP56  TPAD26-OP-GP  [TPAD26-OP]  67.01 160.02 270 bottom
TP57  TPAD26-OP-GP  [TPAD26-OP]  69.43 168.23 270 bottom
TP58  TPAD26-OP-GP  [TPAD26-OP]  68.15 168.98 270 bottom
TP59  TPAD26-OP-GP  [TPAD26-OP]  69.12 163.5 270 bottom
TP60  TPAD26-OP-GP  [TPAD26-OP]  69.3 161.7 90 bottom
TP61  TPAD26-OP-GP  [TPAD26-OP]  69.92 165.26 90 bottom
TP62  TPAD26-OP-GP  [TPAD26-OP]  70.09 167.11 90 bottom
TP63  TPAD26-OP-GP  [TPAD26-OP]  77.98 170.81 180 bottom
TP64  TPAD26-OP-GP  [TPAD26-OP]  77.85 167.89 180 bottom
TP65  -  [TPAD30]  92.61 160.22 0 top
TP67  -  [TPAD30]  99.82 55.12 0 top
TP68  -  [TPAD30]  110.86 63.2 0 top
TP69  -  [TPAD30]  194.52 54.26 0 top
TP70  -  [TPAD30]  192.97 54.11 0 top
TP71  -  [TPAD30]  195.2 53.07 0 top
TP72  -  [TPAD30]  193.86 53.02 0 top
TP73  -  [TPAD30]  192.74 52 0 top
TP74  -  [TPAD30]  194.64 51.88 0 top
TP75  -  [TPAD30]  193.35 50.71 0 top
TP76  -  [TPAD30]  194.67 50.61 0 top
TP77  -  [TPAD30]  194.01 49.46 0 top
TP78  -  [TPAD30]  195.3 49.49 0 top
TP79  -  [TPAD30]  192.74 47.94 0 top
TP80  -  [TPAD30]  194.16 47.99 0 top
TP81  -  [TPAD30]  195.48 48.22 0 top
TP82  -  [TPAD30]  180.52 59.36 0 top
TP83  -  [TPAD30]  178.41 58.65 0 top
TP84  -  [TPAD30]  180.32 58.02 0 top
TP85  -  [TPAD30]  179.12 57.52 0 top
TP86  -  [TPAD30]  180.37 56.73 0 top
TP87  -  [TPAD30]  179.2 55.86 0 top
TP88  -  [TPAD30]  179.73 48.96 0 top
TP89  -  [TPAD30]  179.02 47.56 0 top
TP90  -  [TPAD30]  180.37 47.71 0 top
TP91  -  [TPAD30]  179.05 46.29 0 top
TP92  -  [TPAD30]  180.27 45.65 0 top
TP93  -  [TPAD30]  179.07 45.02 0 top
TP94  -  [TPAD30]  193.42 58.79 0 top
TP95  -  [TPAD30]  139.8 155.91 90 top
TP96  -  [TPAD30]  136.65 156.59 90 top
TP97  TPAD26-OP-GP  [TPAD26-OP]  152.12 159.92 90 bottom
TP98  TPAD26-OP-GP  [TPAD26-OP]  159.01 176.01 180 bottom
TP99  TPAD26-OP-GP  [TPAD26-OP]  140.84 153.54 90 bottom
