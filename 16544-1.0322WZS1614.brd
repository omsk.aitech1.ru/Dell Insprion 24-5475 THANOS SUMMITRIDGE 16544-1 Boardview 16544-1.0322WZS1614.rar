# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ38: length 51.5
  TOP w0.114: v6(167.85,112.07) 168.26,112.48 168.26,112.98 168.33,113.05 168.33,113.75 167.87,114.2 DIMM1.183 ; v6(159.54,150.45) 159.99,150 CPU1.AK33
  L3 w0.089: v6(159.54,150.45) 159.14,150.05 159.14,147.83 158.97,147.66 158.97,144.38
  L3 w0.114: 158.97,144.38 158.65,144.06 158.65,141.97 157.87,141.19 157.87,136.1 158.43,135.54 158.43,135.32 158.55,135.2 158.64,135.2 158.75,135.09 158.75,134.86 158.64,134.74 158.55,134.74 158.43,134.63 158.43,134.4 158.55,134.29 158.64,134.29 158.75,134.17 158.75,133.94 158.64,133.83 158.55,133.83 158.43,133.72 158.43,133.49 158.55,133.37 158.64,133.37 158.75,133.26 158.75,133.03 158.64,132.92 158.55,132.92 158.43,132.8 158.43,132.57 158.55,132.46 158.64,132.46 158.75,132.34 158.75,132.12 158.64,132 158.55,132 158.43,131.89 158.43,131.66 158.55,131.54 158.64,131.54 158.75,131.43 158.75,131.2 158.64,131.09 158.55,131.09 158.43,130.97 158.43,123.49 166.81,115.12 166.81,114.69 166.92,114.58 167.07,114.58 167.19,114.46 167.19,114.23 167.07,114.12 166.92,114.12 166.81,114.01 166.81,113.78 166.92,113.66 167.05,113.66 167.16,113.55 167.16,113.32 167.05,113.21 166.92,113.21 166.81,113.09 166.81,112.86 166.92,112.75 167.1,112.75 167.21,112.63 167.21,112.41 167.1,112.29 166.92,112.29 166.81,112.18 166.81,111.89 166.92,111.77 167.54,111.77 v6(167.85,112.07)
M_A_DQ39: length 51.5
  TOP w0.114: CPU1.AK32 159.97,151 v6(159.53,151.44) ; v6(167.85,108.39) 168.12,108.11 DIMM1.182
  L3 w0.089: 157.93,144.28 157.93,145.51 158.72,146.3 158.72,147.76 158.92,147.96 158.92,150.83 v6(159.53,151.44)
  L3 w0.114: 157.93,144.28 158.31,143.9 158.31,142.08 157.51,141.29 157.51,136.01 158.12,135.41 158.12,123.36 166.49,114.99 166.49,111.72 167.27,110.94 167.27,108.22 167.39,108.1 167.73,108.1 167.85,108.22 v6(167.85,108.39)
M_A_DQ40: length 50.8
  TOP w0.114: CPU1.AM34 157.55,148.55 v6(157.55,148.46) ; DIMM1.195 v6(164.87,113.59)
  L3 w0.089: 157.16,144.67 157.16,145.62 157.9,146.37 157.9,147.81 157.55,148.16 v6(157.55,148.46)
  L3 w0.114: 157.16,144.67 157.16,144.31 156.93,144.09 156.93,142.12 156.52,141.72 156.52,140.22 155.41,139.12 155.41,135.42 155.53,135.3 155.76,135.3 155.87,135.42 155.87,137.04 155.99,137.15 156.21,137.15 156.33,137.04 156.33,135.27 156.01,134.96 156.01,133.04 156.13,132.92 156.36,132.92 156.47,133.04 156.47,134.85 156.59,134.96 156.81,134.96 156.93,134.85 156.93,122.88 164.87,114.93 v6(164.87,113.59)
M_A_DQ41: length 50.7
  TOP w0.114: CPU1.AM33 157.5,149.5 v6(157.5,149.49) ; DIMM1.194 165.12,107.82 165.38,108.08 165.38,108.6 164.93,109.05 v6(164.93,109.1)
  L3 w0.089: v6(157.5,149.49) 156.91,148.89 156.91,148.34 156.65,148.08 156.51,148.08 156.08,147.65 156.08,145.3 155.63,144.85
  L3 w0.114: v6(164.93,109.1) 164.63,109.4 164.47,109.4 164.06,108.99 163.9,108.99 163.74,109.15 163.74,109.31 164.14,109.72 164.14,109.88 164.05,109.98 164.05,114.86 156.29,122.62 156.29,131.86 154.77,133.38 154.77,139.37 154.95,139.56 155.81,140.41 155.81,142.06 155.39,142.48 155.39,144.6 155.63,144.85
M_A_DQ42: length 51.8
  TOP w0.114: v6(159.85,111.3) 160.3,111.3 161.32,112.32 161.32,113.61 161.87,114.16 DIMM1.207 ; CPU1.AP31 155.56,151.56 v6(155.56,151.48)
  L3 w0.089: v6(155.56,151.48) 155.06,150.97 155.06,150.3 154.57,149.82 154.34,149.82 152.67,148.15 152.67,148.02
  L3 w0.114: v6(159.85,111.3) 160.95,112.41 160.95,114.27 153.28,121.95 153.28,130.96 151.85,132.39 151.85,140.44 151.73,140.56 151.73,144.21 152.67,145.15 152.67,148.02
M_A_DQ43: length 51.5
  TOP w0.114: DIMM1.208 161.62,108.45 160.22,109.86 v6(159.82,109.86) ; v6(154.5,149.41) 154.5,149.5 CPU1.AR33
  L3 w0.089: 152.9,147.92 154.39,149.41 v6(154.5,149.41)
  L3 w0.114: v6(159.82,109.86) 160.8,109.86 161.27,110.34 161.27,110.7 161.16,110.81 160.67,110.81 160.56,110.93 160.56,111.15 160.67,111.27 161.16,111.27 161.27,111.38 161.27,114.4 153.59,122.08 153.59,131.23 152.17,132.66 152.17,140.57 152.05,140.69 152.05,144.14 152.9,144.99 152.9,147.92
M_A_DQ44: length 51.5
  TOP w0.114: v6(158.49,150.45) 158.49,150.49 CPU1.AL32 ; DIMM1.191 165.87,112.87 165.13,112.12 v6(164.92,112.12)
  L3 w0.089: 157.36,144.18 157.36,145.53 158.11,146.29 158.11,150.07 v6(158.49,150.45)
  L3 w0.114: 157.36,144.18 157.36,143.87 157.25,143.76 157.25,142.03 156.85,141.63 156.85,140.1 155.73,138.98 155.73,137.7 155.85,137.58 156.07,137.58 156.19,137.7 156.19,138.74 156.3,138.86 156.53,138.86 156.65,138.74 156.65,135.67 157.25,135.07 157.25,123.01 165.62,114.63 165.62,114.37 165.51,114.25 165.39,114.25 165.28,114.14 165.28,113.91 165.39,113.8 165.51,113.8 165.64,113.67 165.64,112.56 165.2,112.12 v6(164.92,112.12)
M_A_DQ45: length 51.8
  TOP w0.114: v6(158.49,151.49) 158.49,151.49 CPU1.AL31 ; DIMM1.190 166.12,108.76 165.08,109.81 164.95,109.81 v6(164.9,109.86)
  L3 w0.089: v6(158.49,151.49) 157.91,150.9 157.91,149.33 157.44,148.86 157.39,148.86 157.11,148.58 157.11,148.25 156.95,148.09 156.95,145.31 156.71,145.06 156.5,145.06 156.05,144.61 156.05,144.32
  L3 w0.114: 156.05,144.32 156.05,143.91 156.43,143.52 156.43,142.25 156.16,141.97 156.16,140.32 155.09,139.24 155.09,133.52 156.61,131.99 156.61,122.75 164.36,115 164.36,110.4 v6(164.9,109.86)
M_A_DQ46: length 50.7
  TOP w0.114: CPU1.AP34 155.62,149.38 155.62,149.46 v6(155.49,149.59) ; v6(162.16,113.62) 162.56,113.22 162.87,113.22 163.08,113.43 163.08,113.8 162.87,114.01 DIMM1.203
  L3 w0.089: v6(155.49,149.59) 155.63,149.45 155.63,149.1 154.2,147.66 154.2,147.31 153.41,146.52 153.41,146.18
  L3 w0.114: 153.41,146.18 153.41,140.86 153.12,140.57 153.12,140.33 153,140.22 152.93,140.22 152.82,140.1 152.82,139.87 152.93,139.76 153,139.76 153.12,139.65 153.12,139.42 153,139.3 152.93,139.3 152.82,139.19 152.82,138.96 152.93,138.85 153,138.85 153.12,138.73 153.12,138.5 153,138.39 152.93,138.39 152.82,138.27 152.82,138.05 152.93,137.93 153,137.93 153.12,137.82 153.12,137.59 153,137.47 152.93,137.47 152.82,137.36 152.82,137.13 152.93,137.02 153,137.02 153.12,136.9 153.12,136.67 153,136.56 152.93,136.56 152.82,136.44 152.82,136.22 152.93,136.1 153,136.1 153.12,135.99 153.12,132.7 154.64,131.17 154.64,130.25 154.53,130.14 154.38,130.14 154.26,130.02 154.26,129.8 154.38,129.68 154.53,129.68 154.64,129.57 154.64,129.34 154.53,129.22 154.38,129.22 154.26,129.11 154.26,128.88 154.38,128.77 154.53,128.77 154.64,128.65 154.64,128.42 154.53,128.31 154.38,128.31 154.26,128.19 154.26,127.97 154.38,127.85 154.53,127.85 154.64,127.74 154.64,127.51 154.53,127.39 154.38,127.39 154.26,127.28 154.26,127.05 154.38,126.94 154.53,126.94 154.64,126.82 154.64,126.59 154.53,126.48 154.38,126.48 154.26,126.37 154.26,126.14 154.38,126.02 154.53,126.02 154.64,125.91 154.64,125.68 154.53,125.57 154.38,125.57 154.26,125.45 154.26,125.22 154.38,125.11 154.53,125.11 154.64,124.99 154.64,124.77 154.53,124.65 154.38,124.65 154.26,124.54 154.26,124.31 154.38,124.19 154.53,124.19 154.64,124.08 154.64,123.85 154.53,123.74 154.38,123.74 154.26,123.62 154.26,123.39 154.38,123.28 154.53,123.28 154.64,123.17 154.64,122.94 154.53,122.82 154.38,122.82 154.26,122.71 154.26,122.48 154.38,122.37 154.53,122.37 154.64,122.25 154.64,121.93 162.33,114.25 162.33,113.79 v6(162.16,113.62)
M_A_DQ47: length 51.4
  TOP w0.114: v6(162.23,108.44) 162.62,108.05 DIMM1.204 ; v6(156.51,151.42) 156.41,151.42 156,151.01 CPU1.AP32
  L3 w0.089: 153.14,144.9 153.14,146.57 153.9,147.33 153.9,148.57 154.28,148.95 154.61,148.95 155.06,149.41 155.06,149.72 155.46,150.11 155.61,150.11 155.91,150.41 155.91,150.81 v6(156.51,151.42)
  L3 w0.114: 153.14,144.9 153.14,141.04 152.48,140.38 152.48,132.79 153.91,131.36 153.91,122.21 161.68,114.45 161.68,109 v6(162.23,108.44)
M_A_DQ48: length 61.6
  TOP w0.114: v6(158.09,109.76) 158.2,109.76 159.08,108.87 159.08,108.52 159.36,108.24 159.62,107.97 DIMM1.216 ; v6(154.5,152.58) 154.5,152.13 154.63,152 CPU1.AR31
  L3 w0.089: 152.04,150.54 152.04,150.77 153.34,152.07 153.99,152.07 v6(154.5,152.58)
  L3 w0.114: 152.04,150.54 152.04,150.3 151.79,150.05 151.54,150.05 151.15,149.65 151.15,148.19 151.25,148.09 151.25,146.53 150.6,145.89 149.63,145.89 149.36,145.62 149.36,144.68 148.82,144.14 148.82,135.14 148.92,135.04 148.92,131.36 149.03,131.24 149.26,131.24 149.38,131.36 149.38,134.06 149.49,134.17 149.72,134.17 149.83,134.06 149.83,128.37 151.47,126.73 151.47,121.19 158.65,114.01 158.65,109.91 158.5,109.76 v6(158.09,109.76)
M_A_DQ49: length 61.4
  TOP w0.114: v6(159.84,113.44) 159.87,113.47 DIMM1.215 ; CPU1.AK29 160,154.08 160.46,154.53 v1(160.5,154.53)
  L3 w0.089: 152.17,148.25 153.92,150 153.92,150.67 155.34,152.09 157.59,152.09 157.89,152.39 157.89,153.36 158.5,153.97 160.22,153.97 160.5,154.26 v1(160.5,154.53)
  L3 w0.114: v6(159.84,113.44) 160.02,113.61 160.02,114.02 152.43,121.61 152.43,127.12 150.79,128.76 150.79,136.62 149.87,137.54 149.87,140.74 149.99,140.85 150.21,140.85 150.33,140.74 150.33,137.66 150.44,137.55 150.67,137.55 150.79,137.66 150.79,140.65 150.9,140.76 150.9,144.93 152.17,146.2 152.17,148.25
M_A_DQ50: length 62.6
  TOP w0.114: v6(157.51,154.57) 157.57,154.57 CPU1.AM28 ; DIMM1.228 156.62,107.24 156.62,108.12 155.35,109.4 v6(154.97,109.4)
  L3 w0.089: 150.85,150.98 150.85,151.78 151.89,152.82 151.89,153.46 152.34,153.91 152.64,153.91 153.09,154.36 153.09,154.66 153.52,155.09 155.56,155.09 156.09,154.56 156.09,154.43 156.34,154.18 157.12,154.18 v6(157.51,154.57)
  L3 w0.114: v6(154.97,109.4) 156.07,110.5 156.07,114.24 149.8,120.51 149.8,121.94 148.65,123.08 148.65,127.09 147.11,128.63 147.11,149.4 147.59,149.88 148.38,149.88 148.75,150.26 148.77,150.27 150.15,150.27 150.85,150.98
M_A_DQ51: length 62.8
  TOP w0.114: v6(158.5,154.58) 158.58,154.58 CPU1.AL28 ; v6(154.99,111.53) 156.37,112.91 156.37,114.48 156.38,114.48 DIMM1.229
  L3 w0.089: 150.29,151.06 150.29,151.82 151.49,153.02 151.49,154.15 152.81,155.47 157.51,155.47 158.39,154.58 v6(158.5,154.58)
  L3 w0.114: v6(154.99,111.53) 155.44,111.97 155.44,113.98 149.17,120.25 149.17,121.67 148.02,122.82 148.02,126.82 146.47,128.37 146.47,149.66 147.32,150.51 148.39,150.51 148.59,150.71 149.93,150.71 150.29,151.06
M_A_DQ52: length 62.6
  TOP w0.114: v6(159.84,112.02) 160.5,112.02 160.87,112.39 DIMM1.211 ; CPU1.AM30 158.44,153.44 v6(158.53,153.44)
  L3 w0.089: 152.4,148.07 152.4,148.14 154.31,150.05 154.54,150.05 154.81,150.32 154.81,151.3 155.41,151.89 157.77,151.89 158.09,152.22 158.09,152.66 158.33,152.9 158.7,152.9 158.81,153.01 158.81,153.34 158.71,153.44 v6(158.53,153.44)
  L3 w0.114: v6(159.84,112.02) 159.84,112.04 160.34,112.53 160.34,114.15 152.74,121.74 152.74,130.62 152.63,130.74 152.4,130.74 152.29,130.62 152.29,128.19 152.17,128.08 151.94,128.08 151.83,128.19 151.83,129.53 151.71,129.64 151.33,129.64 151.21,129.76 151.21,129.98 151.33,130.1 151.71,130.1 151.83,130.21 151.83,130.44 151.71,130.56 151.33,130.56 151.21,130.67 151.21,130.9 151.33,131.01 151.71,131.01 151.83,131.13 151.83,131.46 151.3,131.99 151.3,140.29 151.22,140.37 151.22,144.03 152.4,145.2 152.4,148.07
M_A_DQ53: length 61.7
  TOP w0.114: CPU1.AN30 157.45,152.54 v6(157.45,152.53) ; v6(159.8,109.1) 159.82,109.1 160.62,108.3 DIMM1.212
  L3 w0.089: 151.94,148.34 153.06,149.47 153.06,150.63 153.41,150.97 153.79,150.97 155.73,152.91 157.07,152.91 v6(157.45,152.53)
  L3 w0.114: v6(159.8,109.1) 159.82,109.1 160.34,108.58 160.34,108.2 160.07,107.93 159.68,107.93 159.3,108.3 159.3,114.26 152.11,121.46 152.11,126.99 150.47,128.63 150.47,136.36 150.35,136.47 150.13,136.47 150.01,136.36 150.01,135.41 149.9,135.29 149.67,135.29 149.55,135.41 149.55,137.41 149.47,137.49 149.47,143.91 151.94,146.37 151.94,148.34
M_A_DQ54: length 62
  TOP w0.114: CPU1.AP28 156.42,154.58 v6(156.5,154.58) ; v6(154.98,110.11) 155.25,110.11 157.62,107.73 157.62,107.44 DIMM1.224
  L3 w0.089: v6(156.5,154.58) 155.81,155.28 153.45,155.28 152.86,154.7 152.86,154.39 152.58,154.11 152.27,154.11 151.69,153.52 151.69,152.93 150.51,151.75 150.51,150.96
  L3 w0.114: v6(154.98,110.11) 155.75,110.88 155.75,114.11 149.48,120.38 149.48,121.8 148.33,122.95 148.33,126.95 146.79,128.5 146.79,149.53 147.45,150.19 148.38,150.19 148.68,150.49 150.04,150.49 150.51,150.96
M_A_DQ55: length 61.7
  TOP w0.114: v6(155.52,154.56) 155.44,154.56 CPU1.AR28 ; DIMM1.225 157.38,114.4 157.37,114.4 157.37,111.09 157.99,110.47 158.06,110.47 v6(158.07,110.47)
  L3 w0.089: 150.95,150.75 151.06,150.86 151.06,151.63 152.52,153.09 152.66,153.09 152.91,153.34 152.91,153.57 153.39,154.05 153.62,154.05 153.91,154.34 153.91,154.47 154.33,154.9 155.1,154.9 155.44,154.56 v6(155.52,154.56)
  L3 w0.114: 150.95,150.75 150.26,150.06 150.26,149.31 149.72,148.77 148.07,148.77 147.49,148.19 147.49,141.13 147.42,141.06 147.42,128.76 148.97,127.22 148.97,123.22 150.12,122.07 150.12,120.66 156.46,114.32 156.46,112.08 156.79,111.75 156.79,111.58 156.54,111.34 156.54,111.17 156.71,111.01 156.87,111.01 157.12,111.26 157.28,111.26 157.44,111.1 157.44,110.94 157.19,110.69 157.19,110.53 157.35,110.37 157.51,110.37 157.76,110.61 157.92,110.61 v6(158.07,110.47)
M_A_DQ56: length 70.9
  TOP w0.114: CPU1.AK27 v6(159.5,155.5) ; DIMM1.237 154.38,114.45 154.37,114.45 154.37,114.19 154.9,113.67 v6(154.97,113.67)
  L3 w0.089: 150.1,152 151.28,153.18 151.28,154.22 152.73,155.66 157.63,155.66 158.3,154.99 159.56,154.99 159.68,155.11 159.68,155.32 v6(159.5,155.5)
  L3 w0.114: 150.1,152 148.71,152 147.99,151.27 147.3,151.27 145.93,149.91 145.93,128.12 147.45,126.6 147.45,122.84 147.13,122.52 147.13,120.31 147.24,120.19 147.47,120.19 147.59,120.31 147.59,122.03 147.7,122.14 147.93,122.14 148.04,122.03 148.04,119.42 149.17,118.29 150.34,118.29 151.56,117.08 151.56,116.92 151.21,116.57 151.21,116.41 151.37,116.25 151.53,116.25 151.88,116.59 152.04,116.59 152.2,116.43 152.2,116.27 151.86,115.92 151.86,115.76 152.02,115.6 152.18,115.6 152.53,115.95 152.69,115.95 152.85,115.79 152.85,115.62 152.5,115.28 152.5,115.12 152.66,114.95 152.83,114.95 153.17,115.3 153.33,115.3 153.5,115.14 153.5,114.98 153.15,114.63 153.15,114.47 153.31,114.31 153.47,114.31 153.82,114.65 153.98,114.65 154.14,114.49 154.14,114.33 153.8,113.98 153.8,113.82 153.96,113.66 154.12,113.66 154.47,114.01 154.63,114.01 v6(154.97,113.67)
M_A_DQ57: length 71.1
  TOP w0.114: CPU1.AK26 v1(160.5,156.5) ; DIMM1.236 154.62,107.82 154.13,108.32 154.13,110.65 153.22,111.56 v6(152.84,111.56)
  L3 w0.089: 150.59,154.79 152.24,156.43 156.86,156.43 157.42,157 160.38,157 160.5,156.88 v1(160.5,156.5)
  L3 w0.114: v6(152.84,111.56) 152.84,111.32 152.57,111.05 152.21,111.05 152.04,111.21 152.04,111.94 152.16,112.06 152.22,112.06 152.33,112.17 152.33,112.4 152.22,112.52 152.16,112.52 152.04,112.63 152.04,112.86 152.16,112.97 152.22,112.97 152.33,113.09 152.33,113.32 152.22,113.43 152.16,113.43 152.04,113.54 152.04,114.11 150.41,115.74 150.26,115.74 146.04,119.96 146.04,120.72 145.93,120.84 145.6,120.84 145.48,120.95 145.48,121.18 145.6,121.3 145.93,121.3 146.04,121.41 146.04,121.79 145.93,121.9 145.58,121.9 145.47,122.02 145.47,122.25 145.58,122.36 145.93,122.36 146.04,122.47 146.04,122.7 145.93,122.82 145.58,122.82 145.47,122.93 145.47,127.23 144.98,127.72 144.98,150.3 147.29,152.61 147.63,152.61 148.93,153.91 148.93,154.1 149.63,154.79 150.59,154.79
M_A_DQ58: length 71.3
  TOP w0.114: v6(155.52,157.48) 155.52,157.55 155.97,158 CPU1.AP25 ; DIMM1.249 151.38,114.12 151.37,114.12 151.66,113.84 151.66,113.72 151.54,113.6 151.19,113.6 151.08,113.49 151.08,113.26 151.19,113.14 151.54,113.14 151.66,113.03 151.66,112.8 151.09,112.24 150.63,112.24 v6(150.25,112.63)
  L3 w0.089: 154.15,158 155.4,158 155.52,157.88 v6(155.52,157.48)
  L3 w0.114: v6(150.25,112.63) 150.25,112.51 150.13,112.39 149.85,112.39 149.71,112.52 149.71,113.87 149.55,114.03 148.21,114.03 147.67,114.57 147.67,115.92 147.25,116.33 146.57,116.33 146.46,116.22 146.46,115.84 146.35,115.73 146.12,115.73 146,115.84 146,116.22 145.89,116.33 145.48,116.33 144.39,117.42 144.39,117.58 144.47,117.65 144.47,117.81 144.31,117.97 144.14,117.97 144.07,117.9 143.91,117.9 143.74,118.07 143.74,126.56 143.33,126.97 143.33,151.04 145.45,153.16 145.45,154.13 145.56,154.24 145.72,154.24 145.85,154.11 146.01,154.11 146.17,154.27 146.17,154.43 146.04,154.57 146.04,154.73 146.2,154.89 146.37,154.89 146.5,154.76 146.66,154.76 146.82,154.92 146.82,155.08 146.69,155.21 146.69,155.37 149.32,158 149.59,158 149.71,157.88 149.71,157.58 149.82,157.47 150.05,157.47 150.16,157.58 150.16,157.88 150.28,158 150.51,158 150.62,157.88 150.62,157.58 150.73,157.47 150.96,157.47 151.08,157.58 151.08,157.88 151.19,158 151.42,158 151.53,157.88 151.53,157.58 151.65,157.47 151.88,157.47 151.99,157.58 151.99,157.88 152.11,158 152.33,158 152.45,157.88 152.45,157.58 152.56,157.47 152.79,157.47 152.91,157.58 152.91,157.88 153.02,158 154.15,158
M_A_DQ59: length 70.9
  TOP w0.114: v6(154.5,157.59) 154.92,158 CPU1.AR25 ; DIMM1.250 151.12,107.71 150.47,108.36 v6(150.25,108.36)
  L3 w0.089: 151.6,157.07 153.99,157.07 v6(154.5,157.59)
  L3 w0.114: v6(150.25,108.36) 150.25,107.05 150.36,106.94 150.73,106.94 150.84,107.05 150.84,107.97 150.96,108.08 151.18,108.08 151.3,107.97 151.3,107.07 151.41,106.96 151.64,106.96 151.76,107.07 151.76,108.38 150.8,109.34 150.72,109.42 150.72,109.46 150.71,109.47 150.71,113.53 150.39,113.85 150.18,113.85 149.68,114.35 148.34,114.35 147.98,114.7 147.98,116.05 147.38,116.65 145.63,116.65 145,117.29 145,117.73 144.05,118.68 144.05,126.69 144.04,126.7 143.64,127.1 143.64,150.91 146.05,153.31 146.05,153.65 147.2,154.81 147.2,155.44 148.33,156.56 151.09,156.56 151.6,157.07
M_A_DQ60: length 72.2
  TOP w0.114: CPU1.AN27 v6(157.5,156.5) ; v6(152.84,112.98) 153.18,112.64 153.34,112.64 153.54,112.85 153.7,112.85 153.86,112.68 153.86,112.52 153.66,112.32 153.66,112.16 153.82,112 153.98,112 154.19,112.2 154.35,112.2 154.51,112.04 154.51,111.88 154.31,111.67 154.31,111.51 154.46,111.36 154.46,108.37 154.73,108.09 155.36,108.09 155.62,107.83 DIMM1.232
  L3 w0.089: 150.78,154.63 152.39,156.23 157.37,156.23 157.5,156.36 v6(157.5,156.5)
  L3 w0.114: v6(152.84,112.98) 152.94,113.08 152.94,113.7 150.45,116.19 150.27,116.19 146.48,119.98 146.48,122.9 146.82,123.24 146.82,126.19 146.7,126.31 146.47,126.31 146.36,126.19 146.36,123.43 146.24,123.32 146.02,123.32 145.9,123.43 145.9,127.25 145.3,127.85 145.3,150.17 147.24,152.12 147.58,152.12 148.97,153.51 150.48,153.51 150.78,153.81 150.78,154.63
M_A_DQ61: length 70.9
  TOP w0.114: DIMM1.233 155.38,114.48 155.37,114.48 155.37,114.07 155.5,113.94 155.5,112.77 v6(154.97,112.24) ; CPU1.AM27 158.12,156 158.52,155.6 v6(158.52,155.5)
  L3 w0.089: 150.05,152.25 151.07,153.27 151.07,154.58 152.34,155.85 158.17,155.85 v6(158.52,155.5)
  L3 w0.114: 150.05,152.25 148.42,152.25 147.83,151.67 147.24,151.67 145.61,150.04 145.61,127.98 147.13,126.46 147.13,123.11 146.79,122.77 146.79,120.16 149.45,117.51 150.41,117.51 150.83,117.08 150.83,116.26 153.3,113.79 153.3,110.17 153.41,110.05 153.64,110.05 153.76,110.17 153.76,110.26 153.87,110.37 154.12,110.37 154.24,110.48 154.24,110.71 154.12,110.83 153.87,110.83 153.76,110.94 153.76,111.17 153.87,111.28 153.95,111.28 154.07,111.4 154.07,111.63 153.95,111.74 153.87,111.74 153.76,111.86 153.76,113.02 153.87,113.13 154.1,113.13 154.21,113.02 154.21,112.08 154.33,111.97 154.76,111.97 154.97,112.18 v6(154.97,112.24)
M_A_DQ62: length 71.1
  TOP w0.114: DIMM1.245 152.38,114.83 152.37,114.83 152.37,113.74 152.03,113.4 152.03,112.73 150.98,111.68 150.36,111.68 150.25,111.8 v6(150.25,111.92) ; v6(158.49,157.43) 159,157.94 CPU1.AL25
  L3 w0.089: v6(158.49,157.43) 158.09,157.43 157.61,157.92 156.26,157.92 155.27,158.9 153.27,158.9 152.6,158.23 151.38,158.23
  L3 w0.114: v6(150.25,111.92) 150.16,111.83 149.96,111.83 149.31,112.48 149.31,112.64 149.39,112.72 149.39,112.88 149.23,113.04 149.07,113.04 148.99,112.96 148.83,112.96 148.62,113.17 148.62,113.33 148.65,113.37 148.65,113.53 148.49,113.69 148.33,113.69 148.29,113.66 148.13,113.66 147.39,114.4 147.37,114.4 146.96,114.4 146.56,114.8 146.56,114.96 146.67,115.07 146.67,115.23 146.51,115.39 146.34,115.39 146.24,115.29 146.08,115.29 143.42,117.94 143.42,126.43 143.01,126.84 143.01,151.18 143.13,151.29 143.13,151.45 143.02,151.56 143.02,151.72 143.19,151.88 143.35,151.88 143.45,151.78 143.61,151.78 143.77,151.94 143.77,152.1 143.47,152.4 143.47,152.57 143.63,152.73 143.79,152.73 144.1,152.42 144.26,152.42 145.12,153.28 145.12,154.25 149.1,158.23 151.38,158.23
M_A_DQ63: length 72.1
  TOP w0.114: CPU1.AM25 158.03,158 v6(158.5,158.48) ; v6(150.21,109.78) 152.12,107.87 DIMM1.246
  L3 w0.114: v6(150.21,109.78) 148.83,109.78 148.76,109.86 148.76,110.16 148.87,110.27 149.15,110.27 149.26,110.39 149.26,110.61 149.15,110.73 148.87,110.73 148.76,110.84 148.76,111.07 148.87,111.19 149.15,111.19 149.26,111.3 149.26,111.53 149.15,111.64 148.87,111.64 148.76,111.76 148.76,112.13 147.13,113.76 146.7,113.76 142.78,117.68 142.78,126.17 142.37,126.57 142.37,152.41 142.56,152.59 148.69,158.72 152.5,158.72 153.1,159.32 157.66,159.32 v6(158.5,158.48)
M_A_DQS_DN0: length 85
  TOP w0.114: CPU1.G19 182.63,164 182.44,163.81 v6(182.44,163.5)
  TOP w0.127: DIMM1.11 212.87,114.1 212.78,114 212.78,113.25 213.76,112.27 214.15,112.27 v6(214.36,112.48)
  L3 w0.14: v6(182.44,163.5) 182.44,163.64 182.68,163.87 183.28,163.87 183.62,163.54 189.1,163.54 189.38,163.83 194.08,163.83 197.77,160.14 197.77,158.1 198.09,157.77 198.51,157.77 198.92,158.19 199.15,158.19 199.32,158.02 199.32,157.79 198.9,157.38 198.9,156.96 199.26,156.61 199.68,156.61 200.17,157.1 200.4,157.1 200.57,156.94 200.57,156.71 200.07,156.21 200.07,155.79 201.95,153.91 201.95,152.05 201.83,151.92 201.83,151.5 201.95,151.38 201.95,150.96 201.83,150.84 201.83,150.42 201.95,150.29 201.95,149.87 201.83,149.75 201.83,149.33 201.95,149.21 201.95,148.64 205.1,145.5 205.1,145.32 205.39,145.03 205.57,145.03 205.87,144.73 205.87,144.55 206.16,144.26 206.34,144.26 206.63,143.96 206.63,143.79 206.93,143.49 207.11,143.49 207.4,143.19 207.4,143.02 207.7,142.72 207.88,142.72 208.17,142.42 208.89,142.42 210.17,141.14 210.17,136.59 210.05,136.47 210.05,136.05 210.17,135.92 210.17,135.5 210.05,135.38 210.05,134.96 210.17,134.84 210.17,134.42 210.05,134.29 210.05,133.87 210.17,133.75 210.17,133.08 211.35,131.9 211.35,128.17 213.55,125.97 213.55,117.84 213.84,117.54 214.09,117.54 214.23,117.4 214.23,117.12 214.09,116.98 213.84,116.98 213.55,116.69 213.55,115.16 213.85,114.86 214.27,114.86 214.63,115.22 214.83,115.22 215.03,115.02 215.03,114.82 214.67,114.46 214.67,114.04 215.05,113.66 215.05,112.48 214.83,112.27 214.57,112.27 v6(214.36,112.48)
M_A_DQS_DN1: length 75.5
  TOP w0.114: v6(183.5,159.59) 183.46,159.59 183.05,160 CPU1.G23
  TOP w0.127: DIMM1.32 207.62,109.1 208.62,110.1 209.54,110.1 v6(209.77,109.88)
  L3 w0.089: v6(183.5,159.59) 183.5,159.67 183.75,159.92 184.58,159.92 184.84,160.18 185.95,160.18 186.49,159.63 186.93,159.63 186.96,159.6 186.99,159.6
  L3 w0.14: 186.99,159.6 187.59,159.6 187.73,159.46 187.73,158.92 188.02,158.62 188.52,158.62 188.82,158.92 188.82,159.46 188.96,159.6 192.84,159.6 193.76,158.68 193.76,156.22 197.69,152.29 197.69,145.91 199.84,143.76 199.84,140.19 200.84,139.19 200.84,136.02 203.49,133.37 203.91,133.37 204.2,133.66 204.43,133.66 204.6,133.5 204.6,133.26 204.3,132.97 204.3,132.55 207.15,129.71 207.15,113.83 207.57,113.41 207.57,110.84 208.26,110.15 209.49,110.15 v6(209.77,109.88)
M_A_DQS_DN2: length 66.7
  TOP w0.114: v6(184.5,156.5) CPU1.F26
  TOP w0.127: DIMM1.53 202.38,111.95 202.06,111.63 201.68,111.63 v6(201.46,111.41)
  L3 w0.089: v6(184.5,156.5) 184.5,156.28 184.61,156.17 185.1,156.17 185.22,156.29 185.76,156.29 186.44,155.61 186.44,155.47 187.83,154.08 188.21,154.08 188.25,154.12 188.27,154.12
  L3 w0.14: v6(201.46,111.41) 201.7,111.64 201.97,111.64 202.29,111.97 202.29,124.65 200.92,126.02 200.92,126.22 201.35,126.66 201.35,127.11 201.03,127.43 200.58,127.43 200.14,126.99 199.95,126.99 199.64,127.3 199.64,127.5 200.15,128 200.15,128.46 199.83,128.78 199.37,128.78 198.87,128.27 198.67,128.27 198.47,128.47 198.47,128.67 199.03,129.23 199.03,129.64 198.68,130 198.26,130 197.7,129.44 197.5,129.44 197.3,129.64 197.3,129.84 198.12,130.65 198.12,131.15 197.42,131.85 197,131.85 196.8,131.64 196.61,131.64 196.41,131.84 196.41,132.04 196.61,132.24 196.61,132.66 195.53,133.74 195.53,137.58 192.99,140.11 192.99,150.46 189.34,154.12 188.27,154.12
M_A_DQS_DN3: length 59.1
  TOP w0.114: v6(184.53,152.51) 185,152.98 CPU1.E30
  TOP w0.127: DIMM1.74 197.13,107.72 197.71,108.3 197.71,109.21 197.48,109.44 197.48,109.5 197.11,109.88 v6(197.11,110.02)
  L3 w0.14: v6(184.53,152.51) 184.16,152.14 184.16,150.92 184.39,150.69 184.39,149.39 185.1,148.67 185.1,146.18 186.74,144.55 186.74,140.36 187.43,139.68 187.43,136.51 188.2,135.74 189.25,135.74 190.56,134.42 190.56,125.37 190.69,125.24 191,125.24 191.12,125.37 191.12,127.05 191.6,127.53 192.98,127.53 193.52,126.98 193.52,123.14 196.27,120.39 196.27,112.23 196.48,112.01 196.48,109.89 196.61,109.76 196.85,109.76 v6(197.11,110.02)
M_A_DQS_DN4: length 52.1
  TOP w0.114: CPU1.AJ34 161,149.34 160.88,149.46 v6(160.55,149.46)
  TOP w0.127: v6(167.82,109.86) 167.82,109.94 168.04,110.16 168.79,110.16 169.56,110.93 169.56,113.17 169.35,113.38 169.35,114.16 169.38,114.18 DIMM1.177
  L3 w0.14: v6(167.82,109.86) 167.82,109.95 167.99,110.12 168.45,110.12 168.75,110.42 168.75,114.86 160.18,123.42 160.18,130.95 159.92,131.21 159.92,139.19 159.19,139.92 159.19,141.06 159.36,141.23 159.36,142.8 159.5,142.94 159.5,142.94 159.63,143.07 159.63,143.07 160.52,143.96 160.52,149.43 v6(160.55,149.46)
M_A_DQS_DN5: length 51.6
  TOP w0.114: CPU1.AN33 156.94,150 v6(156.52,150.42)
  TOP w0.127: v6(162.23,110.65) 162.46,110.42 163.17,110.42 163.98,109.61 163.98,108.11 164.12,107.97 DIMM1.198
  L3 w0.089: v6(156.52,150.42) 156.87,150.07 156.87,149.71 154.84,147.67 154.84,146.15 154.8,146.11 154.8,146.1
  L3 w0.14: v6(162.23,110.65) 162.45,110.43 162.78,110.43 163.18,110.83 163.18,114.6 155.49,122.29 155.49,131.53 153.97,133.05 153.97,139.7 154.62,140.36 154.8,140.54 154.8,146.1
M_A_DQS_DN6: length 61.8
  TOP w0.114: CPU1.AN29 157,153.91 156.68,153.59 v6(156.49,153.59)
  TOP w0.127: DIMM1.219 158.87,114.23 158.74,114.1 158.74,113.83 159.06,113.5 159.06,112.44 158.72,112.1 158.33,112.1 v6(158.12,111.89)
  L3 w0.089: 151.39,150.82 151.4,150.84 151.46,150.84 152.03,151.4 152.03,151.96 153.15,153.09 153.31,153.09 153.69,153.09 154.76,154.16 155.94,154.16 156.19,153.91 156.19,153.72 156.32,153.59 v6(156.49,153.59)
  L3 w0.14: 151.39,150.82 150.54,149.97 150.54,148.89 150.4,148.75 150.27,148.75 149.98,148.45 149.98,147.95 150.27,147.66 150.4,147.66 150.54,147.52 150.54,147.37 150.75,147.16 150.75,146.74 150.42,146.41 148.77,146.41 147.96,145.6 147.96,128.98 150.65,126.29 150.65,125.99 150.51,125.85 149.85,125.85 149.53,125.53 149.53,125.08 149.85,124.76 150.5,124.76 150.66,124.59 150.66,124.36 150.5,124.2 149.9,124.2 149.6,123.9 149.6,123.4 149.9,123.11 150.51,123.11 150.65,122.97 150.65,120.88 157,114.54 157,112.52 157.46,112.05 157.96,112.05 v6(158.12,111.89)
M_A_DQS_DN7: length 70.8
  TOP w0.114: v6(157.48,157.46) 157.35,157.46 157,157.11 CPU1.AN26
  TOP w0.127: DIMM1.240 153.62,107.97 153.6,108 153.6,109.35 153.37,109.58 153.2,109.58 v6(152.87,109.91)
  L3 w0.089: 151.68,156.25 151.69,156.26 151.69,156.32 152.07,156.69 156.76,156.69 157.07,157 157.07,157.3 157.22,157.46 v6(157.48,157.46)
  L3 w0.14: v6(152.87,109.91) 152.69,109.72 152.05,109.72 151.92,109.59 151.69,109.59 151.52,109.75 151.52,109.98 151.67,110.13 151.67,110.55 151.51,110.7 151.51,113.86 150.72,114.65 150.51,114.65 149.8,115.36 149.38,115.36 149.2,115.18 149,115.18 148.8,115.38 148.8,115.58 148.98,115.76 148.98,116.18 147.16,118 146.74,118 146.19,117.45 145.96,117.45 145.8,117.62 145.8,117.85 146.36,118.41 146.36,118.87 146.04,119.19 145.59,119.19 145.25,118.85 145.02,118.85 144.86,119.02 144.86,119.25 145.18,119.57 145.18,119.98 144.94,120.23 144.94,126.94 144.44,127.43 144.44,150.52 146.85,152.92 146.85,153.32 147.98,154.45 147.98,154.86 147.87,154.97 147.87,155.17 148.07,155.37 148.26,155.37 148.37,155.26 148.97,155.26 150.69,155.26 151.41,155.98 151.68,156.25
M_A_DQS_DN8: length 7.4
  TOP w0.127: v6(193.21,111.64) 192.9,111.32 192.31,111.32 191.75,111.88 191.75,113.94 191.87,114.07 DIMM1.95
  BOTTOM w0.127: R109.2 193.38,112.69 193.55,112.52 193.55,111.97 v6(193.21,111.64)
M_A_DQS_DP0: length 85.1
  TOP w0.114: CPU1.H19 182.49,164.49 v6(182.49,164.55)
  TOP w0.127: v6(214.33,111.77) 214.07,112.03 213.66,112.03 212.54,113.15 212.54,114.01 212.37,114.17 DIMM1.13
  L3 w0.14: v6(214.33,111.77) 214.56,112 214.95,112 215.32,112.37 215.32,113.77 214.93,114.15 214.93,114.35 215.3,114.71 215.3,115.13 214.94,115.48 214.52,115.48 214.16,115.12 213.96,115.12 213.81,115.27 213.81,116.58 213.95,116.72 214.2,116.72 214.5,117.01 214.5,117.51 214.2,117.81 213.95,117.81 213.81,117.95 213.81,126.08 211.61,128.28 211.61,132.01 210.44,133.19 210.44,141.25 209,142.69 208.28,142.69 202.22,148.75 202.22,154.02 200.34,155.9 200.34,156.1 200.83,156.6 200.83,157.05 200.51,157.37 200.06,157.37 199.57,156.87 199.37,156.87 199.17,157.07 199.17,157.27 199.58,157.68 199.58,158.13 199.26,158.45 198.81,158.45 198.4,158.04 198.2,158.04 198.03,158.21 198.03,160.25 194.19,164.09 189.27,164.09 188.99,163.81 183.73,163.81 183.39,164.14 182.68,164.14 182.49,164.33 v6(182.49,164.55)
M_A_DQS_DP1: length 75.8
  TOP w0.114: v6(183.49,160.4) 183.52,160.4 183.92,160 CPU1.F23
  TOP w0.127: DIMM1.34 207.12,107.83 207.38,108.09 207.38,109.2 208.52,110.34 209.48,110.34 v6(209.72,110.59)
  L3 w0.089: v6(183.49,160.4) 183.78,160.11 184.51,160.11 184.76,160.37 186.03,160.37 186.57,159.82 186.93,159.82 186.96,159.86 186.99,159.86
  L3 w0.14: v6(209.72,110.59) 209.55,110.41 208.37,110.41 207.84,110.95 207.84,113.52 207.42,113.94 207.42,129.82 204.57,132.66 204.57,132.86 204.86,133.15 204.86,133.61 204.54,133.93 204.09,133.93 203.8,133.63 203.6,133.63 201.1,136.13 201.1,139.3 200.11,140.3 200.11,143.87 197.95,146.02 197.95,152.4 194.03,156.33 194.03,158.79 192.95,159.86 188.85,159.86 188.55,159.57 188.55,159.03 188.41,158.89 188.13,158.89 187.99,159.03 187.99,159.57 187.7,159.86 186.99,159.86
M_A_DQS_DP2: length 66.4
  TOP w0.114: v6(184.5,155.5) 184.17,155.5 184,155.67 CPU1.F27
  TOP w0.127: DIMM1.55 201.87,114.25 202.13,114 202.13,112.05 201.96,111.87 201.64,111.87 201.46,112.05 v6(201.46,112.12)
  L3 w0.089: 188.27,153.85 188.25,153.85 188.21,153.89 187.75,153.89 186.25,155.39 186.25,155.53 185.68,156.1 185.3,156.1 185.18,155.98 184.61,155.98 184.5,155.86 v6(184.5,155.5)
  L3 w0.14: v6(201.46,112.12) 201.67,111.91 201.86,111.91 202.02,112.08 202.02,124.54 200.65,125.91 200.65,126.33 201.09,126.77 201.09,127 200.92,127.16 200.69,127.16 200.26,126.73 199.84,126.73 199.37,127.19 199.37,127.61 199.88,128.11 199.88,128.35 199.72,128.51 199.48,128.51 198.98,128 198.56,128 198.21,128.36 198.21,128.78 198.77,129.34 198.77,129.53 198.57,129.73 198.37,129.73 197.81,129.17 197.39,129.17 197.04,129.53 197.04,129.95 197.86,130.76 197.86,131.03 197.31,131.58 197.11,131.58 196.91,131.38 196.49,131.38 196.14,131.73 196.14,132.15 196.34,132.35 196.34,132.55 195.26,133.63 195.26,137.47 192.73,140 192.73,140.42 192.6,140.55 192.6,140.97 192.73,141.09 192.73,141.51 192.6,141.63 192.6,142.05 192.73,142.18 192.73,145.3 192.6,145.42 192.6,145.84 192.73,145.97 192.73,146.39 192.6,146.51 192.6,146.93 192.73,147.05 192.73,147.47 192.6,147.6 192.6,148.02 192.73,148.14 192.73,150.35 189.23,153.85 188.27,153.85
M_A_DQS_DP3: length 59.1
  TOP w0.114: v6(183.51,152.5) 184,152.99 CPU1.F30
  TOP w0.127: v6(197.04,109.31) 197.27,109.31 197.47,109.11 197.47,108.4 197.02,107.95 196.8,107.95 196.62,107.78 DIMM1.76
  L3 w0.14: v6(197.04,109.31) 196.85,109.5 196.5,109.5 196.21,109.78 196.21,111.9 196,112.11 196,120.28 193.25,123.03 193.25,126.87 192.87,127.26 191.71,127.26 191.39,126.94 191.39,125.26 191.11,124.97 190.58,124.97 190.3,125.26 190.3,134.31 189.14,135.47 188.09,135.47 187.16,136.4 187.16,139.57 186.48,140.25 186.48,144.43 184.84,146.07 184.84,148.56 184.12,149.28 184.12,150.58 183.89,150.81 183.89,152.12 v6(183.51,152.5)
M_A_DQS_DP4: length 52.3
  TOP w0.114: v6(160.52,150.5) 161,150.02 CPU1.AJ33
  TOP w0.127: DIMM1.179 168.87,114.39 169.11,114.16 169.11,113.28 169.32,113.07 169.32,111.03 168.69,110.4 167.96,110.4 v6(167.79,110.57)
  L3 w0.14: v6(160.52,150.5) 160.52,150.06 160.12,149.66 160.12,148.97 160.26,148.84 160.26,144.07 159.52,143.34 159.09,142.91 159.09,141.34 158.93,141.17 158.93,139.81 159.65,139.08 159.65,131.1 159.92,130.84 159.92,123.31 168.48,114.75 168.48,110.53 168.34,110.39 167.97,110.39 v6(167.79,110.57)
M_A_DQS_DP5: length 51.8
  TOP w0.114: v6(157.49,150.47) 157.49,150.51 CPU1.AN32
  TOP w0.127: v6(162.23,109.89) 162.53,110.18 163.07,110.18 163.74,109.51 163.74,108.13 163.62,108.01 DIMM1.200
  L3 w0.089: v6(157.49,150.47) 157.07,150.05 157.07,149.63 155.03,147.6 155.03,146.16 155.07,146.12 155.07,146.1
  L3 w0.14: v6(162.23,109.89) 162.51,110.16 162.9,110.16 163.45,110.72 163.45,114.71 155.76,122.4 155.76,131.64 154.24,133.16 154.24,139.59 154.73,140.09 155.07,140.43 155.07,146.1
M_A_DQS_DP6: length 61.5
  TOP w0.114: v6(155.46,153.54) 155.56,153.45 155.85,153.45 156,153.6 CPU1.AP29
  TOP w0.127: DIMM1.221 158.38,114.23 158.5,114.11 158.5,113.73 158.82,113.4 158.82,112.54 158.62,112.34 158.25,112.34 158.12,112.48 v6(158.12,112.64)
  L3 w0.089: v6(155.46,153.54) 155.88,153.54 156,153.66 156,153.83 155.86,153.97 154.84,153.97 153.77,152.9 153.23,152.9 152.22,151.88 152.22,151.33 151.59,150.7 151.59,150.65 151.57,150.63
  L3 w0.14: 151.57,150.63 150.81,149.86 150.81,148.78 150.51,148.48 150.38,148.48 150.24,148.34 150.24,148.06 150.38,147.92 150.51,147.92 150.81,147.63 150.81,147.48 151.02,147.27 151.02,146.63 150.53,146.14 148.88,146.14 148.22,145.49 148.22,133.44 148.35,133.32 148.35,132.9 148.22,132.78 148.22,132.36 148.35,132.23 148.35,131.81 148.22,131.69 148.22,131.27 148.35,131.15 148.35,130.73 148.22,130.6 148.22,130.18 148.35,130.06 148.35,129.64 148.22,129.51 148.22,129.1 150.92,126.4 150.92,125.88 150.62,125.58 149.96,125.58 149.8,125.42 149.8,125.19 149.96,125.02 150.61,125.02 150.93,124.7 150.93,124.25 150.61,123.93 150.01,123.93 149.87,123.79 149.87,123.51 150.01,123.37 150.62,123.37 150.92,123.08 150.92,120.99 157.26,114.65 157.26,112.63 157.57,112.32 157.9,112.32 158.12,112.54 v6(158.12,112.64)
M_A_DQS_DP7: length 70.9
  TOP w0.114: v6(156.48,157.43) 156.43,157.43 CPU1.AP26
  TOP w0.127: DIMM1.242 153.12,107.86 153.36,108.1 153.36,109.25 153.27,109.34 153,109.34 v6(152.84,109.17)
  L3 w0.089: 151.49,156.44 151.51,156.45 151.56,156.45 151.99,156.88 156.68,156.88 156.87,157.07 156.87,157.33 156.77,157.43 v6(156.48,157.43)
  L3 w0.14: v6(152.84,109.17) 152.55,109.46 152.16,109.46 152.03,109.32 151.58,109.32 151.33,109.56 151.25,109.64 151.25,110.09 151.4,110.24 151.4,110.44 151.24,110.59 151.24,113.75 150.61,114.38 150.4,114.38 149.69,115.1 149.49,115.1 149.31,114.92 148.89,114.92 148.54,115.27 148.54,115.69 148.72,115.87 148.72,116.07 147.05,117.74 146.85,117.74 146.3,117.19 145.85,117.19 145.53,117.51 145.53,117.96 146.1,118.53 146.1,118.76 145.93,118.92 145.7,118.92 145.37,118.58 144.91,118.58 144.59,118.9 144.59,119.36 144.91,119.68 144.91,119.87 144.67,120.12 144.67,126.83 144.18,127.32 144.18,150.63 146.58,153.03 146.58,153.43 147.71,154.56 147.71,154.75 147.6,154.86 147.6,155.28 147.96,155.64 148.37,155.64 148.48,155.53 148.97,155.53 150.58,155.53 151.39,156.34 151.49,156.44
M_A_DQS_DP8: length 7.7
  TOP w0.127: v6(193.21,110.74) 192.88,111.08 192.21,111.08 191.5,111.78 191.5,113.94 191.37,114.07 DIMM1.97
  BOTTOM w0.127: v6(193.21,110.74) 193.42,110.54 193.42,108.68 R110.2
M_A_EVENT#: length 54.6
  TOP w0.114: DIMM1.134 182.13,108.23 182.22,108.32 v6(182.22,108.34) ; v6(171.55,149.46) 171.5,149.41 171.5,148.5 CPU1.W35
  L3 w0.114: v6(182.22,108.34) 182.68,108.8 182.68,109.1 182.98,109.39 182.98,113.85 182.95,113.87 182.95,117.4 183.11,117.56 183.11,117.94 175.92,125.13 175.92,133.44 174.24,135.12 174.24,138.78 174.01,139.01 173.98,138.98 173.64,138.98 173.4,139.23 173.4,139.29 173.37,139.29 173.37,148.13 173.91,148.67 173.91,149.67 173.67,149.91 172,149.91 v6(171.55,149.46)
  BOTTOM w0.114: v6(171.55,149.46) 171.55,148.05 RN2416.4 ; v6(182.22,108.34) v2(182.22,107.54)
M_A_ODT0: length 48.1
  TOP w0.178: v6(166.58,147.5) 166.08,148 CPU1.AD35 ; DIMM1.155 174.87,112.97 175.41,112.43 175.41,112.18 174.82,111.59 174.82,111.34 175.07,111.09 175.32,111.09 175.91,111.68 176.17,111.68 176.56,111.28 v6(176.58,111.28)
  L3 w0.191: v6(166.58,147.5) 166.58,140.16 167.73,139.01 167.73,124.05 174.51,117.27 174.51,112.56 175.79,111.28 v6(176.58,111.28)
M_A_ODT1: length 48.4
  TOP w0.178: CPU1.AF31 164.43,151.57 v6(164.43,151.49) ; DIMM1.161 173.37,114.07 173.18,113.88 173.18,113.62 173.64,113.17 173.64,112.92 173.39,112.67 173.13,112.67 172.68,113.12 172.43,113.12 v6(172.22,112.91)
  L3 w0.191: v6(172.22,112.91) 172.22,114.74 171.46,115.5 171.46,117.17 165.51,123.13 165.51,136.17 162.46,139.22 162.46,142.79 163.95,144.28 163.95,150.65 164.43,151.12 v6(164.43,151.49)
M_A_RAS#: length 50.4
  TOP w0.178: v6(176.58,109.86) 176.58,109.85 175.62,108.89 DIMM1.152 ; CPU1.AB34 167.99,149 v6(167.46,149.53)
  L3 w0.089: 166,148.15 166,149.56 166.33,149.9 167.09,149.9 v6(167.46,149.53)
  L3 w0.191: v6(176.58,109.86) 174.07,112.37 174.07,115.71 173.24,116.54 173.24,117.91 167.28,123.86 167.28,137.81 165.51,139.59 165.51,144.23 166,144.71 166,148.15
M_A_WE#: length 47.8
  TOP w0.178: CPU1.AB35 167.51,148.49 v6(167.43,148.49) ; v6(176.56,112.81) 175.87,113.49 DIMM1.151
  L3 w0.191: v6(167.43,148.49) 167.1,148.17 167.1,140.53 168.17,139.47 168.17,124.23 176.13,116.28 176.13,115.81 175.89,115.57 175.18,115.57 174.98,115.36 174.98,114.81 175.18,114.61 176.39,114.61 176.58,114.42 176.58,113.9 176.39,113.71 175.25,113.71 175.06,113.52 175.06,113 175.25,112.81 v6(176.56,112.81)
M_B_A0: length 61.6
  TOP w0.102: CPU1.AC36 167.47,146.53 167.47,145.82 167.75,145.54 168.19,145.54 168.61,145.12 168.61,143.84 168.64,143.8 168.64,142.61 168.32,142.29 168.32,142.29 v6(168.01,141.98)
  TOP w0.178: DIMM2.144 179.62,93.32 v6(179.65,93.35)
  L6 w0.165: v6(168.01,141.98) 168.48,141.51 168.48,140.18 168.36,140.06 168.36,136.89 171.89,133.36 171.89,123.32 178.68,116.53 178.68,103.76 179.23,103.21 179.23,98.43 179.02,98.22 179.02,94.62 179.65,93.99 v6(179.65,93.35)
M_B_A1: length 57
  TOP w0.102: v6(173.83,142.59) 173.42,143 173.42,143.47 173.58,143.64 173.58,145.98 173,146.57 CPU1.U36
  TOP w0.178: v6(183.06,98.11) 183.04,98.11 183.04,98.12 182.76,98.12 182.38,98.5 182.38,98.69 182.37,98.7 DIMM2.133
  L6 w0.165: v6(183.06,98.11) 183.21,98.26 183.21,100.39 183.78,100.97 183.78,107.39 182.99,108.18 182.99,117.5 175.78,124.71 175.78,134.87 172.68,137.98 172.68,141.44 v6(173.83,142.59)
M_B_A2: length 60.4
  TOP w0.102: CPU1.U37 173,145.87 173.38,145.49 173.38,143.72 173.22,143.56 173.22,139.99 v6(173.81,139.4)
  TOP w0.178: v6(183.16,94.37) 182.62,93.83 DIMM2.132
  L6 w0.165: v6(173.81,139.4) 173.81,138.85 177.04,135.63 177.04,125.24 184.42,117.86 184.42,113.9 184.82,113.5 184.82,113.49 184.89,113.42 184.89,113.42 184.9,113.4 184.9,112.83 185.04,112.7 185.04,100.42 184.58,99.96 184.58,95.79 v6(183.16,94.37)
M_B_A3: length 57.8
  TOP w0.102: v6(173.86,141.96) 174.35,142.45 174.35,143.6 174.38,143.63 174.38,144.49 174,144.87 CPU1.T38
  TOP w0.178: v6(183.14,96.65) 183.6,97.11 183.6,98.27 182.87,98.99 DIMM2.131
  L6 w0.165: v6(183.14,96.65) 183.64,97.15 183.64,100.21 184.2,100.77 184.2,112.28 184.06,112.41 184.06,113.06 183.55,113.57 183.55,117.54 176.2,124.9 176.2,135.09 173.1,138.19 173.1,141.2 173.86,141.96 v6(173.86,141.96)
M_B_A4: length 60.9
  TOP w0.102: CPU1.T37 174.58,145.42 174.58,143.55 174.55,143.51 174.55,142.3 174.32,142.06 174.32,141.16 v6(173.84,140.69)
  TOP w0.178: DIMM2.128 183.62,93.73 183.95,94.06 183.95,95.16 183.35,95.76 183.17,95.76 v6(183.13,95.79)
  L6 w0.165: v6(173.84,140.69) 173.37,140.22 173.37,138.57 176.62,135.33 176.62,125.07 184,117.69 184,113.72 184.47,113.25 184.47,113.24 184.48,113.23 184.48,112.58 184.62,112.45 184.62,100.59 184.11,100.08 184.11,96.77 v6(183.13,95.79)
M_B_A5: length 58.9
  TOP w0.178: v6(174.98,143.33) 174.98,143.98 CPU1.R39 ; DIMM2.126 184.12,93.06 184.42,93.35 184.42,93.36 v6(185.07,94)
  L6 w0.165: v6(185.07,94) 185.21,94.15 185.22,94.15 186.19,95.12 186.19,96.52 187.5,97.83 187.5,113.48 186.09,114.88 186.09,118.56 178.71,125.94 178.71,136.83 175.57,139.97 175.57,142.75 v6(174.98,143.33)
M_B_A6: length 61.2
  TOP w0.102: CPU1.R36 174.62,146.62 174.62,145.84 175.08,145.38 175.16,145.38 175.59,144.95 175.59,143.62 175.62,143.6 175.62,141.21 175.53,141.13 175.25,141.13 v6(174.95,141.43)
  TOP w0.178: v6(185.12,96.93) 185.1,96.95 184.77,96.95 183.98,97.74 183.98,98.8 183.87,98.9 DIMM2.127
  L6 w0.102: v6(174.95,141.43) 174.56,141.04 174.56,139.54 175,139.11
  L6 w0.165: v6(185.12,96.93) 186.66,98.47 186.66,113.13 185.26,114.53 185.26,118.21 177.88,125.59 177.88,136.22 175,139.11
M_B_A7: length 60.9
  TOP w0.178: DIMM2.122 185.12,92.81 185.98,93.67 185.98,94.76 v6(185.22,95.52) ; CPU1.P39 176,139.55 175.84,139.4 175.13,139.4 174.97,139.55 v6(174.97,140.03)
  L6 w0.165: v6(174.97,140.03) 174.97,139.81 178.3,136.48 178.3,125.77 185.67,118.39 185.67,114.71 187.08,113.31 187.08,98.18 185.72,96.82 185.72,96.02 v6(185.22,95.52)
M_B_A8: length 56.4
  TOP w0.102: v6(174.93,142.06) 174.96,142.06 175.42,142.52 175.42,143.51 175.39,143.54 175.39,144.26 175,144.65 CPU1.R38
  TOP w0.178: DIMM2.125 184.37,97.83 184.76,97.44 184.93,97.44 v6(185.13,97.64)
  L6 w0.102: 174.53,138.92 174.36,139.1 174.36,141.49 v6(174.93,142.06)
  L6 w0.165: 174.53,138.92 177.46,136 177.46,125.42 184.84,118.04 184.84,114.1 185.32,113.62 185.32,113.01 185.46,112.87 185.46,106.45 186.21,105.7 186.21,98.72 v6(185.13,97.64)
M_B_A9: length 64.6
  TOP w0.102: v6(177.03,142.06) 176.51,142.58 176.51,143.42 176.58,143.5 176.58,146.42 CPU1.P36
  TOP w0.178: DIMM2.121 185.37,98.92 186.22,98.07 186.22,95.26 v6(186.64,94.84)
  L6 w0.165: v6(177.03,142.06) 176.54,141.57 176.54,140.47 179.55,137.46 179.55,126.29 189.01,116.83 189.01,97.13 186.72,94.84 v6(186.64,94.84)
M_B_A10: length 57.9
  TOP w0.178: v6(167.94,140.59) 167,141.53 CPU1.AC39 ; DIMM2.146 177.12,92.31 v6(177.98,93.17)
  L6 w0.165: v6(177.98,93.17) 178,93.17 178.6,93.77 178.6,98.39 178.81,98.6 178.81,103.04 178.2,103.65 178.2,106.07 177.62,106.66 177.62,117 171.47,123.15 171.47,133.19 167.94,136.72 v6(167.94,140.59)
M_B_A11: length 61.5
  TOP w0.102: v6(176.98,140.72) 176.3,141.4 176.3,143.75 176.38,143.82 176.38,145.62 CPU1.P37
  TOP w0.178: v6(186.52,93.98) 186.52,93.65 185.62,92.76 DIMM2.120
  L6 w0.165: v6(176.98,140.72) 180.02,137.68 180.02,126.41 189.43,117.01 189.43,96.89 v6(186.52,93.98)
M_B_A12: length 61.9
  TOP w0.102: v6(177.01,142.69) 177.46,143.14 177.46,144.53 CPU1.N38
  TOP w0.178: v6(186.86,96.31) 186.86,97.96 185.87,98.94 DIMM2.119
  L6 w0.165: v6(186.86,96.31) 188.56,98.02 188.56,103.6 187.98,104.18 187.98,117.26 179.13,126.11 179.13,137.22 176.27,140.08 176.27,143.23 176.81,143.76 177.17,143.76 177.43,143.51 177.43,143.11 v6(177.01,142.69)
M_B_A13: length 58.6
  TOP w0.102: CPU1.AG38 163.57,144.43 163.57,143.88 163.77,143.68 163.77,139.88 v6(163.19,139.3)
  TOP w0.178: v6(174.1,94.87) 174.1,93.7 174.12,93.67 DIMM2.158
  L6 w0.165: v6(163.19,139.3) 163.97,138.51 163.97,138.51 164.14,138.35 164.14,135.78 167.94,131.98 167.94,121.51 172.33,117.12 172.33,116.38 173.54,115.17 173.54,104.56 174.34,103.76 174.34,95.12 v6(174.1,94.87)
M_B_ACT_N: length 59.9
  TOP w0.102: 178.4,143.44 178.4,144.6 CPU1.M38
  TOP w0.178: v6(178.98,141.95) 178.78,141.95 178.4,142.33 178.4,143.44 ; v6(189.21,94.92) 188.53,94.92 187.86,94.25 187.86,93.91 187.77,93.82 187.77,93.43 187.12,92.78 DIMM2.114
  L6 w0.165: v6(189.21,94.92) 189.21,95.98 189.84,96.62 189.84,117.18 180.5,126.53 180.5,139.03 178.98,140.55 v6(178.98,141.95)
M_B_BG0: length 64
  TOP w0.102: v6(178.98,143.31) 178.61,143.68 178.61,146.39 CPU1.M36
  TOP w0.178: DIMM2.115 186.87,98.8 v6(190.78,94.89)
  L6 w0.165: v6(178.98,143.31) 179.94,142.34 179.94,141.04 180.99,139.99 180.99,126.63 190.26,117.35 190.26,95.76 190.78,95.24 v6(190.78,94.89)
M_B_BG1: length 61.8
  TOP w0.178: CPU1.M39 178,141.89 179.14,140.75 v6(180.93,140.75) ; DIMM2.113 187.37,98.99 190.02,96.34 190.35,96.34 v6(191.29,95.4)
  L6 w0.165: v6(191.29,95.4) 191.05,95.64 191.05,101.42 191.44,101.8 191.44,116.77 181.41,126.8 181.41,140.28 v6(180.93,140.75)
M_B_BS0: length 59.7
  TOP w0.102: CPU1.AD38 166.39,144.61 166.39,143.57 v6(165.98,143.16)
  TOP w0.178: DIMM2.150 176.12,92.91 v6(177.93,94.72)
  L6 w0.165: v6(177.93,94.72) 178.14,94.92 178.14,98.52 178.39,98.78 178.39,102.87 177.78,103.48 177.78,105.79 177.07,106.49 177.07,116.95 171.05,122.97 171.05,133.02 167.44,136.63 167.44,141.7 v6(165.98,143.16)
M_B_BS1: length 55.9
  TOP w0.102: v6(165.96,141.84) 166.6,142.48 166.6,145.6 CPU1.AC37
  TOP w0.178: v6(177.6,97.81) 177.6,97.89 177.37,98.12 DIMM2.145
  L6 w0.165: v6(165.96,141.84) 166.83,140.96 166.83,136.64 170.63,132.84 170.63,122.8 176.07,117.36 176.07,106.9 177.29,105.68 177.29,103.37 177.98,102.69 177.98,98.95 177.6,98.58 v6(177.6,97.81)
M_B_CAS#: length 61.6
  TOP w0.102: v6(162.99,141.31) 163.37,141.68 163.37,143.09 162.62,143.84 162.62,146.16 162.87,146.41 163.41,146.41 CPU1.AF36
  TOP w0.178: v6(174.71,94.13) 174.62,94.05 DIMM2.156
  L6 w0.165: v6(174.71,94.13) 174.76,94.19 174.76,104.03 173.96,104.83 173.96,115.34 172.75,116.55 172.75,117.31 168.36,121.7 168.36,132.15 164.56,135.95 164.56,138.52 164.03,139.05 164.03,140.32 163.04,141.31 v6(162.99,141.31)
M_B_CKE0: length 60.2
  TOP w0.102: v6(180.96,142.04) 180.39,142.6 180.39,145.16 180.16,145.39 179.9,145.39 179.29,146 CPU1.L37
  TOP w0.178: DIMM2.109 188.37,98.6 190.2,96.78 191.52,96.78 v6(191.57,96.82)
  L6 w0.165: v6(180.96,142.04) 181.83,141.17 181.83,126.98 191.86,116.95 191.86,101.59 191.57,101.3 v6(191.57,96.82)
M_B_CKE1: length 62.6
  TOP w0.102: v6(181.01,143.31) 180.81,143.31 180.61,143.51 180.61,145.39 CPU1.K37
  TOP w0.178: DIMM2.110 188.12,92.93 188.2,93 188.2,93.64 188.67,94.1 v6(188.67,94.35)
  L6 w0.165: v6(188.67,94.35) 188.77,94.35 188.83,94.42 189.44,94.42 189.45,94.4 190.99,94.4 192.12,95.54 192.12,101.24 192.27,101.4 192.27,117.12 182.25,127.15 182.25,142.07 v6(181.01,143.31)
M_B_CLK0: length 62.8
  TOP w0.178: v6(170.47,140.14) 170.6,140.27 171.93,140.27 172.67,141 172.67,143.67 CPU1.U39 ; v6(179.75,95.6) 179.92,95.77 180.56,95.77 181.27,96.49 181.27,98.92 181.37,99.02 DIMM2.137
  L6 w0.165: v6(170.47,140.14) 170.27,140.34 170.1,140.34 169.98,140.21 169.98,137.73 173.65,134.06 173.65,123.82 180.3,117.17 180.3,107.87 181.09,107.07 181.09,106.36 180.76,106.02 180.48,106.02 180.32,105.86 180.32,105.31 180.48,105.15 180.76,105.15 181.11,104.79 181.11,96.38 180.65,95.92 180.07,95.92 v6(179.75,95.6)
M_B_CLK1: length 62.3
  TOP w0.102: CPU1.V38 171.6,144.6 171.6,142.91 171.09,142.4 170.74,142.4 v6(170.48,142.13)
  TOP w0.178: v6(180.38,95.07) 180.63,94.83 180.97,94.83 181.39,94.41 181.39,93.19 181.03,92.83 181.03,92.63 181.12,92.54 DIMM2.138
  L6 w0.165: v6(180.38,95.07) 180.65,94.8 180.99,94.8 182.02,95.82 182.02,100.85 182.61,101.45 182.61,106.79 181.17,108.23 181.17,117.6 174.56,124.22 174.56,134.41 171.45,137.52 171.45,142.02 171.11,142.35 170.7,142.35 v6(170.48,142.13)
M_B_CLK#0: length 62.5
  TOP w0.178: v6(170.48,140.83) 170.73,140.58 171.8,140.58 172.35,141.14 172.35,143.65 CPU1.V39 ; v6(179.75,96.47) 179.75,96.33 179.99,96.09 180.42,96.09 180.95,96.62 180.95,98.89 180.87,98.97 DIMM2.139
  L6 w0.165: v6(179.75,96.47) 180.01,96.21 180.53,96.21 180.82,96.5 180.82,104.67 180.63,104.85 180.36,104.85 180.02,105.19 180.02,105.98 180.36,106.32 180.63,106.32 180.8,106.48 180.8,106.95 180.49,107.26 180.01,107.75 180.01,117.05 173.36,123.7 173.36,124.19 173.25,124.31 173.25,124.8 173.36,124.91 173.36,125.41 173.25,125.52 173.25,126.02 173.36,126.13 173.36,126.63 173.25,126.74 173.25,127.24 173.36,127.35 173.36,130.28 173.25,130.39 173.25,130.89 173.36,131 173.36,131.5 173.25,131.61 173.25,132.11 173.36,132.22 173.36,132.72 173.25,132.83 173.25,133.33 173.36,133.44 173.36,133.93 169.68,137.61 169.68,140.34 169.98,140.63 170.28,140.63 v6(170.48,140.83)
M_B_CLK#1: length 62.4
  TOP w0.102: CPU1.W38 171.4,144.6 171.4,142.99 171,142.6 170.74,142.6 v6(170.48,142.86)
  TOP w0.178: DIMM2.140 180.62,92.58 180.72,92.67 180.72,92.97 181.07,93.32 181.07,94.27 180.84,94.51 180.64,94.51 v6(180.38,94.25)
  L6 w0.165: v6(170.48,142.86) 170.7,142.65 171.23,142.65 171.74,142.14 171.74,137.64 174.85,134.53 174.85,124.34 181.47,117.72 181.47,108.35 182.9,106.92 182.9,101.33 182.31,100.73 182.31,95.7 181.12,94.51 180.64,94.51 v6(180.38,94.25)
M_B_CS#0: length 60.1
  TOP w0.102: CPU1.AE37 164.55,145.55 164.55,143.71 164.32,143.47 164.32,142.76 v6(164.72,142.35)
  TOP w0.178: v6(177.6,96.29) 177.5,96.19 177.06,96.19 176.8,96.45 176.8,97.61 176.37,98.04 DIMM2.149
  L6 w0.165: v6(164.72,142.35) 166.35,140.73 166.35,136.53 170.16,132.72 170.16,122.6 175.65,117.11 175.65,106.73 176.78,105.6 176.78,97.11 v6(177.6,96.29)
M_B_CS#1: length 56.2
  TOP w0.102: CPU1.AG39 163.57,143.43 163.57,141.13 v6(163.09,140.64)
  TOP w0.178: v6(173.79,96.59) 174.37,97.18 DIMM2.157
  L6 w0.165: v6(173.79,96.59) 173.92,96.73 173.92,101.46 173.12,102.26 173.12,114.99 171.9,116.21 171.9,116.86 167.52,121.24 167.52,131.81 163.68,135.64 163.68,137.93 162.75,138.86 162.75,140.31 v6(163.09,140.64)
M_B_DQ0: length 93.2
  TOP w0.102: 189.53,162.4 186.6,162.4 CPU1.D20
  TOP w0.114: 189.53,162.4 191.53,162.4 v6(192.35,163.22) ; v6(216.12,94.43) 215.42,94.43 213.69,92.7 213.69,92.42 213.62,92.36 DIMM2.8
  L6 w0.102: v6(192.35,163.22) 192.73,162.84 193.57,162.84 205.21,151.2 205.21,149.68 210.6,144.3 210.6,124.45 219.29,115.76 219.29,102.58 217.69,100.98 217.69,95.46 216.66,94.43 v6(216.12,94.43)
M_B_DQ1: length 91.8
  TOP w0.114: DIMM2.7 213.87,98.54 v6(214.34,98.08) ; CPU1.B21 v6(187.5,161.5)
  L6 w0.102: v6(187.5,161.5) 187.91,161.91 191.05,161.91 191.43,161.52 193.57,161.52 204.27,150.83 204.27,147.78 207.99,144.06 207.99,141.17 209.63,139.54 209.63,124.04 218.38,115.29 218.38,106.11 218.23,105.97 217.79,105.97 217.69,105.86 217.69,105.66 217.79,105.56 218.23,105.56 218.33,105.46 218.33,105.25 218.23,105.15 217.12,105.15 217.01,105.05 217.01,104.85 217.12,104.75 218.23,104.75 218.33,104.64 218.33,104.44 218.23,104.34 216.4,104.34 216.3,104.24 216.3,104.04 216.4,103.93 218.23,103.93 218.33,103.83 218.33,103.38 214.34,99.38 v6(214.34,98.08)
