# Allegro board 16544-1.0322WZS1614.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 192.41,22.99 192.15,23.24 192.15,23.29 192.02,23.42 190.83,23.42 190.53,23.72 190.53,24.23 191.39,25.1 191.39,26.29 190.63,27.05 190.63,28.19 193.42,30.99 194.69,30.99 194.82,30.86 194.82,30.48 194.56,30.23 194.56,29.34 194.44,29.21 194.44,28.56 194.82,28.18 196.08,28.18 196.34,27.91 199.77,27.91 199.95,27.74 199.95,27.1 198.96,26.11 198.96,24.56 199.21,24.31 199.21,23.57 199.06,23.42 196.14,23.42 195.71,22.99 ; 14 cut-outs
GND on BOTTOM: 115.14,204.19 115.09,204.24 115.09,205.54 114.99,205.64 114.71,205.64 114.68,205.66 114.68,206.78 114.75,206.85 114.75,207.1 114.63,207.21 114.63,208.56 114.22,208.97 114.22,209.98 114.63,210.39 115.6,210.39 115.75,210.24 115.75,210.11 115.74,210.1 115.74,209.61 115.89,209.46 115.89,209.05 115.34,208.51 115.34,206.86 115.44,206.76 115.72,206.76 115.77,206.71 115.77,205.69 115.75,205.66 115.37,205.66 115.32,205.61 115.32,204.24 115.27,204.19
GND on BOTTOM: 116.46,213.36 116.31,213.51 116.31,215.49 115.7,216.1 115.7,218.34 115.85,218.49 119.23,218.49 119.56,218.16 119.56,216.66 119.13,216.23 119.13,215.39 119.38,215.14 119.76,215.14 120.27,214.63 120.27,213.61 120.02,213.36
GND on L2GND: outline of 92 points within 0.76,0.76 235.24,235.24 ; 31 cut-outs
GND on L3: outline of 85 points within 0.76,0.76 235.24,235.24
GND on L3: 162.31,172.85 167.13,172.85 168.02,173.74 178.94,173.74 180.72,171.96 180.72,162.31 180.21,161.8 180.21,161.04 180.47,160.78 181.36,160.78 181.86,160.27 181.86,159.38 180.72,158.24 180.09,158.24 179.83,157.99 179.83,156.72 181.36,155.19 181.74,155.19 181.86,155.07 181.86,154.43 181.23,153.8 180.21,153.8 179.58,153.16 178.31,153.16 178.05,153.42 178.05,153.67 177.55,154.18 175.01,154.18 172.85,152.02 162.43,152.02 160.78,153.67 160.78,154.69 160.27,155.19 160.27,156.97 159.26,157.99 159.26,160.02 161.54,162.31 161.54,167.13 159.64,169.04 158.62,169.04 157.99,169.67 157.99,170.94 156.97,171.96 156.97,172.97 157.35,173.35 161.8,173.35
GND on L3: 0.76,135.89 0.76,185.04 3.56,182.25 11.18,182.25 13.46,179.96 13.46,170.43 8.51,165.48 8.51,143.64
GND on L3: 153.29,106.81 173.48,106.81 174.88,105.41 181.74,105.41 184.4,102.74 189,102.74 189.59,103.33 189.59,105.46 192.02,107.9 192.02,107.95 193.04,108.97 194.56,108.97 196.47,107.06 202.44,107.06 203.2,106.3 203.2,101.09 201.8,99.69 201.8,97.16 201.04,96.39 201.04,83.19 199.64,81.79 182.12,81.79 180.34,83.57 169.54,83.57 165.1,88.01 164.08,88.01 162.22,89.88 160.36,89.88 158.67,91.57 153.54,91.57 152.4,92.71 152.4,94.74 152.65,95 152.65,106.17
GND on L3, L4: 166.37,56.39 169.8,56.39 170.81,55.37 170.81,52.58 170.05,51.82 170.05,50.42 169.67,50.04 169.04,50.04 168.53,49.53 168.53,48.9 168.28,48.64 166.24,48.64 163.83,51.05 163.83,53.85
GND on L4: 78.7,0.76 78.53,0.83 78.46,1 78.46,102 77.95,103.25 76.7,103.76 1,103.76 0.83,103.83 0.76,104 0.76,235 0.83,235.17 1,235.24 235,235.24 235.17,235.17 235.24,235 235.24,102.06 234.52,102.06 234.52,145.85 234.31,146.05 226.19,146.05 225.43,146.81 223.52,146.81 220.6,149.73 220.6,158.88 220.98,159.26 228.09,159.26 232.16,163.32 232.16,198.75 234.52,201.12 234.52,233.96 233.83,234.65 16.21,234.65 2.03,220.47 2.03,115.95 9.4,108.58 9.4,106.18 10.54,105.03 76.7,105.03 78.82,104.17 79.73,102.06 79.71,102.06 79.67,102.03 79.67,101.97 79.71,101.94 79.73,101.94 79.73,11.76 83.36,8.13 84.4,8.13 90.5,2.03 115.57,2.03 116.33,1.27 120.27,1.27 121.03,2.03 216.36,2.03 217.65,3.33 223.85,3.33 229.46,8.94 231.89,8.94 233.97,11.02 233.97,19.68 233.17,20.47 233.17,22 233.43,22.25 233.82,22.25 233.97,22.4 233.97,64.7 234.52,65.25 234.52,101.86 234.59,101.94 235.24,101.94 235.24,1 235.17,0.83 235,0.76
GND on L4: 153.29,106.81 173.48,106.81 174.88,105.41 181.74,105.41 184.4,102.74 189.08,102.74 189.33,103 189.36,103 189.61,103.25 189.61,107.06 192.53,109.98 193.55,109.98 196.47,107.06 202.44,107.06 203.2,106.3 203.2,101.09 201.8,99.69 201.8,97.16 201.04,96.39 201.04,83.19 199.64,81.79 182.12,81.79 180.34,83.57 169.54,83.57 165.1,88.01 162.23,88.01 158.67,91.57 153.54,91.57 152.4,92.71 152.4,94.74 152.65,95 152.65,106.17
GND on L5GND: 78.7,0.76 78.53,0.83 78.46,1 78.46,102 77.95,103.25 76.7,103.76 1,103.76 0.83,103.83 0.76,104 0.76,235 0.83,235.17 1,235.24 235,235.24 235.17,235.17 235.24,235 235.24,1 235.17,0.83 235,0.76 ; 23 cut-outs
GND on L6: 101.85,104.39 107.95,104.39 108.58,103.76 108.58,102.36 104.14,97.92 96.01,97.92 86.87,88.77 86.87,85.85 85.72,84.71 81.79,84.71 81.41,85.09 81.41,97.03 81.66,97.28 86.74,97.28 90.55,101.09 94.74,101.09 95.25,101.6 99.06,101.6
GND on L6: outline of 136 points within 0.76,0.76 235.24,235.24
GND on L6: 209.68,33.93 214.83,33.93 215.42,33.35 215.42,32.46 214.15,31.19 212.88,31.19 211.79,30.1 211.79,28.8 212.55,28.04 219.25,28.04 219.48,28.27 222,28.27 223.11,27.15 223.11,24.59 226.75,20.95 226.75,16.84 226.43,16.52 226.33,16.52 226.19,16.38 225.68,16.38 225.43,16.64 225.04,16.64 224.79,16.38 224.79,15.11 225.04,14.86 225.55,14.86 225.81,15.11 225.81,15.24 225.93,15.37 225.96,15.37 226.42,14.91 226.42,13.74 225.93,13.26 217.81,13.26 217.37,12.83 217.37,9.5 217.63,9.25 219.79,9.25 221.95,11.4 223.44,11.4 223.55,11.3 223.55,9.65 218.44,4.55 195.96,4.55 194.36,6.15 194.36,12.01 193.22,13.16 189.89,13.16 189.84,13.11 184.78,13.11 184.35,13.54 183.95,13.54 183.77,13.72 183.77,18.21 185.98,20.42 186.44,20.42 186.82,20.04 204.39,20.04 207.31,22.96 207.31,26.04 205.84,27.51 204.7,27.51 204.43,27.77 204.47,27.81 204.47,28.96 205.36,29.84 205.49,29.84 205.99,30.35 205.99,30.86 206.25,31.11 207.65,31.11 209.04,32.51 209.04,33.3
GND on L7GND: 78.7,0.76 78.53,0.83 78.46,1 78.46,102 77.95,103.25 76.7,103.76 1,103.76 0.83,103.83 0.76,104 0.76,235 0.83,235.17 1,235.24 235,235.24 235.17,235.17 235.24,235 235.24,1 235.17,0.83 235,0.76 ; 25 cut-outs
VBAT_SB_N on TOP: 128.4,42.16 128.27,42.29 128.27,42.39 127.69,42.39 127.36,42.72 126.29,42.72 126.01,43 126.01,43.81 126.19,43.99 127.28,43.99 127.48,44.2 128.27,44.2 128.4,44.07 128.4,43.05 128.52,42.93 129.16,42.93 129.41,42.67 129.41,42.42 129.16,42.16 ; 2 cut-outs
VCC3_CAM on TOP: 221.62,65.02 221.49,65.15 221.49,67.18 222.5,68.2 224.16,68.2 224.41,67.94 226.57,67.94 226.95,67.56 226.95,66.17 227.2,65.91 228.85,65.91 229.11,65.66 229.11,65.15 228.98,65.02 ; 3 cut-outs
0D6V_S0 on TOP: 228.7,134.54 228.12,135.13 228.12,135.69 227.97,135.84 227.97,136.14 228.02,136.19 229.08,136.19 229.16,136.27 229.87,136.27 230,136.4 230.5,136.4 230.63,136.27 230.63,134.87 230.38,134.62 230.12,134.62 230.11,134.63 229.48,134.63 229.39,134.54
0D6V_S0 on BOTTOM: 185.17,86.11 184.66,86.61 158.24,86.61 158.23,86.63 156.35,86.63 151.52,91.45 151.12,91.45 151.1,91.44 148.74,91.44 147.09,93.09 146.23,93.09 142.34,96.98 142.34,104.47 143.43,105.56 147.04,105.56 147.27,105.33 147.27,104.39 146.96,104.09 145.49,104.09 145.43,104.03 144.51,104.03 143.99,103.5 143.99,98.58 145.8,96.77 145.8,95.73 146.69,94.84 148.95,94.84 149.76,94.03 150.98,94.03 151.04,93.97 151.04,92.9 151.37,92.57 152.84,92.57 156.64,88.77 185.67,88.77 185.8,88.65 185.93,88.65 186.82,87.76 227.97,87.76 231.65,91.44 231.65,97.92 232.41,98.68 232.41,133.55 231.34,134.62 230.89,134.62 230.86,134.59 229.74,134.59 229.57,134.77 229.57,136.04 229.67,136.14 229.69,136.14 229.92,136.37 232.44,136.37 233.81,135 233.81,95.12 233.17,94.49 233.17,90.68 228.6,86.11 ; 5 cut-outs
0D8V_VGA on TOP: 115.35,190.04 115.03,190.36 115.03,191.72 115.18,191.87 118.87,191.87 119.13,191.62 119.13,190.32 118.85,190.04
0D8V_VGA on BOTTOM: 115.57,189.74 115.06,190.25 115.06,191.26 115.32,191.52 118.75,191.52 119,191.26 119,190.25 118.49,189.74
0D8V_VGA on L3: 119.02,192.02 119.28,191.77 119.28,188.19 114.6,183.51 92.46,183.51 92.08,183.13 92.08,171.83 90.93,170.69 90.93,169.54 90.3,168.91 87.17,168.91 87.15,168.94 82.3,168.94 81.92,169.32 81.92,178.94 79.63,181.23 79.63,183.77 80.64,184.78 86.74,184.78 86.74,185.93 95.38,194.56 108.84,194.56 110.62,192.79 110.62,189.61 110.74,189.48 111.63,189.48 114.17,192.02 ; 3 cut-outs
0D775V_S5 on TOP: 130.94,209.04 130.68,209.3 130.68,211.33 130.94,211.58 132.08,211.58 132.33,211.33 132.33,209.42 131.95,209.04 ; 2 cut-outs
0D775V_S5 on TOP: 133.86,202.69 133.6,202.95 133.6,204.34 133.73,204.47 135.64,204.47 136.02,204.09 136.02,202.82 135.89,202.69 ; 2 cut-outs
0D775V_VDDCR_SOC_S5 on TOP: 133.58,197.61 133.32,197.87 133.32,200.43 132.61,201.14 131.88,201.14 131.6,201.42 131.6,202.49 131.67,202.56 133.1,202.56 133.48,202.18 136.02,202.18 136.27,201.93 138.68,201.93 138.84,201.78 138.84,201.02 138.58,200.76 137.52,200.76 137.29,200.53 137.29,200.41 137.31,200.38 137.29,200.36 137.29,198.12 136.78,197.61 ; 9 cut-outs
0D775V_VDDCR_SOC_S5 on BOTTOM: 134.62,197.74 134.11,198.25 134.11,199.39 134.37,199.64 135.64,199.64 135.76,199.52 135.76,197.99 135.51,197.74
0D775V_VDDCR_SOC_S5 on L3: 154.43,165.51 159.18,165.51 159.89,164.8 159.89,163.98 159.38,163.47 154.05,163.47 154.04,163.46 153.87,163.63 153.87,164.92 154.43,165.48
1D2V_MEM_S3 on TOP: 172.59,101.24 172.37,101.47 172.37,104.27 173.77,105.67 187.48,105.67 187.99,105.16 187.99,101.32 187.91,101.24
1D2V_MEM_S3 on TOP: 221.35,96.34 220.98,96.7 220.98,100.84 221.11,100.97 221.11,101.22 220.98,101.35 219.33,101.35 218.69,101.98 218.69,104.39 218.95,104.65 221.87,104.65 222.38,104.14 222.38,96.69 222.02,96.34
1D2V_MEM_S3 on TOP: 165.48,156.59 165.1,156.97 165.1,158.12 165.99,159 166.24,159 166.5,159.26 166.5,159.54 166.8,159.84 167.36,159.84 167.51,159.69 167.51,159 167.89,158.62 170.69,158.62 171.02,158.95 171.02,160.91 171.15,161.04 171.7,161.04 171.96,160.78 171.96,159.13 172.21,158.88 173.35,158.88 173.86,159.38 173.86,160.02 173.99,160.15 174.62,160.15 174.75,160.02 174.75,159 175.77,157.99 175.77,156.97 175.39,156.59
1D2V_MEM_S3 on BOTTOM: outline of 110 points within 152.27,88.52 222.52,160.02 ; 130 cut-outs
1D2V_MEM_S3 on L2GND: 174.25,89.8 173.19,90.86 173.19,96.19 172.58,96.8 172.58,107.29 171.79,108.08 171.79,114.65 171.34,115.1 171.34,116.5 163.21,124.63 163.21,137.85 162.34,138.71 162.34,141.38 162.22,141.51 162.22,147.6 163.72,149.1 163.72,150.64 164.22,151.15 164.22,155.52 164.42,155.71 176.71,155.71 176.87,155.55 176.87,154.35 177.37,153.86 177.8,153.86 177.89,153.77 177.89,153.24 178.28,152.84 178.53,152.84 179.16,152.22 179.16,151.15 182.21,148.1 182.21,145.26 183.05,144.42 183.05,141.42 184.11,140.36 184.11,134.39 186.53,131.97 186.53,125.82 192.67,119.68 192.67,112.3 192.09,111.71 192.09,109.04 190.68,107.63 189.02,107.63 188.53,107.14 188.53,106.38 187.39,105.23 187.39,103.05 188.66,101.78 188.66,99.11 190.29,97.47 191.18,97.47 191.71,96.95 191.71,94.82 191.18,94.3 189.66,94.3 188.53,93.17 188.53,89.99 188.34,89.8
1D2V_MEM_S3 on L5GND: 173.79,89.88 173.16,90.51 173.16,96.93 171.88,98.22 171.88,114.25 171.32,114.8 171.32,116.43 163.12,124.63 163.12,137.5 162.24,138.38 162.24,147.6 163.66,149.02 163.66,151.31 164.2,151.84 164.2,155.55 164.41,155.77 169.19,155.77 170.28,156.86 176.25,156.86 176.87,156.24 176.87,155.47 176.85,155.46 176.85,154.21 177.21,153.85 177.65,153.85 177.66,153.86 177.73,153.86 177.88,153.72 177.88,153.16 178.22,152.82 178.6,152.82 179.15,152.28 179.15,151.13 182.34,147.93 182.34,145.26 183.06,144.54 183.06,141.45 184.34,140.17 184.34,134.17 186.56,131.95 186.56,129.66 187.69,128.52 187.69,124.2 192.68,119.21 192.68,97.32 192.4,97.04 192.4,91.6 190.68,89.88
1D2V_MEM_S3 on L7GND: 173.95,89.68 172.84,90.79 172.84,98 172.13,98.72 172.13,108.12 171.86,108.39 171.86,114.31 171.31,114.86 171.31,116.42 163.1,124.63 163.1,137.66 162.24,138.52 162.24,145.92 164.22,147.9 164.22,155.62 164.44,155.84 176.55,155.84 176.82,155.57 176.82,154.12 177.14,153.81 177.67,153.81 177.86,153.62 177.86,153.08 178.18,152.77 178.76,152.77 179.14,152.39 179.14,151.13 182.34,147.93 182.34,145.26 183.06,144.54 183.06,141.45 184.34,140.17 184.34,134.17 186.56,131.95 186.56,124.95 192.68,118.83 192.68,97.33 192.4,97.05 192.4,91.58 190.51,89.68
1D05V_PCH_S0 on TOP: 157.51,40.06 157.23,40.34 157.23,41.58 157.25,41.61 159.08,41.61 159.31,41.38 159.31,40.89 159.66,40.54 160.4,40.54 161.14,41.27 161.14,41.58 161.29,41.73 163.25,41.73 163.58,42.06 163.58,48.26 163.07,48.77 161.93,48.77 161.67,48.51 161.67,47.75 161.54,47.62 160.53,47.62 160.4,47.75 160.4,48.39 160.15,48.64 159.23,48.64 158.98,48.39 157.99,48.39 157.58,47.98 157.58,47.7 156.69,46.81 156.41,46.81 156.21,47.02 156.21,48.01 157.73,49.53 159.89,49.53 160.4,50.04 161.9,50.04 162.2,50.34 164.29,50.34 164.59,50.04 164.59,47.37 164.34,47.12 164.34,46.35 164.59,46.1 164.59,43.36 166.29,41.66 166.98,41.66 167.18,41.45 167.18,41.25 166.73,40.79 165.18,40.79 164.13,41.83 163.7,41.83 163.22,41.35 163.22,40.54 163.04,40.36 162.94,40.36 162.84,40.46 162.84,40.61 162.43,41.02 161.82,41.02 160.86,40.06
1D05V_PCH_S0 on TOP: 153.29,42.04 153.17,42.15 150.38,42.15 150.24,42.29 148.84,42.29 147.96,43.18 144.65,43.18 143.64,44.2 142.62,44.2 142.6,44.17 142.57,44.2 134.47,44.2 134.11,44.55 134.11,46.94 134.67,47.5 142.01,47.5 142.77,46.74 147.32,46.74 148.59,45.47 149.35,45.47 150.7,44.12 152.98,44.12 153.16,43.94 155.07,43.94 155.7,44.58 155.7,44.83 156.72,44.83 156.84,44.7 156.84,42.16 156.72,42.04 ; 4 cut-outs
1D05V_PCH_S0 on BOTTOM: outline of 114 points within 143.64,39.88 166.88,50.24 ; 33 cut-outs
1D05V_PCH_S0 on L4: 150.75,44.32 154.69,44.32 155.19,44.83 156.72,44.83 156.97,44.58 156.97,42.55 156.59,42.16 150.62,42.16 150.24,42.55 150.24,43.81
1D05V_PCH_S0 on L6: 162.18,50.42 164.21,50.42 164.72,49.91 164.72,42.29 163.19,40.77 161.16,40.77 160.53,41.4 159.77,41.4 159.13,40.77 157.73,40.77 157.48,41.02 157.48,41.15 156.34,42.29 148.72,42.29 147.83,43.18 144.02,43.18 142.88,44.32 142.88,45.21 143.64,45.97 148.97,45.97 150.37,44.58 154.81,44.58 155.32,45.09 155.32,48.9 155.96,49.53 161.29,49.53
1D05V_PCH_S0_L on TOP: 137.16,38.23 136.53,38.86 136.53,40.51 136.4,40.64 136.4,43.18 136.65,43.43 140.21,43.43 140.46,43.18 140.46,41.86 140.28,41.68 140.28,40.13 140.67,39.75 142.29,39.75 142.34,39.7 142.34,38.86 141.71,38.23 ; 5 cut-outs
1D05V_PCH_S5 on TOP: 143.26,34.16 143.13,34.29 143.13,36.27 143.81,36.96 143.81,39.5 143.99,39.67 144.73,39.67 146.16,38.24 146.7,38.24 146.91,38.02 146.91,37.44 146.46,36.98 146.46,35.46 146.96,34.95 146.96,34.19 146.94,34.16 ; 1 cut-out
1D05V_PCH_S5 on L6: 157.73,40.51 162.05,40.51 162.31,40.26 162.31,39.12 162.18,38.99 157.73,38.99 157.61,38.86 157.61,34.16 156.97,33.53 143.89,33.53 143.64,33.78 143.64,36.83 143.99,37.19 147.9,37.19 148.59,37.87 148.59,39.62 148.84,39.88 154.81,39.88 155.07,40.13 155.07,41.27 155.32,41.53 156.72,41.53 ; 1 cut-out
1D05V_S0 on TOP: 128.78,196.98 128.52,197.23 128.52,197.61 128.4,197.74 127.38,197.74 127.25,197.87 127.25,199.26 127.38,199.39 127.38,199.64 126.75,200.28 126.75,200.53 127,200.79 129.03,200.79 129.79,200.03 129.79,197.49 129.29,196.98 ; 2 cut-outs
1D05V_S0 on TOP: 156.3,162.25 155.32,163.24 155.32,165.38 155.7,165.76 156.24,165.76 156.27,165.79 158.1,165.79 158.69,165.2 158.69,164.3 158.66,164.3 158.34,163.99 158.34,162.98 157.62,162.25
1D05V_S0 on BOTTOM: 127.89,196.98 127.13,197.74 127.13,200.53 127.25,200.66 128.27,200.66 128.65,200.28 130.18,200.28 130.43,200.03 130.43,197.61 129.79,196.98
1D05V_S0 on BOTTOM: 155.42,162.08 154.81,162.69 152.17,162.69 151.74,162.26 151.18,162.26 151.03,162.41 151.03,163.04 150.37,163.7 150.37,169.8 150.11,170.05 145.67,170.05 144.15,171.58 144.15,171.83 143.66,172.31 142.8,172.31 142.57,172.09 138.18,172.09 137.87,171.78 136.78,171.78 135.99,170.99 135.99,169.14 136.37,168.76 136.7,168.76 137.01,168.45 137.01,168 136.55,167.54 134.09,167.54 133.63,168 133.63,171.7 136.17,174.24 141.73,174.24 142.34,174.85 146.35,174.85 146.41,174.8 146.41,174.42 146.43,174.4 146.43,172.92 146.91,172.44 150.9,172.44 152.91,170.43 152.91,169.04 152.27,168.4 152.27,167.26 152.02,167 152.02,164.34 152.27,164.08 153.92,164.08 154.31,164.47 154.31,165.23 154.89,165.81 154.97,165.81 155.19,166.04 157.84,166.04 157.94,165.94 157.94,165.38 158.06,165.25 158.72,165.25 158.85,165.13 158.85,164.39 158.57,164.11 158.32,164.11 158.12,163.91 158.12,162.53 157.66,162.08 ; 10 cut-outs
1D05V_S0 on L4: 133.22,186.89 131.7,186.89 131.01,187.58 131.01,189.03 127.51,192.53 127.51,199.52 126.87,200.15 126.87,200.53 127,200.66 127.66,200.66 128.27,200.05 128.8,200.05 130.58,198.27 130.58,195.43 133.48,192.53 133.48,187.15
1D05V_S0 on L5GND: 135.94,159.25 128.69,166.5 128.69,175.67 125.79,178.56 125.79,194.66 126.99,195.86 126.99,200.45 127.49,200.95 128.22,200.95 129.28,199.89 131.82,199.89 133.06,198.65 133.06,187.42 136.07,184.42 143.38,184.42 150.49,177.3 150.51,177.3 150.86,176.95 150.86,175.03 151.98,173.91 151.98,168.12 152.58,167.53 158.32,167.53 158.81,167.03 158.81,160.13 158.51,159.83 152.6,159.83 152.02,159.25
1D05V_S0 on L6: 132.64,167.49 128.73,171.4 128.73,182.5 131.13,184.9 131.13,188.99 131.5,189.36 132.51,189.36 133.12,188.75 133.12,186.87 136.22,183.77 141.99,183.77 143.38,182.37 143.38,173.1 142.37,172.09 136.78,172.09 136.04,171.35 136.04,169.65 137.16,168.53 137.16,167.89 136.75,167.49 ; 1 cut-out
1D05V_S5 on TOP: 148.21,197.38 147.8,197.79 147.8,198.63 148.06,198.88 151.87,198.88 152.5,198.25 152.5,197.61 152.27,197.38
1D5V_S5 on TOP: 139.57,132.72 139.19,133.1 137.79,133.1 137.54,133.35 137.54,133.73 137.79,133.99 138.56,133.99 139.57,135 141.12,135 141.35,134.77 141.35,132.97 141.1,132.72
1D05V_S5 on TOP: 124.71,194.82 124.46,195.07 124.46,196.47 124.65,196.66 125.03,196.66 125.35,196.98 125.35,198.37 124.33,198.37 123.32,199.39 123.32,200.03 123.95,200.66 123.95,201.29 124.59,201.93 124.97,201.93 125.09,201.8 125.09,199.9 125.48,199.52 127,199.52 127.13,199.39 127.13,196.22 125.73,194.82 ; 2 cut-outs
1D05V_S5 on TOP: 127.25,206.76 127.15,206.86 127.15,207.14 127.28,207.26 127.61,207.26 127.66,207.31 127.66,209.27 127.64,209.3 127.89,209.55 128.91,209.55 129.29,209.17 129.29,207.65 128.4,206.76 ; 2 cut-outs
1D05V_S5 on TOP: 136.53,202.31 136.4,202.44 136.4,203.33 136.65,203.58 139.7,203.58 140.08,203.2 140.08,202.56 139.83,202.31
1D05V_S5 on BOTTOM: 124.59,194.94 124.46,195.07 124.46,195.96 124.21,196.22 124.21,198.25 123.19,199.26 123.19,200.53 124.21,201.55 124.21,202.31 123.7,202.82 123.19,202.82 122.81,203.2 122.81,206.88 125.6,209.68 132.84,209.68 133.99,208.53 133.99,207.9 134.37,207.52 138.68,207.52 140.34,205.87 140.34,200.41 143.26,197.49 146.51,197.49 147.93,198.91 151.84,198.91 152.58,198.17 152.58,197.64 152.54,197.6 152.54,196.48 152.48,196.42 141.53,196.42 139.19,198.75 136.91,198.75 135.64,200.03 133.99,200.03 132.59,201.42 130.68,201.42 129.92,200.66 128.78,200.66 128.52,200.91 127,200.91 126.62,200.53 126.62,195.96 125.6,194.94
1D05V_S5 on BOTTOM: 159.23,165.46 159.05,165.63 159.05,167.08 159.18,167.21 160.35,167.21 160.63,166.93 160.63,166.04 160.05,165.46 ; 1 cut-out
1D05V_S5 on L3: 121.92,209.93 128.52,209.93 128.91,209.55 128.91,204.34 127.64,203.07 127.64,202.82 125.86,201.04 125.86,200.41 125.73,200.28 125.73,199.9 125.98,199.64 126.24,199.64 126.62,199.26 126.62,196.34 125.09,194.82 124.71,194.82 124.33,195.2 124.33,195.83 124.21,195.96 122.68,195.96 121.67,196.98 121.67,209.68
1D05V_S5 on L4: 145.92,198.25 144.27,199.9 144.27,201.55 142.88,202.95 140.97,202.95 139.7,201.68 130,201.68 128.65,203.02 128.65,203.23 128.3,203.58 127.51,203.58 127.25,203.33 127.25,202.18 125.86,200.79 125.86,200.03 126.49,199.39 126.49,195.2 126.24,194.94 124.59,194.94 124.46,195.07 124.46,195.71 124,196.16 124,198.58 123.32,199.26 123.32,200.79 123.44,200.91 123.49,200.91 124,201.42 124,203.25 125.6,204.85 125.6,208.28 126.87,209.55 130.78,209.55 131.57,210.34 138.79,210.34 138.81,210.31 145.41,210.31 146.11,209.61 146.11,203.01 149.42,199.71 152.34,199.71 152.78,199.26 152.78,191.13 146.81,185.17 145.92,185.17 145.8,185.29 145.8,198.12
1D05V_S5 on L5GND: 124.74,194.93 124.45,195.23 124.45,195.84 123.3,196.98 123.3,209.06 123.8,209.56 130.81,209.56 131.57,210.32 139.19,210.32 139.62,209.89 149.37,209.89 151.4,207.87 151.4,204.52 153,202.92 153,197.97 152.58,197.55 146.81,197.55 144.26,200.1 144.26,201.63 142.83,203.06 140.74,203.06 139.42,201.74 133.3,201.74 131.82,200.27 129.44,200.27 128.37,201.33 127.33,201.33 126.61,200.61 126.61,196.01 125.52,194.93
1D05V_S5 on L6: 130.18,199.39 130.18,201.42 129.03,202.56 129.03,209.3 128.78,209.55 125.22,209.55 122.81,207.14 122.81,196.98 124.33,195.45 124.33,195.2 124.59,194.94 125.73,194.94
1D05V_S5 on L6: 151.54,183.11 152.15,182.5 152.15,181.74 152.78,181.1 152.78,180.34 154.43,178.69 154.43,178.31 154.69,178.05 154.81,178.05 155.32,177.55 155.32,174.37 155.57,174.12 155.57,172.21 155.96,171.83 155.96,168.66 157.48,167.13 160.4,167.13 160.78,166.75 160.78,165.86 160.4,165.48 156.46,165.48 153.8,168.15 153.8,168.66 153.16,169.29 153.03,169.29 153.03,171.96 153.16,172.09 153.16,174.24 151.38,176.02 151.38,176.28 147.83,179.83 147.83,181.46 145.67,183.62 145.67,186.18 145.92,186.44 148.21,186.44 148.6,186.04 148.6,184.06 149.56,183.11
1D5V_VDDBT_RTC on TOP: 129.67,42.8 129.29,43.18 128.91,43.18 128.78,43.31 128.78,44.32 128.91,44.45 129.92,44.45 130.68,45.21 130.68,48.77 130.94,49.02 131.32,49.02 131.57,48.77 131.57,47.37 131.95,46.99 131.95,43.05 131.7,42.8 ; 3 cut-outs
1D8V_HDT on TOP: 213.36,145.54 213.16,145.75 213.16,147.73 212.42,148.46 212.22,148.46 211.86,148.82 211.86,149.91 212.06,150.11 212.57,150.11 212.75,149.94 212.75,149.3 213.59,148.46 214.55,148.46 214.71,148.31 214.71,145.72 214.53,145.54
1D8V_HDT on BOTTOM: 209.68,150.24 209.55,150.37 209.55,151.38 209.8,151.64 209.8,153.03 209.55,153.29 209.55,154.18 209.8,154.43 210.19,154.43 210.82,153.8 210.82,152.65 211.2,152.27 211.46,152.27 211.84,152.65 212.6,152.65 212.98,152.27 212.98,151.89 211.46,150.37 210.44,150.37 210.31,150.24 ; 2 cut-outs
1D8V_S0 on TOP: 141.64,41.24 140.84,42.04 140.84,43.31 141.1,43.56 141.48,43.56 141.62,43.42 141.62,42.43 142.29,41.76 142.29,41.33 142.2,41.24
1D8V_S0 on BOTTOM: 206.15,26.67 205.61,27.2 205.61,28.07 203.58,30.1 201.29,30.1 199.64,28.45 197.87,28.45 197.74,28.57 197.74,29.21 197.99,29.46 199.26,29.46 200.53,30.73 201.45,30.73 201.75,31.04 203.9,31.04 205.26,29.68 205.26,29.67 206.84,28.08 207.12,28.08 207.14,28.07 210.95,28.07 211.33,28.45 212.47,28.45 213.49,29.46 214.88,29.46 215.14,29.21 215.14,27.94 215.01,27.81 213.23,27.81 212.34,26.92 210.82,26.92 210.69,26.8 208.53,26.8 208.41,26.67 ; 6 cut-outs
1D8V_S0 on L3: 159.79,79.17 162.99,79.17 164.08,78.08 164.08,63.7 165.13,62.66 165.13,59.08 164.85,58.8 162.74,58.8 161.67,59.87 161.67,61.24 160.86,62.05 160.76,62.05 159,63.8 159,78.38
1D8V_S0 on L4: 215.01,144.65 216.15,143.51 219.46,143.51 222.12,140.84 228.22,140.84 231.78,137.29 231.78,120.14 232.92,119 232.92,105.66 232.54,105.28 228.09,105.28 226.31,103.5 226.31,91.06 227.58,89.79 232.28,89.79 233.3,90.81 233.3,94.23 234.06,95 234.06,102.74 234.44,103.12 234.44,120.9 234.06,121.28 234.06,143.13 231.52,145.67 222.88,145.67 221.49,147.07 217.81,147.07 216.41,145.67 215.26,145.67 215.01,145.41
1D8V_S0 on L6: 161.04,61.34 162.94,61.34 163.45,60.83 163.45,58.55 155.57,50.67 145.16,50.67 142.37,47.88 142.37,44.07 143.51,42.93 146.69,42.93 146.94,42.67 146.94,39.24 146.56,38.86 142.88,38.86 135.13,46.61 132.33,46.61 131.57,47.37 131.57,50.8 134.75,53.98 142.49,53.98 147.83,59.31 159.26,59.31 161.04,61.09
1D8V_S0 on L6: 204.85,81.15 214.76,81.15 215.26,81.66 215.26,81.79 220.34,86.87 229.36,86.87 230.76,88.27 230.76,90.17 230.12,90.81 219.71,90.81 215.77,86.87 203.84,86.87 198.88,81.92 198.88,79.38 198.75,79.38 198.63,79.25 196.72,79.25 193.17,75.69 192.53,75.69 191.64,76.58 188.59,76.58 183.26,81.92 163.19,81.92 161.29,80.01 161.29,78.49 161.67,78.11 167,78.11 167.89,78.99 169.42,78.99 169.93,78.49 180.09,78.49 180.09,77.22 183.9,73.41 200.53,73.41 201.17,74.04 203.07,74.04 203.84,74.8 203.84,80.14
1D8V_S0 on L6: 159.77,164.47 159.77,156.46 160.78,155.45 184.28,155.45 186.25,157.42 186.25,161.54 186.69,161.99 188.15,161.99 189.1,162.94 189.1,163.07 189.61,163.58 193.04,163.58 205.36,151.26 205.36,149.61 211.07,143.89 216.28,143.89 217.04,144.65 217.04,145.54 216.66,145.92 215.9,145.92 215.14,146.69 214.63,146.69 211.84,149.48 211.07,149.48 209.23,151.32 209.23,152.21 207.14,154.31 206.12,154.31 194.82,165.61 186.82,165.61 186.44,165.99 161.29,165.99
1D8V_S5 on TOP: 124.97,76.58 123.95,77.6 123.95,78.74 124.33,79.12 126.62,79.12 127.25,78.49 131.44,78.49 132.08,77.85 136.53,77.85 137.16,78.49 137.16,80.52 132.72,84.96 132.72,86.87 132.84,87 134.62,87 135.76,85.85 135.76,84.45 139.06,81.15 139.06,78.74 136.91,76.58 ; 3 cut-outs
1D8V_S5 on TOP: 143.87,41.27 143.81,41.33 143.81,42.27 143,43.08 143,43.56 143.13,43.69 143.64,43.69 144.44,42.89 144.45,42.9 145.03,42.9 145.26,42.67 145.26,41.94 144.6,41.27
1D8V_S5 on TOP: 139.7,211.33 139.52,211.51 138.48,211.51 138.3,211.68 138.3,212.39 138.28,212.42 138.46,212.6 139.57,212.6 140.46,211.71 140.46,211.46 140.34,211.33
1D8V_S5 on TOP: 132.33,122.94 131.83,123.44 131.83,124.26 132.21,124.64 134.49,124.64 134.7,124.84 136.91,124.84 137.29,124.46 137.29,123.32 136.91,122.94
1D8V_S5 on BOTTOM: 131.95,152.02 130.68,153.29 130.68,156.21 127.89,159 126.11,159 125.86,159.26 125.86,160.02 125.98,160.15 129.29,160.15 131.83,157.61 131.83,156.97 132.21,156.59 132.21,153.92 132.84,153.29 133.73,153.29 133.86,153.16 133.86,152.27 133.6,152.02
1D8V_S5 on BOTTOM: 143.64,42.16 143.51,42.29 143.51,42.67 141.99,44.2 140.34,44.2 138.81,45.72 138.81,54.74 136.02,57.53 131.95,57.53 131.76,57.72 131.76,58.74 133.48,60.45 137.92,60.45 140.53,57.85 140.53,56.2 142.75,53.98 142.75,46.74 143.26,46.23 143.26,45.09 144.02,44.32 144.02,43.69 144.4,43.31 144.78,43.31 145.16,42.93 145.16,42.29 145.03,42.16 ; 1 cut-out
1D8V_S5 on BOTTOM: 125.09,77.6 124.08,78.61 124.08,79.5 126.36,81.79 127,81.79 127.76,82.55 127.76,86.23 128.52,87 133.1,87 134.75,85.34 134.87,85.34 134.87,83.82 133.48,82.42 133.48,79.63 131.44,77.6
1D8V_S5 on L3: 123.83,78.74 123.83,75.82 127.38,72.26 127.38,64.64 127.64,64.39 128.52,64.39 130.18,62.74 130.18,59.05 129.16,58.04 129.16,55.88 129.79,55.24 129.79,47.88 130.05,47.62 131.44,47.62 131.7,47.88 131.7,54.36 132.08,54.74 132.08,56.39 132.84,57.15 132.84,65.28 131.19,66.93 131.19,71.75 127.89,75.06 127.89,76.58 125.35,79.12 124.21,79.12
1D8V_S5 on L4: 129.67,48.26 129.67,46.61 130.56,45.72 139.95,45.72 142.62,43.05 142.62,41.02 143.51,40.13 144.27,40.13 145.16,41.02 145.16,42.8 144.53,43.43 144.15,43.43 144.02,43.56 144.02,46.1 142.11,48.01 134.11,48.01 133.6,47.5 132.08,47.5 131.06,48.51 129.92,48.51
1D8V_S5 on L4: 126.11,210.82 126.62,210.82 127.38,210.06 130.68,210.06 131.57,210.95 131.57,211.33 131.95,211.33 132.33,210.95 140.21,210.95 140.46,211.2 140.46,211.96 139.83,212.6 139.7,212.6 138.81,213.49 126.87,213.49 126.36,212.98 125.86,212.98 121.92,209.04 121.92,205.36 121.03,204.47 121.03,193.68 122.81,191.9 122.81,191.26 127.71,186.36 129.74,186.36 129.84,186.46 129.84,187.15 124.59,192.41 124.59,192.66 123.44,193.8 123.44,197.61 123.06,197.99 123.06,201.93 123.57,202.44 123.57,206.25 124.33,207.01 124.33,209.04
1D8V_S5 on L6: 129.76,151.47 131.42,153.14 133.78,153.14 134.01,152.91 134.01,139.57 133.4,138.96 133.4,132.41 140.08,125.73 140.08,116.08 141.22,114.94 141.22,112.78 142.62,111.38 142.62,83.95 141.48,82.8 135,82.8 133.48,84.33 133.48,86.74 134.24,87.5 134.24,90.3 139.32,95.38 139.32,104.9 138.3,105.92 138.3,120.02 136.65,121.67 133.86,121.67 131.64,123.89 131.64,126.81 129.79,128.65 129.79,133.73 129.76,133.77
1D8V_S5 on L6: 128.14,183.64 128.14,171.58 128.65,171.07 128.65,159.89 127.51,158.75 126.24,158.75 125.6,159.38 125.6,167.51 126.36,168.28 126.36,173.61 125.86,174.12 125.86,184.4 128.65,187.2 129.67,187.2 129.92,186.94 129.92,185.42
1D8V_VGA on TOP: 93.22,155.32 92.71,155.83 92.71,157.23 92.84,157.35 94.49,157.35 94.87,156.97 94.87,155.57 94.61,155.32
1D8V_VGA on BOTTOM: 93.09,155.32 90.98,157.43 78.31,157.43 76.5,159.23 75.08,159.23 74.78,159.54 74.78,162.31 73.28,163.8 73.28,165.05 72.77,165.56 72.77,168.94 73.03,169.19 73.03,171.58 73.23,171.78 73.58,171.78 73.63,171.73 73.79,171.73 74.12,172.06 74.73,172.06 74.8,171.98 74.8,171.48 74.57,171.25 74.57,170.84 75.18,170.23 75.18,166.5 75.31,166.37 75.31,165.33 76.96,163.68 76.96,163.63 76.99,163.6 76.99,163.19 80.14,160.05 91.67,160.05 94.49,157.23 94.49,155.57 94.23,155.32 ; 6 cut-outs
1D35V_MEM_VGA on TOP: 37.87,212.7 37.67,212.9 37.67,221.56 38.48,222.38 40.39,222.38 40.74,222.02 40.74,213.28 40.16,212.7 ; 2 cut-outs
1D35V_MEM_VGA on TOP: 94.87,205.97 94.44,206.4 94.44,208.71 95.5,209.78 98.88,209.78 99.11,209.55 99.11,207.29 97.79,205.97
1D35V_MEM_VGA on TOP: 24.38,147.45 23.88,147.96 23.88,150.62 24.51,151.26 29.34,151.26 29.59,151 29.59,147.7 29.34,147.45
1D35V_MEM_VGA on TOP: 21.34,160.15 20.83,160.66 20.83,166.75 16.13,171.45 16.13,174.24 16.51,174.62 17.02,174.62 17.14,174.5 19.81,174.5 20.45,175.13 20.45,178.44 21.59,179.58 24,179.58 24.38,179.2 24.38,178.44 24.26,178.31 22.61,178.31 21.97,177.67 21.97,163.45 22.48,162.94 23.75,162.94 24.51,163.7 24.77,163.7 24.89,163.58 24.89,161.67 24.26,161.04 24.26,160.4 24,160.15
1D35V_MEM_VGA on BOTTOM: 55.37,195.33 54.23,196.47 54.23,200.03 53.98,200.28 52.2,200.28 51.77,199.85 51.77,199.06 51.59,198.88 51.44,198.88 51.18,198.63 51.18,198.25 51.56,197.87 51.82,197.87 51.94,197.74 51.94,196.72 51.69,196.47 51.05,196.47 49.66,197.87 49.66,200.41 50.67,201.42 54.36,201.42 55.12,200.66 55.12,196.72 55.75,196.09 55.75,195.33 ; 5 cut-outs
1D35V_MEM_VGA on BOTTOM: 90.17,198.63 90.04,198.75 90.04,201.93 90.3,202.18 91.19,202.18 91.82,201.55 91.82,199.39 91.06,198.63 ; 3 cut-outs
1D35V_MEM_VGA on BOTTOM: 37.87,211.76 37.71,211.92 37.71,220.6 37.72,220.6 37.85,220.73 40.01,220.73 40.36,220.37 40.36,212.57 39.55,211.76 ; 1 cut-out
1D35V_MEM_VGA on BOTTOM: 27.05,147.7 26.54,148.21 26.54,151.13 28.07,152.65 37.72,152.65 42.42,157.35 44.45,157.35 45.47,158.37 46.74,158.37 46.99,158.12 46.99,157.1 46.48,156.59 43.94,156.59 38.73,151.38 38.23,151.38 37.34,150.5 34.92,150.5 32.13,147.7 ; 3 cut-outs
1D35V_MEM_VGA on L3: 46.48,228.22 94.36,228.22 95.12,227.46 95.12,213.61 93.34,211.84 70.61,211.84 61.98,203.2 61.98,187.71 60.2,185.93 43.94,185.93 37.59,179.58 37.59,154.31 36.07,152.78 33.4,152.78 31.5,150.88 31.5,148.21 30.99,147.7 27.05,147.7 26.8,147.96 26.8,149.99 20.83,155.96 20.83,206.76 22.48,208.41 37.34,208.41 38.48,209.55 38.48,220.22
1D35V_MEM_VGA on L4: 26.75,147.35 25.76,148.34 25.76,150.72 25.78,150.75 25.78,150.98 21.46,155.3 21.46,161.85 18.21,165.1 18.21,206.3 20.62,208.71 36.63,208.71 37.9,209.98 37.9,219.61 46.28,227.99 95.71,227.99 96.06,227.63 96.06,213.28 94.16,211.38 71.5,211.38 62.08,201.96 62.08,188.37 61.16,187.45 61.16,186 60.53,185.37 43.92,185.37 38.13,179.58 38.13,154.81 36.25,152.93 33.88,152.93 31.85,150.9 31.85,148.84 30.35,147.35
1D35V_MEM_VGA on L5GND: 21.5,161.83 18.17,165.15 18.17,206.27 20.63,208.72 36.6,208.72 37.91,210.03 37.91,219.61 46.31,228 95.68,228 96.08,227.61 96.08,224.84 97.97,222.95 102.31,222.95 102.83,222.43 102.83,221.59 103.86,220.56 112.98,220.56 114.74,218.79 114.74,214.2 110.03,209.49 106.68,209.49 105.88,208.69 105.88,205.38 106.32,204.94 108.28,204.94 108.7,204.52 108.7,200.99 109.59,200.1 109.59,194.28 110.2,193.67 110.2,189.16 108.53,187.49 106.78,187.49 102.87,183.58 90.35,183.58 89.85,183.09 89.85,181.69 89.56,181.39 86.21,181.39 85.88,181.72 80.98,181.72 80.72,181.98 79.86,181.98 79.54,182.3 79.54,182.6 79.02,183.12 78.59,183.12 73.89,187.82 65.01,187.82 64.81,188.02 64.81,188.52 64.42,188.91 61.82,188.91 61.1,188.19 61.1,173.45 61.44,173.11 61.9,173.11 62.43,172.58 68.68,172.58 69.2,172.06 69.2,171.17 68.01,169.98 68.01,159.87 66.15,158.02 66.15,148.24 64.45,146.54 64.45,139.52 64.06,139.13 34.42,139.13 33.91,139.64 28.38,139.64 28.38,145.7 25.77,148.31 25.77,151.01 21.5,155.27
2D5V_MEMVPP_S5 on TOP: 148.69,99.02 148.54,99.17 148.54,102.13 148.64,102.23 149.86,102.23 149.99,102.11 149.99,101.65 149.43,101.09 149.43,99.11 149.34,99.02
2D5V_MEMVPP_S5 on BOTTOM: 148.08,100.23 148.01,100.3 148.01,114.25 148.77,115.01 148.77,116.31 149.61,116.31 150.22,115.7 150.22,100.86 149.58,100.23 ; 5 cut-outs
2D5V_PCH_S0 on TOP: 165.48,43.31 165.1,43.69 165.1,46.35 165.23,46.48 165.74,46.48 165.99,46.23 165.99,43.56 165.74,43.31
2D5V_PCH_S0 on TOP: 154.91,50.83 154.25,51.49 151.21,51.49 151,51.69 150.62,51.69 150.5,51.82 150.44,51.82 148.41,53.85 147.78,53.85 146.52,55.11 146.52,57.8 146.51,57.81 146.51,58.32 145.52,59.31 141.91,59.31 140.59,60.63 140.59,62.99 141.35,63.75 143.64,63.75 144.75,62.64 147.52,62.64 147.65,62.51 147.65,61.16 149.94,58.88 149.94,54.66 150.62,53.98 150.75,53.98 150.88,53.85 151.26,53.85 151.38,53.98 151.64,53.98 151.76,53.85 152.02,53.85 152.15,53.98 152.27,53.98 153.16,53.09 154.91,53.09 155.4,52.6 155.4,51.03 155.19,50.83
2D5V_PCH_S0 on BOTTOM: 151.87,51.23 151.36,51.74 149.4,51.74 149.05,51.38 145.54,51.38 145.34,51.59 145.34,52.68 146.02,53.37 146.05,53.37 146.53,53.85 146.56,53.85 146.56,59.05 144.65,60.96 141.48,60.96 140.84,61.59 140.84,65.28 141.1,65.53 149.86,65.53 150.62,64.77 150.62,54.99 151.26,54.36 151.89,54.36 152.91,53.34 154.56,53.34 154.81,53.09 154.81,51.31 154.74,51.23 ; 6 cut-outs
2D5V_PCH_S0 on BOTTOM: 165.48,43.18 165.35,43.31 165.35,46.74 165.61,46.99 165.99,46.99 166.12,46.86 166.12,43.31 165.99,43.18
2D5V_PCH_S0 on L3: 147.45,56.13 157.61,56.13 159.38,54.36 159.38,53.21 160.4,52.2 160.4,50.42 160.78,50.04 161.54,50.04 164.97,46.61 164.97,46.48 165.23,46.23 165.86,46.23 166.12,45.97 166.12,43.56 164.47,41.91 164.47,40.89 164.34,40.77 163.58,40.77 162.81,41.53 161.16,41.53 160.53,40.89 159.64,40.89 156.97,43.56 156.97,44.32 156.59,44.7 155.32,44.7 155.07,44.96 155.07,50.8 154.81,51.05 151.51,51.05 150.88,51.69 149.73,51.69 147.07,54.36 147.07,55.75 ; 1 cut-out
2D5V_S5 on TOP: 139.57,75.82 139.45,75.95 139.45,77.47 139.57,77.6 148.18,77.6 150.42,79.83 150.42,86.23 148.62,88.04 148.62,88.9 148.98,89.27 149.72,89.27 151.99,87 151.99,78.74 149.07,75.82
2D5V_S5 on BOTTOM: 147.47,97.99 147.35,98.12 147.35,99.49 147.8,99.95 149.45,99.95 149.53,99.87 149.53,98.12 149.4,97.99
2D5V_S5 on L4: 148.97,88.39 149.61,88.39 150.88,89.66 150.88,98.68 149.86,99.69 148.08,99.69 147.32,98.93 147.32,98.3 148.34,97.28 148.34,89.03
3D3V_AUX_KBC on TOP: 97.28,76.45 97.16,76.58 97.16,77.22 97.03,77.34 97.03,78.61 97.35,78.93 99,78.93 99.57,78.36 99.57,77.09 98.93,76.45 ; 1 cut-out
3D3V_AUX_KBC on TOP: 95.63,55.91 95.12,56.41 95.12,56.64 95.39,56.91 96.02,56.91 96.09,56.85 96.85,56.85 96.95,56.74 96.95,56.03 96.82,55.91
3D3V_AUX_KBC on BOTTOM: 120.8,48.69 120.78,48.72 120.78,50.42 120.9,50.55 122.3,50.55 122.71,50.14 122.71,49.3 122.1,48.69
3D3V_DVDD_S0 on BOTTOM: 198.58,29.82 198.53,29.87 198.53,31.29 198.79,31.56 199.3,31.56 199.47,31.72 199.47,32.46 199.39,32.54 198.83,32.54 198.6,32.77 198.6,33.22 198.84,33.46 198.84,35.6 198.93,35.69 198.93,38.3 199.01,38.38 203.68,38.38 203.96,38.1 203.96,37.36 203.71,37.11 200.96,37.11 200.76,36.91 200.76,36.1 200.76,36.09 200.76,34.67 200.99,34.44 202.29,34.44 202.44,34.29 202.44,33.78 202.29,33.63 200.91,33.63 200.61,33.32 200.61,32.74 200.46,32.59 200.46,31.22 200.28,31.04 199.9,31.04 199.62,30.76 199.62,30.2 199.24,29.82 ; 4 cut-outs
3D3V_M2VAUX on TOP: 112.62,90.47 112.5,90.6 112.5,92.3 113.31,93.12 114.43,93.12 114.45,93.14 114.45,94.92 114.55,95.02 115.57,95.02 117.09,93.5 117.09,90.68 115.32,90.68 115.11,90.47 ; 3 cut-outs
3D3V_M2VAUX on TOP: 97.87,88.11 97.78,88.2 97.78,89.34 97.64,89.48 97.64,91.44 97.62,91.45 97.62,92.06 97.05,92.63 97.05,94.92 97.13,95 97.13,95.05 97.99,95.05 98.09,94.95 98.09,93.17 98.25,93.01 99.82,93.01 99.95,93.14 99.95,93.37 99.9,93.42 99.9,95.02 99.92,95.05 101.55,95.05 101.55,93.04 101.63,92.96 103.15,92.96 103.77,92.34 103.77,90.96 104.19,90.54 104.19,90.02 104.11,90.02 103.96,89.87 103.56,89.87 102.49,88.8 102.49,88.29 102.31,88.11 ; 13 cut-outs
3D3V_M2VAUX on BOTTOM: 101.35,88.65 101.09,88.9 101.09,92.08 103.38,94.36 111.12,94.36 111.58,94.82 111.58,101.65 110.67,102.57 110.67,102.92 110.87,103.12 112.39,103.12 113.28,102.23 113.28,94.49 113.41,94.36 116.33,94.36 116.71,93.98 116.71,92.46 116.31,92.05 107.04,92.05 103.63,88.65
3D3V_PCH_S5 on TOP: 156.08,34.42 155.96,34.54 155.96,34.8 156.08,34.92 156.08,35.18 155.96,35.31 155.96,35.56 156.08,35.69 156.08,35.94 155.96,36.07 155.96,36.32 156.08,36.45 156.08,36.83 155.96,36.96 155.96,37.21 156.08,37.34 156.08,37.59 155.96,37.72 155.96,37.97 156.08,38.1 156.08,38.35 155.96,38.48 155.96,38.73 156.34,39.12 156.46,39.12 156.59,39.24 156.59,39.62 156.34,39.88 156.34,41.53 156.46,41.66 156.69,41.66 156.82,41.53 156.82,41.22 157.1,40.94 157.1,36.2 156.84,35.94 156.84,34.67 156.59,34.42
3D3V_PCH_S5 on BOTTOM: 155.96,28.96 155.83,29.08 155.83,38.58 156.06,38.81 156.39,38.81 156.51,38.68 156.51,38.56 157.48,37.59 157.48,29.21 157.23,28.96 ; 2 cut-outs
3D3V_S0 on TOP: 98.76,86.06 97.79,87.02 97.79,87.45 97.89,87.55 102.36,87.55 102.57,87.35 102.57,86.54 102.08,86.06 ; 8 cut-outs
3D3V_S0 on TOP: 153.42,62.23 153.29,62.36 153.29,64.01 153.03,64.26 149.48,64.26 149.22,64.01 149.22,63.37 149.73,62.87 149.73,62.48 149.61,62.36 148.21,62.36 148.08,62.48 148.08,64.14 149.26,65.32 151.35,65.32 151.69,65.66 160.78,65.66 161.06,65.38 161.06,64.8 160.66,64.39 156.34,64.39 155.45,63.5 155.45,62.48 155.19,62.23 ; 9 cut-outs
3D3V_S0 on TOP: 129.79,160.27 129.54,160.53 128.91,160.53 128.4,161.04 128.4,164.21 128.52,164.34 131.17,164.34 131.24,164.41 131.85,164.41 131.95,164.31 131.95,163.42 131.7,163.17 131.06,163.17 130.68,162.79 130.68,160.4 130.56,160.27 ; 5 cut-outs
3D3V_S0 on TOP: 167.84,12.27 167.13,12.98 167.13,19.53 167.51,19.91 169.82,19.91 170.18,19.56 170.18,13.08 169.37,12.27
3D3V_S0 on TOP: 135.25,141.1 135,141.35 131.57,141.35 129.67,143.26 129.67,149.2 132.21,151.74 134.34,151.74 135.41,152.81 138.2,152.81 138.54,152.46 138.54,150.89 138.48,150.83 136.17,150.83 135.61,150.27 134.26,150.27 133.73,149.73 132.46,149.73 132.21,149.48 132.21,147.32 132.66,146.86 132.66,144.93 134.04,143.56 135.71,143.56 136.91,142.37 138.43,142.37 138.81,141.99 138.81,141.48 138.43,141.1 ; 2 cut-outs
3D3V_S0 on TOP: 130.66,14.61 130.25,15.01 130.25,15.98 131.14,16.87 136.7,16.87 137.31,16.26 137.31,15.42 137.29,15.39 137.29,15.24 136.63,15.24 136.5,15.37 132.69,15.37 131.93,14.61
3D3V_S0 on TOP: 144.2,98.3 142.25,100.24 142.25,102.04 140.59,103.71 140.59,105.41 140.21,105.79 140.21,106.68 140.84,107.31 145.54,107.31 146.81,106.05 146.81,104.52 146.94,104.39 150.24,104.39 150.5,104.14 150.5,102.87 150.37,102.74 148.72,102.74 148.08,102.11 148.08,99.95 146.43,98.3 ; 1 cut-out
3D3V_S0 on BOTTOM: 148.59,157.35 147.32,158.62 147.32,161.42 147.79,161.89 148.63,161.89 149.22,161.29 149.22,161.04 149.1,160.91 148.72,160.91 148.34,160.53 148.34,159.51 148.84,159 149.22,159 149.73,158.5 151.33,158.5 151.49,158.34 151.49,157.51 151.33,157.35 ; 1 cut-out
3D3V_S0 on BOTTOM: 95.4,63.47 94.74,64.14 92.96,64.14 92.08,65.02 92.08,69.72 92.46,70.1 92.79,70.1 92.93,69.96 92.93,69.48 93.17,69.24 96.09,69.24 96.55,69.7 96.55,76.61 98.04,78.11 98.04,86.69 98.6,87.25 100.08,87.25 100.58,86.74 100.58,76.96 100.56,76.94 100.56,73.91 99.44,72.8 99.44,67.31 97.28,65.15 97.28,63.86 96.9,63.47 ; 2 cut-outs
3D3V_S0 on BOTTOM: 140.34,105.92 140.21,106.05 140.21,106.55 140.84,107.19 140.84,111 142.62,112.78 142.62,125.73 141.6,126.75 141.6,139.95 139.83,141.73 138.43,141.73 138.42,141.74 138.11,141.74 137.74,142.11 137.74,143.05 138.33,143.64 144.15,143.64 145.54,142.24 145.54,126.87 147.7,124.71 147.7,118.11 148.21,117.6 148.72,117.6 148.97,117.35 150.11,117.35 150.24,117.47 150.62,117.47 150.75,117.35 150.75,116.97 150.37,116.59 146.94,116.59 146.43,116.08 146.43,112.14 144.78,110.49 144.78,109.47 145.03,109.22 145.41,109.22 145.54,109.09 145.54,107.82 145.29,107.57 144.65,107.57 143,105.92 ; 2 cut-outs
3D3V_S0 on BOTTOM: 135.76,151.13 135.51,151.38 135.51,152.02 137.16,153.67 137.16,156.59 136.53,157.23 134.11,157.23 133.6,157.73 133.6,161.39 132.05,162.94 130.3,162.94 130.18,163.07 130.18,164.08 130.54,164.45 134.23,164.45 135.15,163.53 136.07,163.53 136.93,162.66 136.93,159.79 138.26,158.46 138.85,158.46 140.08,157.23 140.08,152.78 138.68,151.38 136.65,151.38 136.4,151.13 ; 5 cut-outs
3D3V_S0 on BOTTOM: outline of 119 points within 88.27,5.08 177.42,63.75 ; 22 cut-outs
3D3V_S0 on L3: 150.62,104.65 151.38,104.65 151.89,104.14 151.89,98.42 151.51,98.04 151.51,92.96 154.69,89.79 161.67,89.79 163.96,87.5 163.96,85.72 163.58,85.34 161.42,85.34 160.02,86.74 152.27,86.74 148.21,90.81 148.21,95.12 148.27,95.19 148.27,99.76 149.99,101.47 149.99,104.01
3D3V_S0 on L4: 168.53,12.45 167.39,11.3 167.39,5.84 166.32,4.78 164.57,4.78 163.58,5.77 163.58,11.94 166.12,14.48 168.02,14.48 168.53,13.97
3D3V_S0 on L4: 95.5,64.26 94.69,63.45 94.69,59.28 93.73,58.32 93.73,57.05 91.9,55.22 91.9,34.29 93.07,33.12 93.07,23.5 92.58,23.5 91.38,22.29 91.38,17.84 90.55,17.02 89.41,17.02 87.35,19.08 87.35,31.6 87.83,32.08 87.88,32.08 88.67,32.87 88.67,46.66 89,46.99 89,56.44 89.03,56.44 90.12,57.53 90.65,57.53 91.08,57.96 91.08,65.96 92.35,67.23 93.93,67.23 95.5,65.66
3D3V_S5 on TOP: 110.01,155.22 109.99,155.23 109.73,155.23 108.84,156.12 108.84,158.5 108.97,158.62 110.9,158.62 111.73,157.78 111.73,155.45 111.51,155.22 ; 1 cut-out
3D3V_S5 on TOP: 136.78,144.4 136.53,144.65 136.53,147.96 136.78,148.21 137.41,148.21 137.49,148.13 138.25,148.13 138.38,148.01 138.38,146.94 138.79,146.53 138.91,146.53 139.17,146.28 139.17,144.91 139,144.74 137.88,144.74 137.54,144.4 ; 2 cut-outs
3D3V_S5 on TOP: 126.75,171.96 126.67,172.03 126.67,174.88 128.74,176.95 128.74,177 130.56,178.82 131.83,178.82 132.08,178.56 132.08,177.8 131.83,177.55 131.06,177.55 129.29,175.77 129.03,175.77 128.91,175.64 128.91,173.86 129.03,173.74 129.79,173.74 130.05,173.48 130.05,172.59 129.67,172.21 128.14,172.21 127.89,171.96 ; 1 cut-out
3D3V_S5 on TOP: 93.98,55.37 93.73,55.63 93.73,56.01 93.47,56.26 92.46,56.26 91.57,57.15 91.57,58.93 91.69,59.05 92.71,59.05 92.84,58.93 92.84,57.53 92.96,57.4 93.85,57.4 94.87,56.39 94.87,55.75 94.49,55.37
3D3V_S5 on TOP: 139.06,15.16 138.89,15.34 138.89,16.87 138.68,17.07 138.51,17.07 138.38,17.2 138.38,23.93 138.63,24.18 141,24.18 141.53,23.65 141.53,17.93 140.89,17.3 140.89,15.54 140.59,15.24 139.9,15.24 139.83,15.16 ; 1 cut-out
3D3V_S5 on TOP: 168.1,20.68 164.97,23.8 157.18,23.8 154.81,26.16 153.95,26.16 153.47,25.68 150.55,25.68 150.39,25.83 150.39,27.23 150.6,27.43 152.1,27.43 152.58,27.91 152.58,28.47 152.68,28.57 158.6,28.57 158.81,28.36 158.81,27.98 158.6,27.76 158.22,27.76 157.96,27.51 157.96,27.05 158.47,26.54 167.77,26.54 170.18,24.13 175.9,24.13 176.28,23.75 176.28,21.82 175.13,20.68
3D3V_S5 on TOP: 222,68.71 221.74,68.96 221.74,70.23 221.87,70.36 223.01,70.36 223.27,70.1 225.93,70.1 226.31,69.72 226.31,68.96 226.06,68.71 ; 2 cut-outs
3D3V_S5 on TOP: 186.69,62.99 186.44,63.25 186.44,66.04 186.94,66.55 189.36,66.55 189.74,66.17 189.74,63.63 189.1,62.99
3D3V_S5 on TOP: 131.19,64.9 130.94,65.15 130.94,69.47 131.19,69.72 133.6,69.72 133.86,69.47 133.86,67.56 133.71,67.41 133.71,64.97 133.63,64.9
3D3V_S5 on BOTTOM: 177.42,18.26 175.13,20.55 175.13,22.99 176.4,24.26 178.05,24.26 179.38,25.58 179.38,29.35 181.64,31.61 181.64,33.68 182.32,34.37 182.32,61.85 182.3,61.87 182.3,65.86 181.86,66.29 169.16,66.29 165.86,62.99 158.5,62.99 156.34,65.15 151.89,65.15 150.24,66.8 143.89,66.8 143.88,66.79 143.32,66.79 142.98,66.45 142.98,66.09 142.82,65.94 142.44,65.94 142.34,66.04 142.34,66.32 141.86,66.8 135.38,66.8 134.24,65.66 134.24,62.61 133.22,61.59 129.03,61.59 128.91,61.72 128.91,62.61 130.56,64.26 130.56,68.71 131.32,69.47 148.34,69.47 151.79,72.92 176.58,72.92 177.72,71.78 185.29,71.78 188.72,68.35 188.72,63.22 186.23,60.73 186.21,60.73 185.85,60.38 185.85,35.51 185.93,35.43 185.93,33.02 184.4,31.5 184.4,30.23 182.88,28.7 182.88,23.01 182.87,23 182.87,21.5 182.16,20.79 182.16,19.05 182.12,19.05 181.33,18.26
3D3V_S5 on BOTTOM: 154.15,27.05 153.95,27.25 153.95,30.81 154.13,30.99 155.32,30.99 155.32,27.56 154.81,27.05
3D3V_S5 on BOTTOM: 138.63,16.94 138.38,17.2 138.38,23.93 138.63,24.18 140.94,24.18 141.48,23.65 141.48,17.88 140.54,16.94
3D3V_S5 on L3: 148.18,18.26 150.7,18.26 152.6,20.17 152.6,23.42 154.13,24.94 154.13,25.6 154.71,26.19 154.71,27.64 154.23,28.12 153.8,28.12 153.03,27.36 153.03,25.15 151.21,23.32 150.6,23.32 149.48,22.2 149.48,21.21 147.88,19.61 147.88,18.57
3D3V_S5 on L4: 152.53,26.04 152.53,21.92 152.51,21.91 152.51,19.95 150.65,18.08 148.31,18.08 148.06,18.34 148.06,19.48 148.08,19.51 148.08,19.89 149.35,21.16 149.35,22.5 150.61,23.76 150.61,25.16 150.37,25.4 150.37,26.29 150.5,26.42 152.15,26.42
3D3V_S5 on L6: 150.75,18.92 150.75,16 149.64,14.9 148.42,14.9 148.08,15.24 144.27,15.24 142.04,17.48 140.64,17.48 139.7,18.41 139.7,24 139.95,24.26 140.84,24.26 141.48,23.62 141.48,20.24 141.66,20.07 142.34,20.07 142.35,20.08 143.8,20.08 144.58,19.3 150.37,19.3
3D3V_SD on BOTTOM: 227.2,18.29 226.69,18.8 222.88,18.8 222.5,19.18 222.5,19.81 222.76,20.07 225.04,20.07 225.43,19.68 227.08,19.68 227.84,18.92 227.84,18.41 227.71,18.29
3D3V_VGA on TOP: 110.36,159.13 108.58,160.91 108.58,161.01 107.98,161.01 107.82,161.16 107.82,161.7 107.92,161.8 108.46,161.8 108.58,161.93 108.58,162.43 107.9,163.12 107.52,163.12 107.31,163.32 107.31,163.86 107.44,163.98 108.18,163.98 108.74,163.42 108.99,163.42 110.62,161.8 110.62,161.04 110.87,160.78 111.51,160.78 111.76,161.04 111.76,161.42 112.01,161.67 112.52,161.67 112.78,161.42 112.78,160.91 112.9,160.78 113.67,160.78 114.07,160.38 114.71,160.38 114.72,160.36 117.06,160.36 117.47,160.78 117.47,164.21 118.11,164.85 118.11,166.14 118.52,166.55 120.8,166.55 121.74,165.61 126.36,165.61 127.76,164.21 127.76,160.53 127.38,160.15 126.36,160.15 126.11,160.4 126.11,163.7 125.73,164.08 124.46,164.08 123.57,163.19 120.14,163.19 119.76,162.81 119.76,159.51 119.46,159.21 115.32,159.21 115.24,159.13 ; 15 cut-outs
3D3V_VGA on BOTTOM: 74.94,154.8 74.42,155.32 72.77,155.32 69.98,158.12 69.98,161.44 70.79,162.26 70.79,168.15 70.23,168.71 70.23,171.68 70.87,172.31 72.14,172.31 72.75,171.7 72.75,169.34 72.36,168.96 72.36,167.69 72.52,167.54 72.52,164.47 71.77,163.72 71.77,161.07 71.55,160.86 71.55,159.77 72.49,158.83 73.33,158.83 74.4,157.76 77.62,157.76 78.36,157.02 78.59,157.02 78.69,156.92 90.98,156.92 91.57,156.34 91.57,155.05 91.31,154.8 ; 4 cut-outs
3D3V_VGA on BOTTOM: 95.66,204.5 95.3,204.85 94.61,204.85 94.49,204.98 94.49,205.82 95.28,206.6 95.28,207.95 95.43,208.1 103.28,208.1 103.53,207.85 103.53,207.16 103.28,206.91 102.01,206.91 101.47,206.38 101.47,205.23 101.35,205.1 100.71,205.1 100.1,205.71 97.36,205.71 97.36,205.69 97.21,205.54 97.21,204.57 97.13,204.5 ; 14 cut-outs
3D3V_VGA on L3: 90.63,154.99 90.63,158.7 94.34,162.41 94.34,163.42 96.39,165.48 97.41,165.48 98.3,164.59 100.46,164.59 101.47,165.61 104.65,165.61 105.66,166.62 110.62,166.62 111.04,166.2 111.04,161.07 111,161.04 111,157.23 109.22,155.45 102.11,155.45 101.98,155.32 101.98,154.56 101.6,154.18 91.44,154.18
AD_JK on TOP: 21.46,117.47 21.34,117.6 21.34,118.75 20.95,119.13 17.27,119.13 17.26,119.11 14.31,119.11 14.02,119.41 14.02,124.21 14.68,124.87 21.13,124.87 21.87,125.6 25.43,125.6 27.53,123.49 27.53,119.84 27.46,119.76 25.65,119.76 25.4,119.51 25.4,117.98 24.89,117.47 ; 2 cut-outs
AD_JK on BOTTOM: 22.05,117.47 20.57,118.95 15.29,118.95 15.01,119.23 15.01,124.66 15.54,125.2 23.14,125.2 23.93,125.98 24.38,125.98 24.51,125.86 24.51,125.48 25.02,124.97 25.02,122.3 25.53,121.79 27.05,121.79 27.3,121.54 27.3,117.98 26.8,117.47 ; 3 cut-outs
AD_JK on L3: 21.21,118.62 22.35,117.47 25.02,117.47 25.65,118.11 25.65,123.7 24.26,125.09 16,125.09 15.62,124.71 15.62,119 16,118.62
AMP_AVDD2 on BOTTOM: 210.03,28.55 209.88,28.7 209.88,29.34 210.03,29.49 210.03,30.84 210.19,30.99 212.88,30.99 213.09,30.77 213.09,29.71 212.09,28.7 210.85,28.7 210.69,28.55 ; 2 cut-outs
AMP_BST_B_C on BOTTOM: 208.91,14.1 208.28,14.73 208.28,16 208.53,16.26 210.44,16.26 210.57,16.13 210.57,14.48 210.19,14.1 ; 3 cut-outs
AMP_OUT_A on TOP: 215.11,18.34 214.93,18.52 214.93,19.96 215.06,20.09 215.77,20.09 216.03,19.84 216.03,18.47 215.9,18.34
AMP_OUT_A on BOTTOM: 214.62,16.34 214.58,16.38 214.58,17.73 215.06,18.21 215.06,20.02 215.16,20.12 216.05,20.12 216.56,19.61 216.56,19 216.81,18.75 217.88,18.75 218.06,18.57 218.06,17.4 217.3,16.64 216.59,16.64 216.29,16.34 ; 3 cut-outs
AMP_OUT_A_C on BOTTOM: 216.92,14.99 216.53,15.37 216.53,16 216.79,16.26 217.81,16.26 218.06,16.51 218.06,16.76 218.31,17.02 218.69,17.02 218.82,16.89 218.82,15.11 218.69,14.99 ; 1 cut-out
AMP_OUT_A_L on TOP: 217.93,11.56 217.68,11.81 216.28,11.81 216.15,11.94 216.15,13.08 216.41,13.34 218.57,13.34 218.82,13.08 218.82,11.68 218.69,11.56
AMP_OUT_A_L on BOTTOM: 218.06,11.56 217.74,11.87 216.09,11.87 214.5,13.46 214.5,14.73 214.63,14.86 216.28,14.86 216.28,13.56 216.64,13.21 218.44,13.21 218.69,12.95 218.69,11.68 218.57,11.56 ; 2 cut-outs
AMP_OUT_B on TOP: 214,18.54 213.66,18.87 213.66,20.04 213.82,20.19 214.3,20.19 214.55,19.94 214.55,18.72 214.38,18.54
AMP_OUT_B on BOTTOM: 211.07,15.37 210.95,15.49 210.95,17.4 211.2,17.65 212.34,17.65 213.23,18.54 213.23,19.05 212.85,19.43 212.85,19.94 213.11,20.19 214.38,20.19 214.63,19.94 214.63,18.29 214.12,17.78 214.12,16.51 213.74,16.13 212.6,16.13 211.84,15.37 ; 1 cut-out
AMP_OUT_C on TOP: 209.35,14.35 209.3,14.4 209.3,18.29 210.31,19.3 210.95,19.3 211.2,19.56 211.33,19.56 211.46,19.43 211.46,18.41 211.07,18.03 211.07,14.4 211.02,14.35 ; 3 cut-outs
AMP_OUT_C_L on TOP: 209.09,10.54 208.99,10.64 208.99,12.75 209.19,12.95 211.33,12.95 211.46,13.08 212.52,13.08 212.7,13.26 215.52,13.26 215.65,13.13 215.65,11.94 215.52,11.81 214.12,11.81 213.91,12.03 212.56,12.03 212.55,12.01 211.48,12.01 210.01,10.54
AMP_OUT_D on TOP: 207.01,14.35 206.96,14.4 206.96,19.2 207.57,19.81 208.79,19.81 209.17,20.19 210.08,20.19 210.16,20.12 210.16,19.79 208.79,18.41 208.79,14.45 208.69,14.35 ; 3 cut-outs
AMP_SPKR_L+_C on TOP: 217.93,5.21 217.81,5.33 217.81,8.89 217.65,9.04 217.65,9.42 218.01,9.78 218.87,9.78 219.07,9.58 219.07,9.02 218.69,8.64 218.69,5.33 218.57,5.21
AMP_SPKR_L+_C on BOTTOM: 215.75,8.48 214.41,9.82 214.41,11.11 213.41,12.12 212.45,12.12 212.24,12.32 212.24,14.78 212.42,14.96 213.94,14.96 214.1,14.81 214.1,13.28 216.15,11.23 216.15,10.52 216.87,9.8 218.85,9.8 219.07,9.58 219.07,8.74 218.82,8.48 ; 1 cut-out
