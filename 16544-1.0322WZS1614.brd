# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQB1_12: length 24.9
  TOP w0.13: VRAMB2.B13 47.1,214.87 47.48,214.49 v6(47.5,214.49) ; GPU1.E9 58.05,195.65 v6(58,195.65)
  L6 w0.089: 47.57,212.4 47.16,212.81 47.16,214.15 v6(47.5,214.49)
  L6 w0.11: v6(58,195.65) 58,195.97 57.55,196.42 57.55,196.7 56.68,197.56 56.68,198.34 48.6,206.42 48.6,211.36 47.57,212.4
DQB1_13: length 25.9
  TOP w0.13: v6(57.96,193.91) 58.47,193.4 GPU1.G9 ; VRAMB2.A13 v6(46.7,213.7)
  L6 w0.11: v6(46.7,213.7) 46.7,212.67 48.18,211.19 48.18,206.24 56.02,198.4 56.02,197.73 57.16,196.58 57.16,196.24 57.59,195.81 57.59,194.28 v6(57.96,193.91)
DQB1_14: length 31.6
  TOP w0.13: VRAMB2.E13 v6(46.7,216.9) ; GPU1.H9 58.6,192.7 58.14,193.16 v6(57.89,193.16)
  L6 w0.11: v6(46.7,216.9) 46.29,216.49 45.71,216.49 45.7,216.48 45.5,216.48 45.28,216.26 45.28,213.5 47.76,211.02 47.76,206.07 55.56,198.27 55.56,197.67 56.78,196.45 56.78,196.16 57.24,195.7 57.24,193.75 57.42,193.56 57.49,193.56 v6(57.89,193.16)
DQB1_15: length 31.5
  TOP w0.13: GPU1.F8 56.95,194.65 v6(56.8,194.65) ; VRAMB2.F13 v6(47.5,217.7)
  L6 w0.089: v6(47.5,217.7) 47.5,217.68 47.12,217.3 46.87,217.3 45.39,217.3 45.23,217.14
  L6 w0.11: v6(56.8,194.65) 56.8,194.92 56.35,195.38 56.35,196.35 55.05,197.65 55.05,198.14 47.34,205.84 47.34,210.84 44.86,213.32 44.86,216.77 45.23,217.14
DQB1_16: length 36.9
  TOP w0.13: VRAMB2.U4 55.35,227.94 58.61,227.94 60.7,225.85 60.7,209.03 62.59,207.14 62.59,203.46 62.96,203.09 62.96,198.24 GPU1.B15
DQB1_17: length 35.3
  TOP w0.13: GPU1.C15 62.66,197.64 62.66,202.91 62.1,203.46 62.1,206.93 60.2,208.84 60.2,225.5 58.35,227.35 57.81,227.35 57.66,227.5 56.5,227.5 VRAMB2.U2
DQB1_18: length 33.9
  TOP w0.13: VRAMB2.T4 54.7,226.5 56.86,226.5 56.99,226.63 57.43,226.63 57.48,226.67 58.13,226.67 58.5,226.31 59.71,225.09 59.71,211.96 59.46,211.71 59.46,208.89 61.62,206.73 61.62,203.46 62,203.08 62,198.9 GPU1.A14
DQB1_19: length 32.3
  TOP w0.13: VRAMB2.T2 56.32,225.68 56.96,225.68 57.06,225.78 57.45,225.78 57.46,225.78 57.99,225.78 59.19,224.58 59.19,212.79 58.85,212.45 58.85,209.3 59.1,209.05 59.1,208.56 61.13,206.53 61.13,203.46 61.5,203.1 61.5,198.5 GPU1.B14
DQB1_20: length 31.6
  TOP w0.13: VRAMB2.N2 56.29,223.32 56.93,223.32 57.04,223.2 57.4,223.2 57.94,222.66 57.94,213.94 56.51,212.51 56.51,207.54 58.61,205.44 58.61,203.58 60.24,201.95 60.24,196.76 GPU1.D12
DQB1_21: length 28.7
  TOP w0.13: VRAMB2.M2 56.3,222.5 56.82,222.5 56.97,222.34 57.16,222.34 57.56,221.94 57.56,214.64 57.57,214.63 57.57,214.28 57.32,214.03 57.25,214.03 56.74,213.52 55.77,212.55 55.77,207.59 58.12,205.23 58.12,203.66 59.34,202.45 59.34,198.26 GPU1.B11
DQB1_22: length 30.3
  TOP w0.13: GPU1.C11 59.04,197.66 59.04,202.31 57.64,203.72 57.64,205.03 55.04,207.63 55.04,211.86 52.52,214.38 52.52,222.04 52.74,222.26 53.12,222.26 53.37,222.51 53.91,222.51 VRAMB2.M4
DQB1_23: length 29.2
  TOP w0.13: GPU1.A9 58.6,202.17 57.15,203.62 57.15,204.83 54.41,207.58 54.41,211.58 54.33,211.66 54.33,211.86 52.22,213.97 52.22,222.78 52.74,223.3 53.9,223.3 VRAMB2.N4
DQB1_24: length 33.4
  TOP w0.13: VRAMB2.N13 47.5,224.1 50.2,224.1 50.98,223.32 50.98,212.67 52,211.65 52.67,210.98 52.67,206.88 55.51,204.04 55.51,203.63 56.94,202.2 56.94,197.36 GPU1.C8
DQB1_25: length 32
  TOP w0.13: VRAMB2.N11 49.1,223.3 49.66,223.3 49.98,222.98 50.22,222.98 50.7,222.5 50.7,218.24 50.44,217.98 50.44,212.25 50.65,212.05 50.65,212.02 52.19,210.47 52.19,206.68 55.27,203.59 55.27,203.25 56.64,201.89 56.64,196.76 GPU1.D8
DQB1_26: length 32.2
  TOP w0.13: GPU1.C6 55.44,197.66 55.44,202.05 51.18,206.31 51.18,208.43 48.88,210.73 45.45,214.16 45.45,222.54 46.16,223.24 46.76,223.24 VRAMB2.M13
DQB1_27: length 29
  TOP w0.13: VRAMB2.M11 49.08,222.52 49.08,221.88 49.28,221.68 50.02,221.68 50.44,221.26 50.44,218.61 50.04,218.21 50.04,211.76 51.35,210.45 51.69,210.11 51.69,206.49 55.74,202.44 55.74,198.26 GPU1.B6
DQB1_28: length 36.7
  TOP w0.13: GPU1.D5 55,196.05 54.26,196.79 54.26,199.56 48.64,205.18 48.64,207.29 44.09,211.83 44.09,224.59 44.49,224.99 44.5,224.99 45.22,225.7 45.53,225.7 45.55,225.72 45.89,225.72 45.91,225.7 46.7,225.7 VRAMB2.T13
DQB1_29: length 41.5
  TOP w0.13: GPU1.C4 53.52,197.41 52.8,198.71 52.8,198.86 52.02,199.64 51.18,199.64 49.98,200.85 49.98,201.23 47.12,204.47 46.44,207.43 43.92,209.94 43.92,210.13 41.75,212.31 41.75,224.66 43.05,225.96 43.05,225.98 45.07,228 46.56,228 47.98,227.62 VRAMB2.U11
DQB1_30: length 37.7
  TOP w0.13: GPU1.B4 53.8,198.79 52.35,200.24 52.24,200.24 50.99,201.49 50.99,202.01 48.12,204.88 48.12,207.12 43.21,212.04 43.21,224.36 45.47,226.62 46.04,226.62 46.16,226.5 48.3,226.5 VRAMB2.T11
DQB1_31: length 36.5
  TOP w0.13: GPU1.A3 51.99,200.01 51.79,200.01 50.46,201.33 50.46,201.83 47.62,204.67 47.62,206.93 44.41,210.14 44.41,210.33 42.51,212.23 42.51,224.56 45.43,227.48 46.53,227.48 VRAMB2.U13
DQC0_0: length 36.5
  TOP w0.13: GPU1.C1 50.91,196.7 44.95,202.67 42.74,202.67 41.29,204.11 40.6,204.11 37.19,207.52 25.35,207.52 22.53,204.69 22.53,203.47 VRAMC1.A13
DQC0_1: length 37.7
  TOP w0.13: VRAMC1.B11 23.5,201.7 23.5,203.84 23.38,203.96 23.38,204.63 25.63,206.88 26.62,206.88 26.64,206.91 37.1,206.91 40.38,203.63 41.09,203.63 42.59,202.13 44.77,202.13 50.71,196.2 GPU1.D2
DQC0_2: length 41.6
  TOP w0.13: VRAMC1.A11 23.1,201.5 22.61,202 22.4,202 22,202.4 22,205.03 24.54,207.57 24.54,207.67 24.84,207.98 37.44,207.98 40.82,204.6 41.49,204.6 42.92,203.17 45.15,203.17 51.12,197.2 52.1,197.2 GPU1.D3
DQC0_3: length 37
  TOP w0.13: GPU1.E4 53.26,195.74 50.46,195.74 44.67,201.52 42.51,201.52 40.89,203.14 40.16,203.14 37.08,206.22 25.82,206.22 25.07,205.47 25.07,205.46 24.26,204.65 24.26,203.87 24.27,203.85 24.27,203.55 24.26,203.53 24.26,203.26 24.16,203.15 24.15,203.15 VRAMC1.B13
DQC0_4: length 29.1
  TOP w0.13: GPU1.F2 51.74,194.26 47.62,194.26 43.57,198.31 39.89,198.31 38.1,200.1 31.46,200.1 30.92,199.56 28.74,199.56 28.32,199.98 28.32,200.72 28.12,200.92 27.48,200.92 VRAMC1.F11
DQC0_5: length 32.4
  TOP w0.13: VRAMC1.F13 26.74,203.26 26.74,203.86 27.52,204.64 35.71,204.64 40.13,200.22 40.13,200.05 41.25,198.93 43.66,198.93 47.12,195.47 48.03,194.56 52.34,194.56 GPU1.F3
DQC0_6: length 32.1
  TOP w0.13: VRAMC1.E11 26.7,200.9 26.7,200.34 27.02,200.02 27.02,199.78 27.54,199.26 31.16,199.26 31.52,199.62 37.69,199.62 37.96,199.35 37.96,199.33 39.48,197.81 43.37,197.81 47.48,193.7 49.8,193.7 50.14,193.36 53.24,193.36 GPU1.H4
DQC0_7: length 33.6
  TOP w0.13: VRAMC1.E13 25.9,202.5 25.9,199.8 26.77,198.93 31.43,198.93 31.64,199.14 37.21,199.14 38.35,198 39.04,197.31 43.16,197.31 47.41,193.06 52.64,193.06 GPU1.H3
DQC0_8: length 29
  TOP w0.13: VRAMC1.E4 26.59,195.99 26.7,196.1 26.7,197.09 27.32,197.71 35.79,197.71 37.92,195.58 41.68,195.58 41.76,195.5 42.56,195.5 46.66,191.4 GPU1.J1
DQC0_9: length 30.3
  TOP w0.13: VRAMC1.F4 27.5,196.09 27.5,196.63 27.74,196.88 27.74,197.26 27.96,197.48 35.62,197.48 38.13,194.97 39.93,194.97 40.08,194.82 42.54,194.82 46.4,190.96 52.34,190.96 GPU1.L3
DQC0_10: length 28.5
  TOP w0.13: VRAMC1.F2 27.5,193.7 27.5,193.11 27.66,192.95 28.16,192.45 35.71,192.45 37.5,194.23 37.92,194.23 37.92,194.23 38.23,194.23 38.23,194.23 42.42,194.23 45.99,190.66 51.74,190.66 GPU1.L2
DQC0_11: length 31.8
  TOP w0.13: VRAMC1.E2 26.69,193.71 26.69,193.08 26.8,192.96 26.8,192.3 27.04,192.06 36.06,192.06 37.49,193.49 42.45,193.49 44.35,191.59 44.58,191.59 46.41,189.76 53.24,189.76 GPU1.M4
DQC0_12: length 32.3
  TOP w0.13: VRAMC1.B2 24.32,193.68 24.32,193.04 24.28,193 24.28,192.94 24.22,192.88 24.22,191.96 25.27,190.91 25.96,190.91 26.06,190.8 38.58,190.8 38.86,191.08 40.21,191.08 40.41,190.88 41.45,190.88 43.27,189.07 44.65,189.07 45.21,188.5 51.5,188.5 GPU1.P2
DQC0_13: length 33.8
  TOP w0.13: VRAMC1.B4 23.5,195.3 23.5,193.14 23.39,193.03 23.39,192.91 23.38,192.89 23.38,192.55 23.39,192.53 23.39,191.81 24.9,190.3 25.53,190.3 25.63,190.4 40.56,190.4 40.59,190.37 41.28,190.37 43.07,188.58 44.65,188.58 45.23,188 51.1,188 GPU1.P1
DQC0_14: length 35.3
  TOP w0.13: GPU1.R3 52.36,187.34 45.4,187.34 44.65,188.09 42.83,188.09 41.12,189.8 24.5,189.8 24.21,190.09 24.16,190.09 24.16,190.14 22.65,191.65 22.65,192.19 22.5,192.34 22.5,193.5 VRAMC1.A2
DQC0_15: length 37
  TOP w0.13: VRAMC1.A4 22.06,194.65 22.06,191.23 22.28,191.01 22.38,191.01 24.18,189.2 41.01,189.2 42.61,187.61 44.65,187.61 45.22,187.04 51.76,187.04 GPU1.R2
DQC0_16: length 31.3
  TOP w0.13: v1(32.3,202.5) VRAMC1.M13 ; v6(55.35,193.2) 55.35,193.05 GPU1.H6
  L6 w0.089: v1(32.3,202.5) 32.7,202.9 32.7,204.46 33.37,205.12
  L6 w0.11: 33.37,205.12 37.64,205.12 39.87,202.9 44.43,202.9 53.68,193.65 54.63,193.65 55.08,193.2 v6(55.35,193.2)
DQC0_17: length 31.4
  TOP w0.13: GPU1.J8 57.35,191.4 56.81,191.95 v6(56.81,192) ; VRAMC1.N13 v6(33.1,203.3)
  L6 w0.089: v6(33.1,203.3) 33.5,203.7 33.5,204.47 33.74,204.71
  L6 w0.1: 53.83,193.22 54.29,192.76 55.76,192.76
  L6 w0.11: v6(56.81,192) 56.6,192 55.84,192.76 55.76,192.76 ; 53.83,193.22 53.52,193.22 44.28,202.46 39.38,202.46 37.13,204.71 33.74,204.71
DQC0_18: length 25.9
  TOP w0.13: GPU1.J7 56.55,191.4 56.01,191.94 v6(56.01,192) ; VRAMC1.U13 36.33,203.33 v6(36.35,203.33)
  L6 w0.11: v6(36.35,203.33) 37.57,203.33 38.87,202.03 44.12,202.03 53.31,192.84 53.75,192.84 54.16,192.44 55.56,192.44 56,192 v6(56.01,192)
DQC0_19: length 24.9
  TOP w0.13: GPU1.J5 54.9,191.45 v6(54.35,192) ; VRAMC1.T13 v6(35.5,202.5)
  L6 w0.11: v6(35.5,202.5) 35.91,202.91 37.12,202.91 38.44,201.6 43.92,201.6 52.2,193.32 52.33,193.32 53.19,192.46 53.62,192.46 54.08,192 v6(54.35,192)
DQC0_20: length 26.2
  TOP w0.13: v6(36.51,200.9) 36.3,200.9 VRAMC1.U11 ; v6(56.95,190.8) 57.4,190.35 GPU1.L8
  L6 w0.11: v6(36.51,200.9) 37.84,199.57 43.09,199.57 50.86,191.8 51.68,191.8 52.27,191.22 56.54,191.22 v6(56.95,190.8)
DQC0_21: length 29.2
  TOP w0.13: GPU1.L6 55.8,190.35 v6(55.35,190.8) ; VRAMC1.N11 v6(33.1,201.7)
  L6 w0.089: v6(33.1,201.7) 33.5,201.3 33.5,200.05 33.63,199.92
  L6 w0.11: 33.63,199.92 34.87,198.68 42.79,198.68 50.45,191.02 51.08,191.02 51.71,190.39 54.94,190.39 v6(55.35,190.8)
DQC0_22: length 25.3
  TOP w0.13: v6(54.45,190.8) 54.9,190.35 GPU1.L5 ; VRAMC1.T11 v6(34.7,200.9)
  L6 w0.11: v6(34.7,200.9) 36.49,199.11 42.96,199.11 50.67,191.4 51.44,191.4 52.04,190.8 v6(54.45,190.8)
DQC0_23: length 33.2
  TOP w0.13: VRAMC1.M11 v6(31.5,201.7) ; v6(57.75,189.6) 58.2,189.15 GPU1.M9
  L6 w0.089: v6(31.5,201.7) VRAMC1.M11 31.9,200.33 32.03,200.2
  L6 w0.11: 32.03,200.2 33.99,198.25 42.62,198.25 50.15,190.71 50.67,190.71 51.37,190.01 57.34,190.01 v6(57.75,189.6)
DQC0_24: length 23.8
  TOP w0.13: GPU1.P5 54.45,188.25 v6(54.45,188.4) ; VRAMC1.T4 v6(35.5,195.3)
  L6 w0.089: v6(35.5,195.3) 35.53,195.3 35.93,195.7 36.47,195.7 36.47,195.71 36.95,195.71 37.62,195.04
  L6 w0.11: 37.62,195.04 43.25,195.04 49.9,188.39 52.01,188.39 52.42,187.98 53.74,187.98 54.16,188.4 v6(54.45,188.4)
DQC0_25: length 21.8
  TOP w0.13: v6(53.55,188.4) 53.55,188.25 GPU1.P4 ; v6(36.3,196.1) VRAMC1.U4
  L6 w0.11: v6(36.3,196.1) 37.2,196.1 37.6,195.7 43.18,195.7 50.06,188.82 53.13,188.82 v6(53.55,188.4)
DQC0_26: length 25.2
  TOP w0.13: VRAMC1.U2 36.32,194.52 v6(36.46,194.52) ; v6(56.95,187.2) 56.95,187.05 GPU1.R8
  L6 w0.11: v6(36.46,194.52) 43.17,194.52 49.69,188 51.83,188 52.14,187.69 53.95,187.69 54.2,187.94 56.21,187.94 v6(56.95,187.2)
DQC0_27: length 24.5
  TOP w0.13: v6(55.35,187.2) 55.35,187.05 GPU1.R6 ; VRAMC1.T2 v6(35.5,193.7)
  L6 w0.089: 37.44,193.68 37.01,194.1 35.76,194.1 35.5,193.84 v6(35.5,193.7)
  L6 w0.11: v6(55.35,187.2) 54.89,187.66 54.32,187.66 54.04,187.38 51.76,187.38 51.5,187.64 49.46,187.64 43.6,193.51 37.61,193.51 37.44,193.68
DQC0_28: length 29.3
  TOP w0.13: VRAMC1.N2 v6(33.1,194.5) ; v6(56.15,186) 56.15,185.85 GPU1.U7
  L6 w0.089: 34.06,192.1 33.4,192.76 33.4,193.43 33.5,193.53 33.5,193.87 33.5,193.87 33.5,194.21 33.21,194.5 v6(33.1,194.5)
  L6 w0.1: 52.52,186.4 55.18,186.4 55.18,186.41 55.52,186.41 55.52,186.4 55.82,186.4 56.15,186.07 v6(56.15,186)
  L6 w0.11: 52.52,186.4 51.18,186.4 50.96,186.18 50.28,186.18 50.06,186.4 47.84,186.4 43.9,190.35 35.57,190.35 34.3,191.62 34.3,191.87 34.06,192.1
DQC0_29: length 28.1
  TOP w0.13: GPU1.U6 55.35,185.85 v6(55.35,186) ; v6(32.3,193.7) VRAMC1.M2
  L6 w0.11: v6(32.3,193.7) 32.3,193.51 32.74,193.07 32.74,192.54 35.36,189.92 43.72,189.92 47.79,185.85 52.76,185.85 52.9,186 v6(55.35,186)
DQC0_30: length 32.6
  TOP w0.13: GPU1.V8 57.4,184.35 v6(56.95,184.8) ; VRAMC1.N4 v6(32.3,195.3)
  L6 w0.089: v6(32.3,195.3) 32.3,195.27 31.9,194.87 31.9,194.67 31.9,194.67 31.9,194.33 31.9,194.33 31.9,193.87 31.9,193.87 31.9,193.53 31.9,193.53 31.9,193.08 31.89,193.06 31.89,192.73 31.9,192.71 31.9,192.71 32.46,192.15
  L6 w0.11: 32.46,192.15 32.46,191.92 34.88,189.5 43.55,189.5 47.56,185.5 52.89,185.5 52.95,185.56 56.19,185.56 v6(56.95,184.8)
DQC0_31: length 33.3
  TOP w0.13: v6(56.15,184.8) 56.6,184.35 GPU1.V7 ; v6(31.5,196.1) VRAMC1.M4
  L6 w0.089: v6(31.5,196.1) 31.5,195.99 31.1,195.59 31.1,195.14 31.09,195.13 31.09,193.52 31.17,193.44 31.17,192.87 31.46,192.57
  L6 w0.11: 31.46,192.57 31.46,192.33 34.71,189.08 43.38,189.08 47.31,185.15 53.17,185.15 53.24,185.22 55.73,185.22 v6(56.15,184.8)
DQC1_0: length 29.8
  TOP w0.13: VRAMC2.N11 26.58,177.48 26.73,177.62 26.73,178.22 27.77,179.27 31.33,179.27 31.7,178.9 38,178.9 38.25,179.15 38.8,179.7 50.87,179.7 51.15,179.98 53.38,179.98 GPU1.AA4
DQC1_1: length 28.5
  TOP w0.13: GPU1.AC2 51.5,178.7 41.31,178.7 38.09,175.48 37.21,174.6 36.54,173.92 28.07,173.92 27.78,174.22 27.78,174.34 27.5,174.62 27.5,175.2 27.44,175.26 VRAMC2.M13
DQC1_2: length 26.1
  TOP w0.13: VRAMC2.M11 27.51,177.6 28.13,177.6 28.28,177.76 28.28,178.46 28.87,179.04 30.9,179.04 31.54,178.4 39.77,178.4 40.57,179.2 51.1,179.2 GPU1.AC1
DQC1_3: length 28.3
  TOP w0.13: VRAMC2.N13 26.61,175.29 26.7,175.2 26.7,174.62 26.78,174.54 26.78,174.12 27.24,173.66 37.12,173.66 41.66,178.2 41.84,178.2 GPU1.AD1
DQC1_4: length 36.3
  TOP w0.13: GPU1.AE3 52.38,176.28 50.98,176.28 50.81,176.11 45.73,176.11 44.81,175.19 42.98,175.19 42.96,175.19 39.73,171.96 33.27,171.96 33.02,171.7 25.6,171.7 23.37,173.93 23.37,174.46 23.5,174.59 23.5,176.8 VRAMC2.T11
DQC1_5: length 32.7
  TOP w0.13: GPU1.AE2 51.76,176.56 45.85,176.56 44.97,175.68 42.76,175.68 41.2,174.12 40.84,174.12 39.38,172.65 38.72,172.65 38.63,172.57 32.74,172.57 32.13,171.96 26.29,171.96 25.83,172.42 25.81,172.42 24.23,174 24.23,174.47 24.3,174.55 24.3,175.2 VRAMC2.T13
DQC1_6: length 37.4
  TOP w0.13: GPU1.AF2 51.5,175.1 45.5,175.1 44.62,174.22 43.41,174.22 40.28,171.09 24.36,171.09 22.94,172.52 22.1,173.35 22.1,176.38 22.92,177.2 VRAMC2.U11
DQC1_7: length 33.6
  TOP w0.13: GPU1.AF1 51.1,175.6 45.55,175.6 44.65,174.71 43.29,174.71 43.29,174.7 43.18,174.7 39.83,171.35 25.1,171.35 24.69,171.76 22.5,173.95 22.5,175 VRAMC2.U13
DQC1_8: length 38.3
  TOP w0.13: GPU1.U4 53.26,186.14 45.63,186.14 44.65,187.12 42.38,187.12 40.76,188.75 24.41,188.75 24,188.34 24,188.3 22.08,186.38 22.08,183.82 22.78,183.12 VRAMC2.U4
DQC1_9: length 34.3
  TOP w0.13: VRAMC2.U2 22.62,184.88 22.62,186.02 24.74,188.14 40.66,188.14 42.16,186.64 44.65,186.64 45.43,185.86 52.64,185.86 GPU1.U3
DQC1_10: length 32.7
  TOP w0.13: GPU1.U1 45.43,185.4 44.68,186.15 41.91,186.15 40.52,187.54 25.03,187.54 23.5,186.01 23.48,186.01 23.48,185.59 23.5,185.57 23.5,183.21 VRAMC2.T4
DQC1_11: length 31.4
  TOP w0.13: GPU1.V2 51.5,184.9 45.6,184.9 44.84,185.67 40.55,185.67 38.92,187.29 25.7,187.29 24.32,185.92 24.32,184.82 24.12,184.62 VRAMC2.T2
DQC1_12: length 28
  TOP w0.13: VRAMC2.M2 27.52,184.81 27.52,185.63 28.04,186.16 36.14,186.16 39.18,183.12 41.44,183.12 41.55,183.01 49.65,183.01 50.06,183.42 51.78,183.42 GPU1.W2
DQC1_13: length 29.2
  TOP w0.13: VRAMC2.M4 27.53,182.37 27.53,181.76 27.58,181.71 27.58,181.53 28.02,181.1 35.9,181.1 37.68,182.88 38.48,182.88 38.74,182.62 41.22,182.62 41.34,182.5 53.3,182.5 GPU1.Y4
DQC1_14: length 29.6
  TOP w0.13: VRAMC2.N2 25.88,183.98 25.88,181.58 25.88,181.57 25.88,181.23 25.88,181.22 25.88,181.18 26.54,180.52 36.72,180.52 37.58,181.38 40.97,181.38 40.99,181.4 50.2,181.4 50.6,181.8 GPU1.Y1
DQC1_15: length 29.1
  TOP w0.13: VRAMC2.N4 26.74,182.37 26.74,181.61 26.73,181.61 26.73,181.26 26.98,181.01 27.03,181.01 27.25,180.79 36.29,180.79 37.5,182 39.28,182 39.29,181.99 50.09,181.99 50.32,182.22 52.68,182.22 GPU1.Y3
DQC1_16: length 30
  TOP w0.13: GPU1.V4 54,184.35 v6(53.55,184.8) ; v6(31.5,182.4) VRAMC2.F4
  L6 w0.089: v6(31.5,182.4) 31.5,182.63 31.1,183.03 31.1,183.37 31.1,184.37 31.3,184.57
  L6 w0.11: v6(53.55,184.8) 47.07,184.8 43.6,188.27 33.33,188.27 31.3,186.23 31.3,184.57
DQC1_17: length 29.3
  TOP w0.13: GPU1.V5 54.9,184.35 v6(54.45,184.8) ; VRAMC2.E4 v6(32.3,183.2)
  L6 w0.089: v6(32.3,183.2) 32.3,183.43 31.9,183.83 31.9,185.44 31.88,185.47 31.88,185.97 32.05,186.15
  L6 w0.11: 32.05,186.15 33.75,187.84 43.43,187.84 46.85,184.42 53.11,184.42 53.15,184.38 54.04,184.38 v6(54.45,184.8)
DQC1_18: length 27.5
  TOP w0.13: v6(55.35,183.6) 55.8,183.15 GPU1.W6 ; VRAMC2.F2 v6(32.3,184.8)
  L6 w0.089: 33.33,186.68 32.68,186.03 32.68,185.43 32.3,185.06 v6(32.3,184.8)
  L6 w0.11: 33.33,186.68 34.02,187.36 43.31,187.36 46.61,184.07 54.88,184.07 v6(55.35,183.6)
DQC1_19: length 26.7
  TOP w0.13: VRAMC2.E2 v6(33.1,184) ; GPU1.W5 54.45,183.45 v6(54.45,183.6)
  L6 w0.089: v6(33.1,184) 33.1,184.1 33.5,184.5 33.5,184.94 33.48,184.97 33.48,186.04 33.93,186.49
  L6 w0.11: v6(54.45,183.6) 54.05,183.19 53.73,183.19 53.67,183.14 53.43,183.14 53.37,183.19 53.13,183.19 52.65,183.68 51.26,183.68 51.19,183.75 50.43,183.75 50.36,183.68 46.41,183.68 43.14,186.95 34.39,186.95 33.93,186.49
DQC1_20: length 22.5
  TOP w0.13: GPU1.Y6 55.8,181.8 55.43,182.17 v6(55.43,182.39) ; VRAMC2.B2 v6(35.5,184.8)
  L6 w0.089: 36.92,184.39 36.91,184.41 36.47,184.41 36.47,184.4 35.79,184.4 35.5,184.69 v6(35.5,184.8)
  L6 w0.11: v6(55.43,182.39) 55.25,182.22 50.27,182.22 50.08,182.4 45.26,182.4 45.03,182.62 44.6,182.62 42.84,184.39 36.92,184.39
DQC1_21: length 22.3
  TOP w0.13: VRAMC2.A2 36.3,184 v6(36.33,184) ; v6(56.15,182.4) 56.15,182.25 GPU1.Y7
  L6 w0.11: v6(36.33,184) 36.33,183.99 36.73,183.59 43.05,183.59 44.34,182.29 44.95,182.29 45.24,182 50.05,182 50.11,181.94 55.69,181.94 v6(56.15,182.4)
DQC1_22: length 24.6
  TOP w0.13: v6(57.75,182.4) 58.2,181.95 GPU1.Y9 ; VRAMC2.B4 v6(35.5,183.2)
  L6 w0.11: v6(57.75,182.4) 56.96,181.61 45.22,181.61 44.94,181.89 44.07,181.89 43.16,182.8 36.54,182.8 36.14,183.2 v6(35.5,183.2)
DQC1_23: length 20.4
  TOP w0.13: v6(36.3,182.4) VRAMC2.A4 ; GPU1.AA5 54.45,181.05 v6(54.45,181.2)
  L6 w0.11: v6(54.45,181.2) 54,180.75 52.21,180.75 51.78,181.18 45.14,181.18 44.89,181.43 43.84,181.43 43.07,182.2 36.5,182.2 v6(36.3,182.4)
DQC1_24: length 28.3
  TOP w0.13: GPU1.AC7 56.15,178.95 v6(56.15,178.8) ; VRAMC2.F11 v6(31.5,176.8)
  L6 w0.089: v6(31.5,176.8) 31.5,176.81 31.9,177.21 31.9,178.03 32.33,178.46
  L6 w0.11: 32.33,178.46 32.39,178.51 32.39,178.61 33.53,179.75 43.03,179.75 43.24,179.55 44.75,179.55 44.95,179.75 54.4,179.75 54.45,179.7 55.25,179.7 v6(56.15,178.8)
DQC1_25: length 24.8
  TOP w0.13: v6(54.45,178.8) 54.45,178.95 GPU1.AC5 ; VRAMC2.E11 v6(33.1,176.8)
  L6 w0.089: 33.99,178.36 33.51,177.88 33.51,177.43 33.1,177.03 v6(33.1,176.8)
  L6 w0.11: v6(54.45,178.8) 53.75,179.5 52.1,179.5 51.73,179.13 43.07,179.13 42.86,179.34 39.07,179.34 39.04,179.37 34.81,179.37 34.09,178.65 34.09,178.46 33.99,178.36
DQC1_26: length 21.3
  TOP w0.13: v6(53.55,178.8) 53.55,178.95 GPU1.AC4 ; VRAMC2.B11 v6(34.7,177.6)
  L6 w0.11: v6(34.7,177.6) 36.05,178.95 39.04,178.95 39.07,178.92 42.69,178.92 42.89,178.72 51.82,178.72 52.35,179.25 53.1,179.25 v6(53.55,178.8)
DQC1_27: length 23.7
  TOP w0.13: GPU1.AD9 57.75,177.75 v6(57.75,177.6) ; v6(36.49,177.64) 36.34,177.64 VRAMC2.A11
  L6 w0.11: v6(57.75,177.6) 57.04,178.31 52.41,178.31 52.23,178.49 44.93,178.49 44.75,178.3 42.72,178.3 42.54,178.49 37.34,178.49 v6(36.49,177.64)
DQC1_28: length 24.1
  TOP w0.13: VRAMC2.B13 v6(35.5,176) ; GPU1.AE8 56.95,176.55 v6(56.95,176.4)
  L6 w0.089: v6(35.5,176) 35.91,175.6 37.03,175.6
  L6 w0.11: v6(56.95,176.4) 56.31,177.04 55.28,177.04 54.92,177.41 50.78,177.41 50.77,177.41 50.43,177.41 50.42,177.41 50.23,177.41 50.02,177.2 45.76,177.2 44.89,176.32 44.03,176.32 43.31,175.6 37.03,175.6
DQC1_29: length 22
  TOP w0.13: VRAMC2.A13 v6(36.32,175.18) ; GPU1.AE6 55.8,176.85 v6(55.35,176.4)
  L6 w0.11: v6(55.35,176.4) 54.66,177.09 51.67,177.09 51.17,176.6 50.78,176.6 50.77,176.59 50.43,176.59 50.42,176.6 50.2,176.6 50.02,176.78 45.64,176.78 44.77,175.91 44.22,175.91 43.11,174.8 36.7,174.8 v6(36.32,175.18)
DQC1_30: length 25.2
  TOP w0.13: VRAMC2.E13 v6(33.1,175.2) ; v6(54.45,176.4) 54.45,176.55 GPU1.AE5
  L6 w0.089: 33.62,173.82 33.5,173.94 33.5,174.57 33.1,174.97 v6(33.1,175.2)
  L6 w0.11: 33.62,173.82 42.72,173.82 44.4,175.49 44.65,175.49 45.38,176.22 51.75,176.22 51.89,176.36 52.85,176.36 53.35,176.86 53.99,176.86 v6(54.45,176.4)
DQC1_31: length 31
  TOP w0.13: VRAMC2.F13 v6(31.5,175.2) ; GPU1.AF10 58.55,175.35 v6(58.55,175.2)
  L6 w0.1: 31.5,174.28 v6(31.5,175.2)
  L6 w0.11: 31.5,174.28 32.38,173.4 42.9,173.4 44.57,175.08 44.75,175.08 45.5,175.82 51.98,175.82 52.09,175.94 57.81,175.94 v6(58.55,175.2)
DQD0_0: length 30.6
  TOP w0.13: v6(56.15,175.2) 56.15,175.35 GPU1.AF7 ; VRAMD1.M13 v6(32.3,165.5)
  L6 w0.089: v6(32.3,165.5) 32.3,165.65 32.64,165.99 32.64,166.07 32.7,166.13 32.7,166.47 32.64,166.53 32.64,167.44 33.54,168.34
  L6 w0.11: 33.54,168.34 37.58,172.38 42.49,172.38 45.51,175.4 52.08,175.4 52.32,175.64 55.71,175.64 v6(56.15,175.2)
DQD0_1: length 23.2
  TOP w0.13: v6(54.45,175.2) 54.45,175.35 GPU1.AF5 ; VRAMD1.U13 v6(36.31,166.31)
  L6 w0.11: v6(36.31,166.31) 41.22,171.22 42.53,171.22 45.83,174.52 53.47,174.52 53.73,174.77 54.15,175.2 v6(54.45,175.2)
DQD0_2: length 26.1
  TOP w0.13: GPU1.AF4 53.55,175.35 v6(53.55,175.2) ; VRAMD1.N13 v6(33.1,166.3)
  L6 w0.089: v6(33.1,166.3) 33.1,166.4 33.5,166.8 33.5,167.44 34.18,168.12
  L6 w0.11: 34.18,168.12 37.96,171.9 42.6,171.9 45.69,174.98 52.21,174.98 52.43,174.75 53.1,174.75 v6(53.55,175.2)
DQD0_3: length 25.1
  TOP w0.13: v6(55.35,174) 55.8,174.45 GPU1.AG6 ; VRAMD1.T13 v6(35.5,166.3)
  L6 w0.089: v6(35.5,166.3) 35.53,166.3 35.92,165.91 36.88,165.91 37.2,166.23
  L6 w0.11: 37.2,166.23 37.27,166.23 41.59,170.55 42.51,170.55 46.1,174.14 53.59,174.14 53.9,174.44 54.91,174.44 v6(55.35,174)
DQD0_4: length 24.5
  TOP w0.13: v6(55.35,172.8) 55.35,172.95 GPU1.AJ6 ; v6(36.53,163.9) 36.13,164.3 VRAMD1.U11
  L6 w0.11: v6(55.35,172.8) 55.04,172.8 54.53,173.3 54.31,173.3 54.02,173.01 51.72,173.01 51.22,172.52 47.34,172.52 38.72,163.9 v6(36.53,163.9)
DQD0_5: length 25.2
  TOP w0.13: GPU1.AJ5 54.45,172.95 v6(54.45,172.8) ; VRAMD1.T11 v6(34.7,163.9)
  L6 w0.11: v6(54.45,172.8) 54.36,172.71 51.99,172.71 51.38,172.1 47.6,172.1 38.88,163.38 35.22,163.38 v6(34.7,163.9)
DQD0_6: length 31.5
  TOP w0.13: VRAMD1.N11 v6(33.1,164.7) ; GPU1.AJ9 57.75,172.95 v6(57.75,172.8)
  L6 w0.089: v6(33.1,164.7) 33.1,164.59 33.5,164.19 33.5,163.76 33.5,163.76 33.5,163.19 33.83,162.86
  L6 w0.11: v6(57.75,172.8) 57.28,172.33 52.13,172.33 51.48,171.68 47.83,171.68 39.01,162.86 33.83,162.86
DQD0_7: length 32
  TOP w0.13: GPU1.AK7 56.15,171.75 v6(56.15,171.6) ; VRAMD1.M11 v6(31.5,164.7)
  L6 w0.089: v6(31.5,164.7) 31.5,164.69 31.9,164.29 31.9,162.89 32.35,162.44
  L6 w0.11: v6(56.15,171.6) 56.15,171.74 55.83,172.06 52.46,172.06 51.66,171.26 48,171.26 39.18,162.44 32.35,162.44
DQD0_8: length 27.7
  TOP w0.13: v6(56.15,170.4) 56.15,170.55 GPU1.AM7 ; VRAMD1.T4 v6(35.5,158.3)
  L6 w0.11: v6(56.15,170.4) 55.74,170.81 53.53,170.81 52.58,169.86 51.29,169.86 50.79,169.37 48.28,169.37 39.54,160.63 37.25,160.63 35.91,159.29 35.91,158.71 v6(35.5,158.3)
DQD0_9: length 25.1
  TOP w0.13: VRAMD1.U4 v6(36.33,159.13) ; GPU1.AM6 55.35,170.55 v6(55.35,170.4)
  L6 w0.11: v6(55.35,170.4) 54.93,169.98 53.24,169.98 52.72,169.46 51.5,169.46 51.12,169.08 48.59,169.08 39.71,160.2 37.4,160.2 v6(36.33,159.13)
DQD0_10: length 26.4
  TOP w0.13: GPU1.AN6 55.35,169.35 v6(55.35,169.2) ; VRAMD1.T2 v6(35.5,156.7)
  L6 w0.11: v6(55.35,169.2) 55.35,169.14 54.97,168.76 51.82,168.76 51.32,168.26 49.01,168.26 40.21,159.46 38.96,159.46 37.21,157.71 37.21,157.69 36.57,157.05 35.85,157.05 v6(35.5,156.7)
DQD0_11: length 24.7
  TOP w0.13: v6(36.31,157.52) 36.3,157.51 36.3,157.5 VRAMD1.U2 ; GPU1.AN5 54.45,169.35 v6(54.45,169.2)
  L6 w0.11: v6(54.45,169.2) 54.03,169.62 53.4,169.62 53.39,169.6 53.32,169.6 53.15,169.43 52.84,169.12 51.68,169.12 51.26,168.7 48.8,168.7 39.92,159.82 38.62,159.82 36.89,158.09 36.88,158.09 v6(36.31,157.52)
DQD0_12: length 32.6
  TOP w0.13: GPU1.AR7 56.15,168.15 v6(56.15,168) ; VRAMD1.N2 v6(33.1,157.5)
  L6 w0.089: 33.85,154.9 33.5,155.25 33.5,156.07 33.5,156.07 33.5,156.53 33.5,156.53 33.5,156.87 33.5,156.87 33.5,157.25 33.25,157.5 v6(33.1,157.5)
  L6 w0.11: v6(56.15,168) 55.73,167.57 54.6,167.57 54.25,167.22 50.13,167.22 49.28,166.38 49.28,166.12 47.93,164.77 47.93,164.1 38.73,154.9 33.85,154.9
DQD0_13: length 33.1
  TOP w0.13: v6(56.14,166.8) 56.14,167.06 GPU1.AT6 ; VRAMD1.M2 v6(32.29,156.71)
  L6 w0.11: v6(32.29,156.71) 31.78,156.2 31.78,155.63 33.47,153.93 39.28,153.93 51.79,166.45 54.18,166.45 54.28,166.35 55.69,166.35 v6(56.14,166.8)
DQD0_14: length 35.3
  TOP w0.13: v6(32.29,158.31) 32.31,158.31 VRAMD1.N4 ; v6(56.94,168) 56.94,167.86 GPU1.AT8
  L6 w0.089: v6(32.29,158.31) 32.69,157.91 32.69,157.34 32.69,156.54 32.66,156.52 32.66,155.32 33.17,154.81
  L6 w0.11: 33.17,154.81 33.45,154.54 33.69,154.54 33.82,154.41 38.98,154.41 48.55,163.98 48.55,164.57 50.02,166.04 50.02,166.34 50.5,166.82 54.63,166.82 55.03,167.22 56.17,167.22 v6(56.94,168)
DQD0_15: length 34.5
  TOP w0.13: GPU1.AV5 v6(54.36,165.66) ; VRAMD1.M4 v6(31.5,159.1)
  L6 w0.089: 30.9,156.74 30.9,157.71 31.5,158.31 v6(31.5,159.1)
  L6 w0.11: 30.9,156.74 30.9,156.5 31.32,156.08 31.32,155.49 33.19,153.62 39.57,153.62 52.03,166.07 53.94,166.07 v6(54.36,165.66)
DQD0_16: length 36.5
  TOP w0.13: GPU1.AG1 45.64,174.6 44.78,173.73 43.69,173.73 43.63,173.73 40.06,170.17 23.69,170.17 22,168.48 22,165.4 VRAMD1.A11
DQD0_17: length 35.5
  TOP w0.13: VRAMD1.A13 22.53,166.47 22.53,167.68 24.28,169.42 24.78,169.93 40.53,169.93 43.85,173.25 43.87,173.25 44.62,173.25 45.53,174.16 52.66,174.16 GPU1.AG3
DQD0_18: length 37.5
  TOP w0.13: VRAMD1.B11 23.5,164.7 23.5,166.84 23.38,166.96 23.38,167.68 25.37,169.67 37.58,169.67 38.1,169.15 39.44,169.15 39.63,169.34 40.65,169.34 44.07,172.76 44.09,172.76 44.62,172.76 45.74,173.88 53.28,173.88 GPU1.AG4
DQD0_19: length 33.1
  TOP w0.13: VRAMD1.B13 24.28,166.28 24.28,167.1 24.27,167.11 24.27,167.46 24.28,167.47 24.28,167.6 25.58,168.9 25.58,168.91 25.59,168.91 26.1,169.42 37.08,169.42 38.15,168.35 39.78,168.35 40.41,168.99 41,168.99 44.29,172.28 44.62,172.28 45.3,172.96 51.76,172.96 GPU1.AJ2
DQD0_20: length 30
  TOP w0.13: VRAMD1.F13 26.74,166.26 26.74,166.86 27.52,167.64 36.46,167.64 37.63,166.47 38.49,166.47 38.56,166.54 40.39,166.54 40.54,166.4 42.01,166.4 44.37,168.75 44.37,168.98 46.89,171.5 51.5,171.5 GPU1.AK2
DQD0_21: length 35.3
  TOP w0.13: VRAMD1.E13 25.93,165.53 25.93,162.85 26.78,162.01 36.94,162.01 39.12,164.19 41.93,164.19 47.98,170.24 53.24,170.24 GPU1.AM4
DQD0_22: length 31.9
  TOP w0.13: GPU1.AM3 52.64,170.54 47.35,170.54 47.04,170.22 47.04,169.9 44.2,167.06 44.09,167.06 42.04,165 40.61,165 40.29,164.67 39.28,164.67 37.23,162.62 31.52,162.62 31.14,162.24 27.6,162.24 27.02,162.82 27.02,163.02 26.7,163.34 26.7,163.9 VRAMD1.E11
DQD0_23: length 29
  TOP w0.13: VRAMD1.F11 27.48,163.92 27.97,163.92 28.32,163.57 28.32,163.08 28.82,162.58 30.94,162.58 31.46,163.1 37.06,163.1 39.04,165.07 40.04,165.07 40.5,165.54 41.87,165.54 45.51,169.18 45.51,169.64 46.86,171 GPU1.AM1
DQD0_24: length 29.7
  TOP w0.13: GPU1.AR1 48.75,168.6 42.66,162.51 39.49,162.51 37.79,160.81 27.41,160.81 26.7,160.09 26.7,159.1 26.53,158.93 26.53,158.93 VRAMD1.E4
DQD0_25: length 29.7
  TOP w0.13: GPU1.AR2 51.65,168.05 48.91,168.05 42.75,161.9 39.77,161.9 38.35,160.48 27.96,160.48 27.74,160.26 27.74,159.88 27.5,159.63 27.5,159.09 27.33,158.93 VRAMD1.F4
DQD0_26: length 31.3
  TOP w0.13: VRAMD1.F2 27.44,156.76 27.44,156.15 28.25,155.35 35.55,155.35 36.8,156.6 36.8,158.28 38.06,159.54 38.27,159.54 40.13,161.4 42.96,161.4 48.9,167.34 51.24,167.34 GPU1.AT1
DQD0_27: length 34.2
  TOP w0.13: GPU1.AT3 52.64,166.94 49.21,166.94 45.06,162.79 45.04,162.79 43.17,160.91 43.13,160.91 43.07,160.85 40.41,160.85 37.2,157.64 37.2,156.4 35.86,155.06 27.09,155.06 26.75,155.4 26.75,155.9 26.69,155.97 26.69,156.71 VRAMD1.E2
DQD0_28: length 37.3
  TOP w0.13: VRAMD1.B2 23.9,157.1 24.32,156.67 24.32,156.04 24.22,155.94 24.22,155.75 24.18,155.71 24.18,155.42 26.34,153.26 36.31,153.26 41.34,158.3 44.18,158.3 50.7,164.82 50.7,165.2 50.96,165.46 52.36,165.46 GPU1.AV3
DQD0_29: length 37.9
  TOP w0.13: GPU1.AW1 51.3,164.71 44.39,157.8 41.95,157.8 36.8,152.65 26.04,152.65 23.34,155.35 23.34,155.98 23.5,156.14 23.5,158.3 VRAMD1.B4
DQD0_30: length 38
  TOP w0.13: VRAMD1.A2 22.45,156.45 22.45,155.2 23.1,154.55 25.38,152.27 25.5,152.27 25.62,152.15 37.37,152.15 42.52,157.3 44.59,157.3 51.09,163.8 GPU1.AY2
DQD0_31: length 39.9
  TOP w0.13: GPU1.BA1 44.8,156.8 43.11,156.8 37.96,151.65 24.96,151.65 22.06,154.55 22.06,157.66 VRAMD1.A4
DQD1_0: length 22.3
  TOP w0.13: GPU1.AW3 v6(52.65,164.33) ; v6(53.6,149.5) VRAMD2.F4
  L6 w0.089: v6(53.6,149.5) 53.21,149.11 52.17,149.11 52.17,149.1 51.49,149.1 51.43,149.15
  L6 w0.11: v6(52.65,164.33) 51.26,161.85 51.26,161.47 49.49,158.83 48.18,155.75 48.18,150.89 49.74,149.32 51.26,149.32 51.43,149.15
DQD1_1: length 21.4
  TOP w0.13: VRAMD2.E4 v6(52.8,150.3) ; GPU1.AW4 53.55,164.55 v6(53.55,164.4)
  L6 w0.089: 49.86,150.04 50.01,149.9 52.4,149.9 v6(52.8,150.3)
  L6 w0.11: v6(53.55,164.4) 53.55,163.52 52.28,162.25 52.28,160.84 49.92,158.47 49.92,156.89 48.6,155.57 48.6,151.31 49.86,150.04
DQD1_2: length 17.1
  TOP w0.13: VRAMD2.E2 v6(52,151.1) ; GPU1.BA5 54.55,162.65 v6(54.4,162.65)
  L6 w0.089: v6(52,151.1) 51.6,151.5 51.03,151.5 51.02,151.5 49.8,151.5 49.44,151.86
  L6 w0.11: v6(54.4,162.65) 54.4,162.4 53.48,161.48 53.48,160.61 50.77,157.89 50.77,156.54 49.44,155.21 49.44,151.86
DQD1_3: length 18.4
  TOP w0.13: v6(54.4,163.55) 54.55,163.55 GPU1.AY5 ; VRAMD2.F2 v6(51.2,150.3)
  L6 w0.089: v6(51.2,150.3) 50.8,150.7 49.74,150.7 49.6,150.84
  L6 w0.11: v6(54.4,163.55) 53.7,162.85 53.7,162.33 52.94,161.57 52.94,160.66 50.34,158.06 50.34,156.71 49.02,155.39 49.02,151.63 49.4,151.25 49.4,151.04 49.6,150.84
DQD1_4: length 17.2
  TOP w0.13: v6(58,166.15) 58.15,166.15 GPU1.AU9 ; VRAMD2.B2 v6(51.2,153.5)
  L6 w0.089: 51.95,155.35 51.68,155.08 51.68,153.98 v6(51.2,153.5)
  L6 w0.11: 51.95,155.35 53.18,156.58 53.18,157.44 55.78,160.05 55.78,160.86 56.35,161.43 56.35,164.56 56.67,164.87 57.08,164.87 57.28,165.07 57.28,165.63 57.79,166.15 v6(58,166.15)
DQD1_5: length 14.7
  TOP w0.13: VRAMD2.B4 v6(52.8,153.5) ; GPU1.AW9 58.15,164.45 v6(58,164.45)
  L6 w0.089: v6(52.8,153.5) 53.21,153.91 53.21,154.46 53.35,154.6
  L6 w0.11: v6(58,164.45) 57.2,163.65 57.2,162.1 57.47,161.83 57.47,160.45 54.1,157.08 54.1,155.35 53.35,154.6
DQD1_6: length 12.7
  TOP w0.13: VRAMD2.A4 53.58,154.28 v6(53.62,154.28) ; GPU1.AY9 58.15,163.55 v6(58,163.55)
  L6 w0.11: v6(53.62,154.28) 54.52,155.18 54.52,156.91 57.89,160.28 57.89,162.05 57.56,162.38 57.56,163.11 v6(58,163.55)
DQD1_7: length 17.6
  TOP w0.13: v6(59.21,166.98) 59.38,166.98 GPU1.AT11 ; v6(52.09,154.37) 52.07,154.37 VRAMD2.A2
  L6 w0.11: v6(59.21,166.98) 59.21,166.96 58.65,166.4 58.65,165.95 58.44,165.74 57.83,165.74 57.59,165.5 57.59,165.15 57.59,164.59 56.78,163.78 56.78,161.66 57.05,161.39 57.05,160.63 53.65,157.23 53.65,156.1 52.29,154.74 52.11,154.55 52.11,154.39 v6(52.09,154.37)
DQD1_8: length 21.2
  TOP w0.13: GPU1.AU12 60.55,166.15 v6(60.4,166.15) ; v6(59.2,149.5) VRAMD2.F11
  L6 w0.089: 56.92,150.38 57.16,150.14 57.4,149.9 58.76,149.9 59.16,149.5 v6(59.2,149.5)
  L6 w0.11: 56.92,150.38 56.92,157.15 59.35,159.58 59.35,162.93 59.62,163.19 59.62,165.36 v6(60.4,166.15)
DQD1_9: length 18.5
  TOP w0.13: v6(60.4,165.35) 60.55,165.35 GPU1.AV12 ; VRAMD2.E11 v6(59.2,151.1)
  L6 w0.089: 57.38,151.84 57.73,151.5 58.8,151.5 v6(59.2,151.1)
  L6 w0.11: 57.38,151.84 57.34,151.89 57.34,156.98 60.22,159.86 60.22,163.28 59.99,163.52 59.99,164.93 v6(60.4,165.35)
DQD1_10: length 16.7
  TOP w0.13: GPU1.AU14 61.75,166.15 v6(61.6,166.15) ; VRAMD2.B11 v6(58.4,152.7)
  L6 w0.11: v6(61.6,166.15) 60.82,165.36 60.82,164.21 60.64,164.03 60.64,159.69 57.76,156.81 57.76,153.34 v6(58.4,152.7)
DQD1_11: length 12.8
  TOP w0.13: VRAMD2.A11 58.5,154.2 v6(58.5,154.5) ; GPU1.AW14 61.75,164.45 v6(61.6,164.45)
  L6 w0.11: v6(61.6,164.45) 61.06,163.91 61.06,159.51 58.45,156.9 58.45,154.55 v6(58.5,154.5)
DQD1_12: length 15.5
  TOP w0.13: GPU1.AT15 62.95,166.95 v6(62.8,166.95) ; VRAMD2.A13 v6(60.8,154.3)
  L6 w0.11: v6(62.8,166.95) 63.42,166.33 63.42,162.25 62.87,161.7 62.87,160.99 62.74,160.86 62.74,160.38 62.87,160.25 62.87,158.39 61.32,156.85 61.32,154.82 v6(60.8,154.3)
DQD1_13: length 14.8
  TOP w0.13: v6(62.8,165.35) 62.95,165.35 GPU1.AV15 ; VRAMD2.B13 60.4,153.11 60,153.5 v6(60,153.5)
  L6 w0.089: 60.4,155.31 60.4,154.13 60.01,153.74
  L6 w0.11: 60.01,153.74 60,153.74 v6(60,153.5) ; v6(62.8,165.35) 63.21,164.94 63.21,162.88 62.61,162.28 62.61,161.88 62.59,161.86 62.59,161.02 62.51,160.93 62.51,160.3 62.59,160.22 62.59,158.68 60.4,156.49 60.4,155.31
DQD1_14: length 20.3
  TOP w0.13: v6(64,166.15) 64.15,166.15 GPU1.AU17 ; v6(60.8,149.5) VRAMD2.F13
  L6 w0.11: v6(60.8,149.5) 60.82,149.48 61.75,149.48 62.46,150.19 62.46,157.02 63.88,158.45 63.88,163.73 64.06,163.91 64.06,164.83 64.41,165.18 64.41,165.74 v6(64,166.15)
DQD1_15: length 17.5
  TOP w0.13: v6(64,165.35) 64.45,165.8 GPU1.AV17 ; VRAMD2.E13 v6(60.8,151.1)
  L6 w0.089: v6(60.8,151.1) 60.8,151.1 61.2,151.5 61.93,151.5 62.05,151.63
  L6 w0.11: v6(64,165.35) 63.86,165.21 63.86,164.95 63.83,164.92 63.83,163.98 63.65,163.8 63.65,161.47 62.97,160.78 62.97,160.45 63.14,160.27 63.14,158.5 63.09,158.45 63.09,158.32 62.03,157.25 62.03,153.7 62.05,153.67 62.05,151.63
DQD1_16: length 27.4
  TOP w0.13: VRAMD2.U2 51.08,140.58 49.77,140.58 47.29,143.06 47.29,145.97 47.3,145.98 47.3,154.69 53.8,161.19 GPU1.BB4
DQD1_17: length 29.5
  TOP w0.13: VRAMD2.U4 52.18,140.08 49.21,140.08 46.69,142.61 46.69,154.88 53.1,161.3 GPU1.BC3
DQD1_18: length 27.3
  TOP w0.13: GPU1.BC5 54.61,161.3 47.9,154.59 47.9,143.46 49.92,141.44 50.39,141.44 50.43,141.48 52.78,141.48 VRAMD2.T4
DQD1_19: length 26.7
  TOP w0.13: VRAMD2.T2 51.18,142.32 50.03,142.32 48.3,144.05 48.3,154.28 51.16,157.14 51.57,157.14 55.09,160.66 55.44,161.01 55.44,162.34 GPU1.BA6
DQD1_20: length 23
  TOP w0.13: VRAMD2.M2 51.41,145.29 51.19,145.52 50.37,145.52 49.98,145.9 49.98,151.74 49.97,151.75 49.97,152.1 49.98,152.11 49.98,153.71 51.44,155.18 52.77,155.18 55.19,157.61 55.2,157.61 56.92,159.33 56.96,159.33 56.96,162.66 GPU1.BA8
DQD1_21: length 18.9
  TOP w0.13: GPU1.BC8 57.4,158.87 54.37,155.85 54.33,155.85 54.33,154.95 54.44,154.85 54.44,149.67 54.98,149.13 54.98,146.23 54.27,145.52 53.63,145.52 VRAMD2.M4
DQD1_22: length 21.3
  TOP w0.13: GPU1.BB9 57.96,161.56 57.96,158.47 57.44,157.95 56.91,157.95 54.94,155.98 54.94,149.66 55.27,149.33 55.27,145.31 54.7,144.74 54.16,144.74 54.12,144.7 53.6,144.7 VRAMD2.N4
DQD1_23: length 22.7
  TOP w0.13: VRAMD2.N2 52.01,143.89 54.41,143.89 54.43,143.88 54.77,143.88 54.79,143.89 54.89,143.89 55.58,144.58 55.58,149.82 55.44,149.96 55.44,155.24 57.3,157.1 57.53,157.1 58.6,158.17 GPU1.BC9
DQD1_24: length 22.8
  TOP w0.13: GPU1.AY12 60.24,163.24 60.24,160.12 59.9,159.78 59.65,159.52 59.65,157.1 57.14,154.59 57.14,149.74 56.8,149.4 56.8,149.07 56.79,149.06 56.79,146.68 56.8,146.67 56.8,145.4 57.48,144.72 58.38,144.72 VRAMD2.N11
DQD1_25: length 21.2
  TOP w0.13: VRAMD2.M11 58.4,145.5 58.4,146.12 58.22,146.3 57.5,146.3 57.02,146.78 57.02,148.96 57.6,149.54 57.6,153.98 57.58,154 57.58,154.6 58.63,155.66 59.32,155.66 60.13,156.47 60.13,157.76 60.54,158.16 60.54,162.64 GPU1.BA12
DQD1_26: length 19.4
  TOP w0.13: VRAMD2.M13 60.59,145.29 60.8,145.5 61.38,145.5 61.66,145.78 61.84,145.78 62.15,146.09 62.88,146.82 63.38,147.32 63.38,149.31 62.37,150.32 62.37,153.43 60.95,154.85 60.95,156.23 61.6,156.88 61.6,158.85 61,159.44 GPU1.BC12
DQD1_27: length 21.8
  TOP w0.13: VRAMD2.N13 60.8,144.7 61.38,144.7 61.46,144.78 61.92,144.78 63.4,146.26 63.41,146.26 63.41,146.34 63.99,146.91 63.99,150.44 62.89,151.54 62.89,153.43 61.37,154.95 61.37,156.08 61.95,156.67 61.95,159.03 61.54,159.44 61.54,161.54 GPU1.BB14
DQD1_28: length 24
  TOP w0.13: GPU1.BB15 62.94,161.74 62.94,160.34 63.24,160.04 63.24,155.5 64.41,154.33 64.41,152.78 64.77,152.41 64.77,144.95 63.86,144.04 63.86,144.04 62.3,142.48 62.3,142.39 62.11,142.2 61.6,142.2 61.51,142.3 60.8,142.3 VRAMD2.T13
DQD1_29: length 28.4
  TOP w0.13: VRAMD2.T11 59.2,141.5 61.4,141.5 61.58,141.31 62.11,141.31 63.42,142.62 65.01,144.21 65.01,154.47 63.93,155.55 63.93,158.58 63.68,158.83 63.68,160.12 63.84,160.28 63.84,163.24 GPU1.AY17
DQD1_30: length 26.6
  TOP w0.13: VRAMD2.U13 61.11,140.39 61.57,140.39 61.58,140.38 61.95,140.38 61.97,140.39 62.04,140.39 64.48,142.82 65.26,143.6 65.26,155.17 64.59,155.83 64.59,159.87 64.16,160.3 64.16,162.66 GPU1.BA17
DQD1_31: length 27.1
  TOP w0.13: VRAMD2.U11 59.93,139.97 62.52,139.97 63.52,140.98 65.5,142.96 65.5,160.4 GPU1.BC17
DRAM_RST1: length 107.4
  TOP w0.114: v6(65.2,220.1) 65.2,220.13 VRAMB1.J2 ; R616.1 41.46,208.21 v1(42.01,208.76) ; VRAMA2.J2 v6(93.3,220.1) ; v6(102.1,198.8) VRAMA1.J2 ; VRAMB2.J2 v6(56.3,220.1)
  L6 w0.102: v1(42.01,208.76) 42.01,216.61 45.74,220.34 47.23,220.34 47.84,219.73 53.69,219.73 53.73,219.69 54.07,219.69 54.08,219.71 55.32,219.71 55.33,219.69 55.89,219.69 v6(56.3,220.1) 56.3,220.12 56.69,220.51 64.79,220.51 v6(65.2,220.1) 65.61,219.69 66.63,219.69 66.65,219.71 66.99,219.71 67.07,219.63 68.85,219.63 69.72,220.51 70.53,220.51 71.15,221.13 71.15,221.14 71.39,221.38 72.95,221.38 72.97,221.35 73.42,221.35 74.42,220.34 80.64,220.34 84.4,224.1 87.48,224.1 88.19,223.39 90.12,223.39 90.45,223.06 90.45,221.58 90.45,221.58 90.45,220.8 90.74,220.5 91.08,220.5 91.08,220.5 91.87,220.5 91.88,220.51 92.67,220.51 93.07,220.1 v6(93.3,220.1) 93.9,220.7 95.94,220.7 96.62,220.01 96.62,207.98 92.44,203.8 92.44,202.76 92.81,202.39 95.66,202.39 95.99,202.06 97.28,202.06 97.51,201.83 101.22,201.83 102.51,200.54 102.51,199.21 v6(102.1,198.8)
  BOTTOM w0.114: v1(42.01,208.76) v2(42.01,209.68)
DRAM_RST1_R: length 28.5
  TOP w0.114: GPU1.M14 62.09,189.4 61.64,189.85 v6(61.6,189.85) ; R617.2 43.84,205.91 R618.1 43.87,204.99 v1(43.94,204.93)
  BOTTOM w0.114: v1(43.94,204.93) v2(43.94,203.83) 43.94,203.1 52.1,194.94 54.53,194.94 55.09,194.39 55.09,194.33 56.66,192.76 57.28,192.76 57.63,192.4 57.63,191.54 58.19,190.98 58.34,190.98 59.26,190.07 60.08,190.07 60.13,190.11 60.47,190.11 60.73,189.85 v6(61.6,189.85)
DRAM_RST1_RR: length 4.1
  TOP w0.114: R617.1 42.79,206.78 41.88,206.78 v1(41.78,206.88) 41.78,207.35 R616.2 C737.1
  BOTTOM w0.114: v1(41.78,206.88) 41.78,206.39 v2(41.78,206.21)
DRAM_RST2: length 97.1
  TOP w0.114: VRAMD1.J2 v6(29.9,156.7) ; VRAMD2.J2 v6(51.2,147.9) ; v6(29.9,184.8) VRAMC2.J2 ; VRAMC1.J2 v6(29.9,193.7)
  L6 w0.102: v6(29.9,193.7) 29.9,193.47 29.49,193.07 29.49,185.43 29.9,185.03 v6(29.9,184.8) 29.47,184.8 28.93,185.34 28.93,185.65 28.27,186.31 22.66,186.31 22.1,185.75 22.1,155.37 22.5,154.97 28.12,154.97 28.83,155.68 28.83,156.31 29.22,156.7 v6(29.9,156.7) 29.9,156.52 29.49,156.11 29.49,155.11 32.36,152.25 40.34,152.25 44.37,156.29 v1(47.04,156.29) 47.04,148.41 48.13,147.32 50.62,147.32 v6(51.2,147.9)
  BOTTOM w0.114: R625.1 47.55,157.1 v2(47.7,156.95) 47.7,156.57 47.42,156.29 v1(47.04,156.29)
DRAM_RST2_R: length 25.1
  TOP w0.114: GPU1.AK19 66.85,172.2 v6(66.4,171.75)
  BOTTOM w0.089: 58.13,164.87 59,165.75 59.4,165.75 59.9,166.25 59.9,167.07 60.18,167.35 60.58,167.35 60.8,167.57 60.8,169.92 61.49,170.61 63.17,170.61 63.59,171.03 63.86,171.3 64.27,171.3 64.31,171.35 66,171.35 v6(66.4,171.75)
  BOTTOM w0.114: R626.2 48.96,161.29 R627.1 50.14,161.4 50.14,162.1 50.8,162.76 v2(51.7,162.76) 53.04,162.76 53.19,162.92 53.19,162.92 53.98,163.7 53.98,163.73 54.23,163.98 55.98,163.98 56.31,164.31 56.31,164.54 56.65,164.87 58.13,164.87
DRAM_RST2_RR: length 4.4
  BOTTOM w0.114: R625.2 48.86,158.57 C740.1 48.82,159.18 47.96,159.18 47.7,159.44 v2(47.7,159.77) 47.7,160.15 47.91,160.35 R626.1
EC_3D3V_AUX_S5: length 43.4
  TOP w0.254: R2466.2 123.14,49.66 123.6,50.11 v1(123.65,50.11)
  L4 w0.254: v1(123.65,50.11) 122.86,50.11 121.67,51.31 121.67,58.88 121.36,59.18 116.74,59.18 116.61,59.05 115.72,59.05 v1(115.29,59.49) 115.29,59.54 114.83,59.99 114.83,62.26 114.78,62.31 114.78,62.76 114.83,62.81 114.83,67.31 113.72,68.43 113.72,68.91 109.47,73.15 104.09,73.15 102.13,75.11 v1(102.13,75.21)
  BOTTOM w0.254: R181.1 115.51,59.27 v1(115.29,59.49)
  vias: v3(102.51,80.18)
EC_3D3V_S0: length 81.5
  TOP w0.406: U3.5 113.6,79.59 113.32,79.87 v1(113.11,79.87)
  TOP w0.508: R2457.1 96.79,61.38 97.43,62.03 v1(98.12,62.03)
  L3 w0.508: v1(98.12,62.03) 98.35,62.03 99.44,63.12 99.44,69.64 v1(101.61,71.81)
  BOTTOM w0.305: U2.1 113.64,47.55 113.56,47.62 ; 113.56,47.62 113.16,47.62 112.7,48.08 ; 113.56,47.62 114.53,47.62 115.01,47.14 C292.1
  BOTTOM w0.356: RN15.2 113.58,54.59 ; 112.01,54.89 112.04,54.91 113.26,54.91 112.93,54.58 RN15.1
  BOTTOM w0.406: 116.27,50.34 117.22,50.34 117.53,50.04 ; 116.27,50.34 Q15.2 ; 116.27,50.34 Q15.5 116.27,51.98 115.32,52.93 115.32,52.96 115.3,52.98 115.3,53.09 114.33,54.06 114.33,54.78 113.93,55.18 113.52,55.18 113.26,54.91 113.58,54.59
  BOTTOM w0.508: 105.93,53.99 R232.2 ; 105.93,53.99 106.05,53.99 107.52,52.53 107.52,51.55 108.6,50.47 109.46,50.47 R233.1 109.67,50.26 109.98,50.26 110.47,49.77 110.47,49.04 111.12,48.39 111.71,48.39 111.76,48.44 112.3,48.44 112.66,48.08 112.7,48.08 ; 105.93,53.99 105.87,54.05 ; C292.1 115.47,47.18 116.45,47.18 C291.1 116.48,47.54 117.53,48.59 117.53,50.04 ; 112.01,54.89 111.73,54.6 R231.1 ; v1(113.11,79.87) 112.35,79.12 111.12,79.12 107.77,75.77 107.77,73.65 106.77,72.64 104.32,72.64 103.48,71.81 v1(101.61,71.81)
  BOTTOM w0.762: R2413.2 97.36,62.5 97.83,62.03 v1(98.12,62.03) 98.42,62.03 99.36,61.09 99.36,60.2 98.37,59.21 v5(98.37,57.35) 101.68,54.05 105.87,54.05
EC_AD0: length 152.2
  TOP w0.203: KBC1.97 116.45,61.61 117,62.16 118.27,62.16 v1(118.8,62.69)
  TOP w0.254: v1(85.14,82.88) 85.19,82.93 93.22,82.93 93.93,83.64 94.71,83.64 v3(96.15,82.2) 96.72,81.64 102.64,81.64 104.65,79.63 v1(104.65,78.74) ; v1(118.8,62.69) 119.34,63.23 120.34,63.23 120.8,63.68 120.8,64.83 121.41,65.44 C1009.1 ; v1(19.05,111.89) 19.05,111.34 R2720.2
  L3 w0.254: v1(118.8,62.69) 118.64,62.84 115.98,62.84 111.02,67.79 111.02,69.44 108.2,72.26 104.14,72.26 103.5,72.9 103.5,77.98 104.27,78.74 v1(104.65,78.74)
  L4 w0.254: v1(85.14,82.88) 88.27,86 88.27,96.76 85.17,99.86 85.17,103.17 78.36,109.98 28.63,109.98 27.76,110.85 27.05,110.85 26.95,110.95 20.02,110.95 19.66,111.3 19.63,111.3 v1(19.05,111.89)
EC_AGND: length 34.4
  TOP w0.203: KBC1.103 114.05,62 114.02,62.03 114.02,62.66 114.17,62.81
  TOP w0.508: R178.2 122.71,62.26 C1016.1 123.2,63.36 v1(123.75,63.91) ; C277.2 113.65,64.66 C276.2 114.42,63.14 114.17,62.89 v1(114.17,62.87) 114.17,62.81 ; v1(123.61,65.44) C1009.2 122.7,65.92 122.48,66.14 121.2,66.14 R177.2 120.01,64.95 C1004.1 ; R2670.2 125.79,60.53 C1146.1 126.59,61.04 126.65,61.09 v1(126.79,61.09)
  L3 w0.508: v1(126.79,61.09) 126.11,61.09 123.75,63.45 v1(123.75,63.91) 123.75,65.3 v1(123.61,65.44)
  BOTTOM w0.508: v1(114.17,62.87) 114.17,63.32 114.58,63.73 R2419.2 114.59,64.15 115.67,65.23 118.54,65.23 v2(119.65,66.33) 121.21,67.89 121.87,67.89 123.61,66.16 v1(123.61,65.44)
EC_AUD_RST_N: length 139.5
  TOP w0.114: KBC1.82 118.72,53.74 119.36,53.1 119.85,53.1 v1(120.09,52.86) ; v1(188.59,69.29) 186.13,69.29 v3(181.36,64.52) 180.14,63.3 v1(180.14,62.94) ; v1(214.55,38.89) 214.55,38.66 214,38.11 214,37.49 213.96,37.46 213.96,35.77 214.68,35.05 PD2.K
  L4 w0.114: v1(188.59,69.29) 188.59,67.46 189.84,66.22 189.84,42.75 190.88,41.71 193.62,41.71 194,41.32 196.88,41.32 199.03,39.17 199.1,39.17 199.85,38.42 204.45,38.42 205.35,37.53 206.35,37.53 206.62,37.25 211.52,37.25 213.16,38.89 v1(214.55,38.89)
  L6 w0.102: v1(180.14,62.94) 176.89,62.94 174.85,64.97 171.42,64.97 170.99,64.54 167.46,64.54 167.43,64.57 154.41,64.57 152.02,62.18 145.16,62.18 144.35,62.99 140.34,62.99 137.41,60.07 134.65,60.07 132.89,58.32 132.05,58.32 130.38,56.64 128.52,56.64 127.56,55.68 125.55,55.68 122.73,52.86 v1(120.09,52.86)
EC_AVCC: length 21.1
  TOP w0.114: KBC1.102 114.45,62.28 114.8,62.63 114.86,62.78 115.3,63.23 C276.1 115.3,64.32 115.18,64.45 C277.1 115.18,65.77 115.19,65.79 v3(115.19,66.11) 115.81,66.11 R183.1 117.96,65.09 R171.2 118.17,64.96 118.72,65.52 119.78,65.52 120.99,66.73 122.35,66.73 123.42,67.79 124.05,67.79 124.41,67.43 124.41,64.97 123.84,64.39 122.7,64.39 R172.1
EC_BEEP_GPIO_EC: length 5.5
  TOP w0.114: v1(108.05,58.39) 108,58.45 107.8,58.45 107.49,58.75 107.49,59.59 108.05,60.14 KBC1.118
  BOTTOM w0.114: R2461.2 107.16,59.35 107.16,58.16 v2(107.3,58.02) 107.68,58.02 v1(108.05,58.39)
EC_CLEAR_RTC: length 13.8
  TOP w0.114: Q37.G 128.56,46.29 R464.1 127.89,46.34 v1(127.89,47.17) ; v1(119.3,46.94) KBC1.65
  L3 w0.114: v1(119.3,46.94) 119.46,46.79 124.62,46.79 125.16,47.33 127.73,47.33 v1(127.89,47.17)
  BOTTOM w0.114: v5(127.38,46.48) 127.89,46.99 v1(127.89,47.17)
EC_DEBUG: length 2.3
  TOP w0.114: TP68.1 110.85,63.18 KBC1.111
EC_I2C_CLK: length 257
  TOP w0.114: v1(203.15,76.89) 201.66,78.38 184.14,78.38 183.54,77.77 v3(183.51,77.77) 183.51,77.75 v1(178.99,73.23) ; R2512.1 219.64,27.34 220.47,27.34 221.14,26.67 v1(221.41,26.67) ; v1(94.49,57.73) 94.39,57.84 93.93,57.84 93.87,57.89 RN45.1 ; v1(107.09,57) 107.06,57.02 107.06,58.22 107.19,58.34 107.19,58.67 107.26,58.75 107.26,59.74 107.65,60.12 KBC1.119 107.65,61.85 109.18,63.38 109.73,63.38 112.14,65.79 112.14,68.35 114.98,71.18 116.81,71.18 117.63,72 117.63,72.67 116.87,73.43 U2505.6 115.42,73.43 115.19,73.66 115.19,76.45 v1(114.99,76.66) ; R2516.1 202.73,28.16 203.28,28.7 203.28,31.47 v1(203.3,31.5)
  L3 w0.114: v1(203.15,76.89) 201.92,76.89 199.4,74.37 199.4,73.29 198.39,72.28 198.39,67.45 196.63,65.7 196.63,63.59 195.84,62.8 195.47,62.8 195.14,62.46 195.14,61.69 195.14,61.07 189.59,55.52 189.59,43.46 189.59,42.64 190.72,41.51 192.46,41.51 194.4,39.57 194.4,37.76 197.26,34.9 197.26,34.29 197.84,33.71 197.84,31.82 198.8,30.86 202.67,30.86 v1(203.3,31.5) ; v1(107.09,57) 106.42,56.33 104.93,56.33 104.67,56.59 101.57,56.59 101.45,56.47 99.87,56.47 98.96,57.38 94.84,57.38 v1(94.49,57.73)
  L4 w0.114: v1(221.41,26.67) 221.41,26.06 220.8,25.45 220.8,24.43 218.21,21.84 216.46,21.84 215.39,20.78 210.24,20.78 209.68,21.34 201.68,21.34 199.21,23.8 199.21,28.75 201.75,31.29 203.1,31.29 v1(203.3,31.5)
  L6 w0.102: v1(178.99,73.23) 177.65,71.88 172.29,71.88 170.52,73.66 162.46,73.66 161.9,73.1 131.85,73.1 128.89,73.1 123.45,67.67 123.17,67.67 122.13,66.62 120.98,66.62 115.57,61.21 114.79,61.21 113.72,60.15 111.02,60.15 109.7,58.83 109.27,58.83 108.31,57.86 107.95,57.86 v1(107.09,57)
  BOTTOM w0.114: v1(114.99,76.66) 115.24,76.4 115.24,75.13 114.97,74.86 U2506.6
EC_I2C_DATA: length 254.5
  TOP w0.114: v1(178.03,73.28) 178.03,73.56 183.19,78.72 201.8,78.72 201.81,78.71 202.51,78.71 v3(203.05,78.18) v1(204.27,76.96) ; RN45.2 94.08,58.54 94.25,58.37 95.1,58.37 v1(95.35,58.12) ; v1(220.29,25.15) 219.35,26.09 R2511.1 ; R2515.1 203.23,27.34 203.23,28.14 203.63,28.55 203.63,30.71 204.22,31.29 v1(204.22,31.52) ; v1(106.35,57.86) 106.35,58.01 106.83,58.5 106.83,59.39 106.91,59.46 106.91,59.72 107.25,60.05 KBC1.120 107.25,61.93 109.04,63.72 109.57,63.72 111.8,65.95 111.8,68.49 114.83,71.53 116.14,71.53 116.32,71.71 U2505.5 115.42,72.16 114.68,72.9 114.68,74.4 114.12,74.96 v1(114.12,77.09)
  L3 w0.114: v1(106.35,57.86) 106.1,57.61 101.98,57.61 101.26,56.89 100.29,56.89 99.16,58.01 95.45,58.01 v1(95.35,58.12) ; v1(204.27,76.96) 203.5,76.2 201.83,76.2 199.82,74.19 199.82,73.03 198.81,72.01 198.81,67.28 197.05,65.52 197.05,62.45 195.56,60.96 195.56,60.9 190.01,55.35 190.01,43.29 191.37,41.93 192.63,41.93 194.82,39.74 194.82,39.08 194.82,37.93 198.32,34.43 198.32,31.93 198.91,31.34 202.29,31.34 203.07,32.13 203.61,32.13 v1(204.22,31.52)
  L4 w0.114: v1(204.22,31.52) 204.22,30.86 203.63,30.28 201.35,30.28 199.64,28.57 199.64,24 201.8,21.84 209.8,21.84 210.44,21.21 215.14,21.21 216.28,22.35 218.06,22.35 220.29,24.59 v1(220.29,25.15)
  L6 w0.102: v1(178.03,73.28) 178,73.3 171.45,73.3 170.68,74.07 162.29,74.07 161.73,73.51 132.01,73.51 128.72,73.51 123.29,68.07 121.79,68.07 121.13,67.41 121.13,67.35 115.4,61.62 114.62,61.62 113.65,60.66 109.88,60.66 109.04,59.82 107.63,59.82 106.37,58.57 106.37,57.89 v1(106.35,57.86)
  BOTTOM w0.114: U2506.5 114.35,76.86 v1(114.12,77.09)
EC_PECI: length 2.9
  TOP w0.114: KBC1.13 100.4,54.54 TP67.1
EC_SCI#: length 178.2
  TOP w0.114: v1(124.74,126.11) 123.37,126.11 v3(121.44,124.18) 121.26,124 v1(121.26,123.01) ; v1(129.08,169.98) 128.82,170.24 RN2407.3 ; v1(93.34,50.77) 93.4,50.77 94.08,50.09 94.68,50.09 R2433.2 ; v6(154.45,180.54) 154.99,180 CPU1.AR3
  L3 w0.114: v1(93.34,50.77) 92.02,52.1 92.02,56.77 94.31,59.05 94.31,67.67 96.55,69.9 96.55,73.79 100.04,77.28 100.04,81.09 101.17,82.22 101.17,84.85 102.02,85.7 102.47,86.15 102.77,86.46 103.67,86.46 103.94,86.73 103.94,87.62 107.11,90.79 107.72,91.4 107.8,91.48 107.8,93.32 117.54,103.06 117.54,105.83 120.15,108.44 120.15,114.26 121.04,115.14 121.04,122.79 v1(121.26,123.01)
  L4 w0.114: v1(144.5,177.88) 144.83,177.55 144.83,176.38 141.53,173.08 135.28,173.08 135.25,173.05 134.8,173.05 131.72,169.98 v1(129.08,169.98) 128.7,169.6 128.7,165.63 127.61,164.54 127.61,147.77 127.03,147.19 127.03,136.7 124.66,134.34 124.66,126.19 v1(124.74,126.11)
  BOTTOM w0.114: v6(154.45,180.54) 153.96,181.04 153.96,181.66 153.7,181.92 153.34,181.92 153.18,181.76 151.89,181.76 151.74,181.91 150.81,181.91 149.69,183.03 147.35,183.03 146.43,182.12 145.59,182.12 144.25,180.77 144.25,178.33 144.5,178.08 v1(144.5,177.88)
EC_SENSE_BT1: length 13.1
  TOP w0.114: KBC1.96 118.73,59.34 118.85,59.46 118.85,60.4 v1(118.37,60.88) ; C1146.2 124.4,60.53 R2670.1 R2669.2 123.8,58.88 v1(123.46,58.53)
  L4 w0.114: v1(123.46,58.53) 121.54,60.45 118.73,60.45 118.39,60.79 118.39,60.86 v1(118.37,60.88)
  BOTTOM w0.114: v2(123.85,59.43) 123.46,59.04 v1(123.46,58.53)
