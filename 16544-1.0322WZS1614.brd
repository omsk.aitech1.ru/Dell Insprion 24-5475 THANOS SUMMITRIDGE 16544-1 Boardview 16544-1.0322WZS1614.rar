# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
L_AD2: length 162.5
  TOP w0.114: KBC1.128 104.03,60.91 103.96,60.91 103.5,61.37 v1(103.41,61.37) ; CPU1.AT21 v6(153.5,162.5)
  L6 w0.102: v6(153.5,162.5) 152.9,161.9 151.03,161.9 149.61,160.48 145.57,160.48 142.6,157.51 141.67,157.51 140.37,156.21 139.52,156.21 136.45,153.14 136.45,142.24 138.84,139.85 138.84,130.96 138.84,130.29 142.34,126.78 142.34,113.05 143.76,111.63 143.76,93.73 146.18,91.31 146.18,88.9 148.77,86.31 148.79,86.31 151.89,83.21 151.89,83.19 152.22,82.85 152.22,82.82 152.49,82.55 153.82,82.55 v1(153.92,82.65)
  BOTTOM w0.114: v1(103.41,61.37) 103.63,61.37 104.27,62 109.12,62 113.97,66.85 113.97,68.45 116.64,71.12 116.95,71.12 LPC1.9 120.33,74.33 121.26,75.26 124.69,75.26 125.32,75.9 147.14,75.9 v5(147.27,75.77) 148.64,75.77 153.92,81.06 v1(153.92,82.65)
L_AD3: length 170.5
  TOP w0.114: CPU1.AT20 v6(154.5,162.5) ; KBC1.1 101.87,59.34 101.6,59.61 101.6,60.33 102.12,60.85 v1(102.12,60.95)
  L6 w0.102: v6(154.5,162.5) 154.09,162.91 149.73,162.91 147.95,161.12 145.63,161.12 142.42,157.91 141.5,157.91 140.23,156.64 139.38,156.64 134.59,151.86 134.59,143.43 138.43,139.6 138.43,131.13 138.43,130.12 141.94,126.62 141.94,112.88 143.36,111.46 143.36,93.56 145.14,91.78 145.14,89.37 151.82,82.69 151.82,82.65 152.32,82.14 153.92,82.14 v1(154.56,81.51)
  BOTTOM w0.114: v1(154.56,81.51) 154.56,81.21 148.08,74.73 127.28,74.73 125.96,73.41 121.24,73.41 LPC1.11 118.49,70.66 116.69,70.66 114.33,68.3 114.33,66.7 109.26,61.63 105.42,61.63 103.89,60.1 v5(103.53,60.1) 102.54,60.1 102.21,60.43 102.21,60.87 v1(102.12,60.95)
L_FRAME_N: length 170.9
  TOP w0.114: v1(145.03,162.66) 145.92,162.66 148.11,164.85 150.85,164.85 CPU1.AW18 ; v1(104.65,59.21) 104.52,59.33 104.14,59.33 103.35,58.54 KBC1.3
  L4 w0.114: v1(155.35,81.51) 154.69,82.17 148.93,82.17 144.34,86.75 143.78,86.75 140.74,89.79 140.74,95.73 142.51,97.5 142.51,122.86 142.09,123.27 142.09,141.91 139.12,144.88 139.12,145.51 139,145.63 139,148.6 139.12,148.73 139.12,152.78 139.93,153.59 139.93,156.31 141.38,157.76 141.38,158.9 145.03,162.56 v1(145.03,162.66)
  BOTTOM w0.114: R124.1 145.2,162.5 v1(145.03,162.66) ; v1(155.35,81.51) 148.21,74.37 127.68,74.37 126.23,72.92 124.82,72.92 123.22,71.32 123.22,69.88 122.56,69.22 121.27,69.22 LPC1.13 119.48,70.33 118.62,69.47 116,69.47 114.68,68.15 114.68,66.55 109.42,61.29 106.12,61.29 v2(105.7,60.87) 104.65,59.82 v1(104.65,59.21)
LAN_DISABLE_N: length 257.6
  TOP w0.114: CPU1.AT5 v1(154.5,178.56) ; v1(134.75,6.2) 134.75,6.66 134.75,6.66 LAUOC1.24
  L3 w0.114: v1(140.35,158.66) 140.67,158.34 140.67,157.07 138.43,154.82 138.43,154.82 137.98,154.37 137.98,146.2 139.62,144.55 139.62,121.98 139.5,121.86 139.5,116.14 139.81,115.83 139.81,112.03 139.58,111.8 139.58,111.06 139.81,110.83 139.81,108.77 140.03,108.55 140.03,107.49 140.02,107.48 140.02,107.1 140.03,107.09 140.03,106.43 139.97,106.37 139.97,105.92 140.03,105.87 140.03,105.51 139.74,105.22 139.74,104.84 140.03,104.55 140.03,103.58 140.36,103.25 140.36,98.43 141.34,97.44 141.34,97.11 141.34,95.36 141.64,95.06 141.64,89.57 142.21,89 142.21,87.43 144.4,85.24 150.44,85.24 151.76,83.92 154.18,83.92 154.19,83.91 154.96,83.91 155.29,84.24 161.51,84.24 162.46,83.28 165.36,83.28 165.36,83.28 165.97,83.28 166.52,82.73 166.52,82.7 168.12,81.1 174.33,81.1 175.68,79.76 175.68,73.87 177.29,72.26 177.29,59.08 179.86,56.52 182.27,56.52 183.59,55.19 183.59,40.94 183.77,40.77 183.77,31.37 183.59,31.19 183.59,29.05 175.92,21.37 165.82,21.37 v1(164.34,19.89)
  L4 w0.114: v1(154.5,178.56) 154.3,178.56 153.54,177.8 153.16,177.8 152.53,177.16 152.27,177.16 151.76,176.66 151.76,176.02 150.34,174.6 148.06,174.6 146.69,173.23 146.69,171.32 144.78,169.42 144.78,163.91 140.59,159.72 140.59,158.9 v1(140.35,158.66) ; v1(164.34,19.89) 164.16,19.71 161.6,19.71 159.51,17.62 159.51,17.6 154.43,12.52 151.3,12.52 150.28,11.51 143.94,11.51 141.33,8.89 136.48,8.89 134.72,7.13 134.72,6.23 v1(134.75,6.2)
  BOTTOM w0.114: R43.1 139.81,158.99 140.14,158.66 v1(140.35,158.66) ; v2(135.33,6.78) v1(134.75,6.2)
LPC_CLK0: length 98.8
  TOP w0.114: R454.2 122.49,86.8 122.17,87.12 121.29,87.12 v1(121.29,87.12) ; v1(133.76,155.45) 133.9,155.59 134.8,155.59 R92.1
  L4 w0.114: v1(137.87,90.04) 137.87,90.27 136.17,91.97 136.17,95.99 136.61,96.43 137.63,96.43 138.11,96.91 138.11,100.58 137.68,101.01 137.68,102.45 135.03,105.11 132.57,105.11 130.94,106.74 130.94,109.89 130.61,110.21 130.61,111.33 130.53,111.41 130.53,120.32 131,120.79 131,130.14 133.53,132.66 133.53,151.3 134.56,152.33 134.56,154.65 133.77,155.45 v1(133.76,155.45)
  BOTTOM w0.114: v1(121.29,87.12) 121.41,87.25 v5(121.41,90.55) 122.39,91.53 128.57,91.53 129.93,90.17 133.76,90.17 133.99,89.94 137.77,89.94 v1(137.87,90.04)
LPC_CLK1: length 130.5
  TOP w0.114: v1(100.58,60.63) 100.58,60.23 100.97,59.85 100.97,59.77 101.55,59.18 101.55,59.17 101.78,58.94 KBC1.2 ; R93.1 137.14,154.69 v3(137.13,154.7) 137.13,154.7 136.35,153.92 135.45,153.92 134.43,154.94 132.84,154.94 v1(132.79,154.99)
  L3 w0.114: v1(100.58,60.63) 100.04,60.09 98.19,60.09 97.12,61.15 96.02,61.15 v1(95.81,61.37)
  L4 w0.114: v1(132.79,154.99) 132.08,154.28 132.08,133.63 129.55,131.11 129.55,130.46 v1(129.11,130.02)
  L6 w0.102: v1(129.11,130.02) 127.86,128.77 127.86,128.31 126.82,127.26 126.82,119.41 124.13,116.72 124.13,101.52 119.63,97.03 119.63,94.61 116.46,91.44 108.83,91.44 106.75,89.36 105.21,89.36 97.87,82.02 97.62,82.02 95.1,79.5 95.1,76.48 96.37,75.21 96.37,63.7 95.81,63.14 v1(95.81,61.37)
LPC_CLK_D: length 4.9
  TOP w0.114: LPC1.1 120.16,85.68 v3(120.43,85.95) 120.46,85.98 R454.1
LPC_PME_N_R: length 14.8
  TOP w0.114: R2435.2 121.38,56.81 v1(120.94,57.24) ; v1(111.05,58.83) 111.12,58.83 111.69,59.39 111.69,59.94 111.65,59.98 KBC1.109
  L3 w0.114: v1(111.05,58.83) 111.15,58.83 111.28,58.7 112.42,58.7 112.45,58.67 113.36,58.67 113.8,58.24 119.94,58.24 v1(120.94,57.24)
  BOTTOM w0.114: v1(111.05,58.83) 110.76,59.11 v2(110.29,59.11)
LPC_SMI_L: length 158.2
  TOP w0.114: CPU1.AW17 150.61,165.61 149.73,165.61 149.48,165.35 147.55,165.35 146.1,163.91 144.63,163.91 141.74,161.02 141.65,161.02 141.26,160.63 139.27,160.63 135.82,157.18 135.45,157.18 135.15,156.88 v1(135.15,156.13) ; v1(166.04,82.52) 166.57,81.99 v3(166.57,75.55) 166.57,68.88 160.68,62.99 157.51,62.99 156.03,61.52 156.03,57.23 155.44,56.63 155.44,54.56 PCH1.B7
  L3 w0.114: v1(139.32,99.36) 139.94,98.75 139.94,98.26 140.93,97.27 140.93,95.19 141.22,94.89 141.22,89.38 141.78,88.82 141.78,87.25 144.22,84.81 150.27,84.81 151.59,83.49 155.13,83.49 155.46,83.82 161.33,83.82 162.29,82.87 165.19,82.87 165.19,82.86 165.7,82.86 v1(166.04,82.52)
  L4 w0.114: v1(139.32,99.36) 139.32,100.39 138.66,101.06 138.66,101.44 138.42,101.68 138.42,130.21 138.9,130.7 138.9,139.08 134.87,143.11 134.87,151.61 135.29,152.03 135.29,155.93 135.15,156.07 v1(135.15,156.13)
  BOTTOM w0.114: v1(135.15,156.13) 134.77,155.75 134.77,154.48 135.28,153.97 R34.1
M2_PEDET: length 7.9
  TOP w0.114: R2745.2 111.52,103.5 R440.2 112.29,104.28 v3(112.81,104.28) 112.95,104.28 R442.2 R2601.2 114.94,103 114.25,102.31 SSDC1.69
M_A_A0: length 50.5
  TOP w0.178: CPU1.AA32 v6(169.5,150.5) ; v6(178.19,107.75) 179.04,106.9 DIMM1.144
  L3 w0.191: v6(178.19,107.75) 179.55,109.11 179.55,116.63 170.86,125.32 170.86,138.48 171.28,138.91 171.28,146.42 170.64,147.06 170.33,147.06 170,147.39 170,150 v6(169.5,150.5)
M_A_A1: length 48.2
  TOP w0.178: DIMM1.133 182.37,114.22 183.01,113.58 183.01,113.4 183.56,112.85 v6(183.58,112.85) ; v6(173.46,151.56) 174,151.03 CPU1.T32
  L3 w0.089: v6(173.46,151.56) 173.96,151.56 174.12,151.41 174.12,148.59 173.62,148.1 173.62,144.46
  L3 w0.191: v6(183.58,112.85) 183.88,113.16 183.88,113.51 183.69,113.7 183.64,113.7 183.45,113.89 183.45,114.27 183.64,114.47 183.69,114.47 183.88,114.66 183.88,115.04 183.69,115.23 183.64,115.23 183.45,115.42 183.45,115.8 183.64,115.99 183.69,115.99 183.88,116.18 183.88,117.87 176.38,125.37 176.38,133.63 174.7,135.31 174.7,139.28 174.46,139.51 174.46,143.62 173.62,144.46
M_A_A2: length 48.2
  TOP w0.178: v6(183.6,109.28) 183.27,109.28 183.02,109.02 183.02,108.22 182.62,107.83 DIMM1.132 ; CPU1.T35 174.07,148 v6(174.52,147.55)
  L3 w0.089: 174.77,146.1 174.77,147.3 v6(174.52,147.55)
  L3 w0.191: 174.77,146.1 174.77,145.32 176.11,143.98 176.11,139.23 176.35,138.99 176.35,135.61 177.71,134.25 177.71,125.92 185.21,118.42 185.21,110.61 184.94,110.34 184.94,110.07 185.16,109.85 185.16,109.58 184.89,109.31 184.62,109.31 184.4,109.53 184.13,109.53 183.87,109.28 v6(183.6,109.28)
M_A_A3: length 51.5
  TOP w0.178: CPU1.T31 v6(173.5,152.5) ; v6(183.7,111.42) 183.76,111.42 184.15,111.81 184.15,112.98 183.44,113.69 183.44,113.76 182.87,114.33 DIMM1.131
  L3 w0.089: 174.19,145.79 173.93,146.05 173.93,148.1 174.31,148.48 174.31,151.69 v6(173.5,152.5)
  L3 w0.191: v6(183.7,111.42) 184.1,111.42 184.32,111.64 184.32,118.05 176.82,125.55 176.82,133.82 175.44,135.21 175.44,143.76 174.16,145.03 174.16,145.77 174.19,145.79
M_A_A4: length 53.3
  TOP w0.178: CPU1.R30 v6(175.5,153.5) ; v6(183.63,109.99) 184.1,109.53 184.1,108.37 183.62,107.9 DIMM1.128
  L3 w0.089: 174.46,145.19 174.46,147.03 174.12,147.37 174.12,148.01 174.61,148.5 174.61,152.61 v6(175.5,153.5)
  L3 w0.191: v6(183.63,109.99) 183.95,109.99 184.77,110.81 184.77,118.24 177.27,125.74 177.27,134.06 175.91,135.42 175.91,139.02 175.77,139.16 175.77,143.88 174.46,145.19
M_A_A5: length 50.5
  TOP w0.178: v6(186.03,110.4) 185.89,110.4 185.31,109.82 185.31,108.97 184.13,107.79 DIMM1.126 ; CPU1.R33 v6(175.5,150.5)
  L3 w0.089: 176.31,146.65 175.91,147.05 175.91,149.65 175.5,150.06 v6(175.5,150.5)
  L3 w0.191: 176.31,146.65 176.31,145.28 177.79,143.8 177.79,139.7 177.86,139.63 177.86,135.98 179.04,134.8 179.04,126.47 186.25,119.27 186.25,119.27 186.54,118.97 186.54,114.78 187.22,114.1 187.22,111.59 v6(186.03,110.4)
M_A_A6: length 51.3
  TOP w0.178: DIMM1.127 183.87,113.87 184.9,112.84 184.9,112.23 v6(186.02,111.11) ; CPU1.R32 v6(175.5,151.5)
  L3 w0.089: 175.99,146.62 175.59,147.02 175.59,147.49 175.08,147.99 175.08,151.08 v6(175.5,151.5)
  L3 w0.191: v6(186.02,111.11) 186.78,111.87 186.78,113.92 186.1,114.59 186.1,118.79 178.6,126.29 178.6,134.62 177.42,135.8 177.42,140.52 177.48,140.58 177.48,143.65 175.99,145.14 175.99,146.62
M_A_A7: length 48.9
  TOP w0.178: v6(176.47,148.49) 176,148.97 CPU1.P34 ; DIMM1.122 185.13,108.11 185.12,108.11 v6(186,108.98)
  L3 w0.089: 176.63,146.72 176.13,147.22 176.13,148.14 v6(176.47,148.49)
  L3 w0.191: v6(186,108.98) 186.03,108.98 187.67,110.61 187.67,114.28 186.99,114.96 186.99,116.13 187.67,116.81 187.67,118.48 179.5,126.64 179.5,134.97 178.34,136.13 178.34,140.11 178.13,140.32 178.13,143.97 176.63,145.47 176.63,146.72
M_A_A8: length 51
  TOP w0.178: CPU1.P30 v6(176.5,153.5) ; v6(186.16,112.56) 186.13,112.53 185.79,112.53 185.34,112.98 185.34,113.02 184.37,113.98 DIMM1.125
  L3 w0.089: 175.51,145.91 174.98,146.44 174.98,147.81 174.89,147.9 174.89,152.46 175.44,153.01 176.01,153.01 v6(176.5,153.5)
  L3 w0.191: v6(186.16,112.56) 186.33,112.73 186.33,113.73 185.65,114.41 185.65,118.61 178.16,126.11 178.16,134.43 176.8,135.79 176.8,138.96 176.47,139.28 176.47,144.15 175.51,145.12 175.51,145.91
M_A_A9: length 54
  TOP w0.178: CPU1.P31 v6(176.5,152.5) ; DIMM1.121 185.37,114.35 186.64,113.08 186.64,112.98 186.74,112.87 186.74,111.33 186.97,111.1 v6(188.51,111.1)
  L3 w0.089: 178.4,146.72 177.44,147.68 177.44,148.42 176.1,149.76 176.1,151.67 176.5,152.07 v6(176.5,152.5)
  L3 w0.191: v6(188.51,111.1) 189.01,111.6 189.01,118.39 180.42,126.99 180.42,135.33 179.45,136.3 179.45,143.72 178.4,144.77 178.4,146.72
M_A_A10: length 47.9
  TOP w0.178: v6(169.54,147.48) 169.06,147 CPU1.AA36 ; DIMM1.146 177.12,107.88 177.73,108.49 v6(178.11,108.49)
  L3 w0.191: v6(169.54,147.48) 169.66,147.36 169.66,146.41 170.43,145.64 170.72,145.64 170.91,145.44 170.91,145.06 170.72,144.87 170.43,144.87 170.24,144.68 170.24,144.13 170.42,143.96 170.73,143.96 170.99,143.69 170.99,139.13 170.41,138.56 170.41,125.13 179.11,116.44 179.11,109.43 178.16,108.49 v6(178.11,108.49)
M_A_A11: length 51.6
  TOP w0.178: CPU1.P33 v6(176.5,150.5) ; v6(188.51,110.36) 188.48,110.33 187.92,110.33 186.53,108.94 186.53,108.82 185.62,107.91 DIMM1.120
  L3 w0.089: v6(176.5,150.5) 177.05,149.95 177.05,149.37 177.8,148.62 177.8,147.77 178.72,146.85
  L3 w0.191: 178.72,146.85 178.72,144.91 179.9,143.73 179.9,136.48 180.86,135.52 180.86,127.17 189.46,118.58 189.46,111.31 v6(188.51,110.36)
M_A_A12: length 48.3
  TOP w0.178: CPU1.N35 176.97,148 v6(176.53,147.55) ; DIMM1.119 185.87,114.35 187.22,113.01 187.22,112.44 187.42,112.23 188.2,112.23 v6(188.51,112.55)
  L3 w0.191: v6(188.51,112.55) 188.56,112.59 188.56,113.35 188.37,113.54 188.3,113.54 188.11,113.73 188.11,114.12 188.3,114.31 188.37,114.31 188.56,114.5 188.56,114.94 188.37,115.13 187.67,115.13 187.48,115.32 187.48,115.7 187.67,115.89 188.37,115.89 188.56,116.08 188.56,116.53 188.37,116.72 188.3,116.72 188.11,116.91 188.11,117.29 188.3,117.48 188.37,117.48 188.56,117.67 188.56,118.22 179.95,126.83 179.95,135.15 178.79,136.32 178.79,141.18 178.48,141.49 178.48,144.17 178,144.65 178,146.63 177.08,147.55 v6(176.53,147.55)
M_A_A13: length 51.4
  TOP w0.178: v6(172.22,109.23) 173.28,109.23 174.12,108.38 DIMM1.158 ; CPU1.AE32 165.5,151.5 v6(165.5,151.52)
  L3 w0.089: v6(165.5,151.52) 165.88,151.14 165.88,150.28 165.64,150.04 165.53,150.04 165.12,149.63 165.12,147.88 165.1,147.85 165.1,146.12 165.22,146.01 165.22,145.23
  L3 w0.191: v6(172.22,109.23) 172.22,109.28 173.61,110.67 173.61,115.46 172.8,116.27 172.8,117.72 166.84,123.68 166.84,137.47 165.22,139.1 165.22,145.23
M_A_ACT_N: length 49.9
  TOP w0.178: v6(190.89,110.01) 190.37,110.01 188.8,108.44 187.81,108.44 187.13,107.76 DIMM1.114 ; CPU1.M35 v6(178.5,148.5)
  L3 w0.089: v6(178.5,148.5) 178.5,147.84 179.32,147.03
  L3 w0.191: v6(190.89,110.01) 190.39,110.51 190.39,118.94 181.78,127.55 181.78,135.9 181.46,136.22 181.46,143.49 179.32,145.63 179.32,147.03
M_A_BG0: length 54.3
  TOP w0.178: CPU1.N31 v6(177.5,152.5) ; DIMM1.115 186.87,114.1 187.9,113.08 188.9,113.08 190.49,111.49 190.84,111.49 v6(190.89,111.44)
  L3 w0.191: v6(190.89,111.44) 191.84,112.39 191.84,119.37 183.11,128.1 183.11,136.45 182.83,136.73 182.83,140.87 182.54,141.17 182.54,143.74 180.72,145.56 180.72,148.75 178.46,151.01 178.35,151.01 178.04,151.33 178.04,151.96 v6(177.5,152.5)
M_A_BG1: length 51.4
  TOP w0.178: DIMM1.113 187.37,114.09 187.95,113.51 189.09,113.51 190.45,112.15 v6(190.89,112.15) ; CPU1.N32 v6(177.5,151.5)
  L3 w0.191: v6(190.89,112.15) 191.39,112.65 191.39,119.19 182.67,127.92 182.67,136.26 182.39,136.54 182.39,140.91 182.24,141.05 182.24,141.21 182.25,143.53 180.4,145.38 180.4,148.65 178.36,150.69 178.26,150.69 177.62,151.33 177.62,151.38 v6(177.5,151.5)
M_A_BS0: length 48
  TOP w0.178: CPU1.AA35 168.48,148.52 v6(168.47,148.52) ; DIMM1.150 176.12,108.17 176.06,108.23 176.06,108.64 176.57,109.15 v6(176.58,109.15)
  L3 w0.191: v6(176.58,109.15) 176.79,109.15 177.09,109.45 177.09,109.61 177.28,109.8 177.41,109.8 177.6,109.99 177.6,110.37 177.41,110.56 177.28,110.56 177.09,110.75 177.09,115.95 168.62,124.42 168.62,143.37 167.56,144.43 167.56,147.85 168.23,148.52 v6(168.47,148.52)
M_A_BS1: length 48.4
  TOP w0.178: CPU1.AA33 v6(168.5,149.5) ; v6(178.16,112.43) 178.16,113.39 177.37,114.17 DIMM1.145
  L3 w0.089: v6(168.5,149.5) 168.1,149.9 168.1,150.67 168.33,150.9 168.67,150.9 169.06,150.5 169.06,148.11 168.76,147.8
  L3 w0.191: 168.76,147.8 168.76,146.9 168.96,146.69 168.96,143.95 169.51,143.41 169.51,124.79 178.16,116.13 v6(178.16,112.43)
M_A_CAS#: length 50.7
  TOP w0.178: CPU1.AD32 166,150.97 v6(165.48,150.45) ; v6(172.16,109.96) 173.22,109.96 174.62,108.56 DIMM1.156
  L3 w0.089: v6(165.48,150.45) 164.92,149.89 164.92,147.96 164.85,147.9 164.85,147.11 164.79,147.05
  L3 w0.191: 164.79,147.05 164.79,143.91 164.13,143.25 164.13,138.86 166.39,136.59 166.39,123.5 172.35,117.54 172.35,116.06 173.16,115.25 173.16,110.93 172.19,109.96 v6(172.16,109.96)
M_A_CKE0: length 48
  TOP w0.178: CPU1.M32 178,150.98 v6(177.52,150.5) ; v6(190.89,113.58) 190.49,113.17 190.04,113.17 189.27,113.94 188.67,113.94 188.37,114.24 DIMM1.109
  L3 w0.191: v6(190.89,113.58) 190.89,119.06 182.22,127.73 182.22,136.08 181.9,136.4 181.9,143.46 180.08,145.28 180.08,145.86 179.89,146.05 179.81,146.05 179.62,146.24 179.62,146.62 179.81,146.81 179.89,146.81 180.08,147 180.08,148.55 178.27,150.37 177.64,150.37 v6(177.52,150.5)
M_A_CKE1: length 54.9
  TOP w0.178: CPU1.M30 v6(178.5,152.5) ; DIMM1.110 188.13,107.76 188.37,108.01 189.19,108.01 189.72,108.54 v6(190.89,108.54)
  L3 w0.191: v6(190.89,108.54) 191.54,109.19 191.54,111.46 192.28,112.2 192.28,119.56 183.55,128.29 183.55,136.63 183.27,136.91 183.27,141.03 182.83,141.47 182.83,143.87 182.01,144.68 182.01,148.03 179.01,151.03 179.01,151.99 v6(178.5,152.5)
M_A_CLK0: length 54.2
  TOP w0.178: DIMM1.137 181.37,114.16 181.19,113.98 181.19,112.5 181.5,112.2 181.72,112.2 v6(182.19,112.66) ; v6(173.5,149.5) CPU1.T34
  L3 w0.089: v6(173.5,149.5) 173.35,149.5 173.01,149.16 173.01,145.14 173.06,145.08 173.06,145.06
  L3 w0.178: 173.06,145.06 173.06,138.75 173.38,138.43 173.38,133.78 173.56,133.6 174.51,133.6 174.81,133.29 174.81,132.41 174.51,132.1 173.56,132.1 173.38,131.92 173.38,131.39 173.56,131.21 174.69,131.21 175.05,130.85 175.05,130.07 174.69,129.71 173.56,129.71 173.38,129.53 173.38,129 173.56,128.82 174.69,128.82 175.05,128.47 175.05,127.68 174.69,127.32 173.56,127.32 173.38,127.15 173.38,126.18 174.75,124.81 174.91,124.81 175.29,124.44 175.29,124.27 175.67,123.9 175.83,123.9 176.21,123.52 176.21,123.36 176.58,122.98 176.75,122.98 177.12,122.6 177.12,122.44 178.32,121.25 178.48,121.25 178.86,120.87 178.86,120.71 179.23,120.33 179.4,120.33 179.77,119.95 179.77,119.79 180.15,119.41 180.31,119.41 180.69,119.04 180.69,118.87 181.07,118.5 181.23,118.5 181.61,118.12 181.61,117.96 181.98,117.58 181.98,115.87 182.1,115.76 182.1,115.22 181.98,115.11 181.98,114.58 182.1,114.46 182.1,113.93 181.98,113.81 181.98,112.87 v6(182.19,112.66)
M_A_CLK1: length 54.1
  TOP w0.178: v6(182.12,109.75) 181.81,110.07 181.21,110.07 180.94,109.8 180.94,107.93 181.13,107.75 DIMM1.138 ; CPU1.U33 v6(173.5,150.5)
  L3 w0.089: 171.57,146.88 171.57,146.9 171.63,146.95 171.63,148.29 170.91,149.01 170.91,150.16 171.9,151.16 172.88,151.16 173.1,150.94 173.1,150.7 173.3,150.5 v6(173.5,150.5)
  L3 w0.178: v6(182.12,109.75) 181.92,109.96 181.35,109.96 180.48,110.82 180.48,116.96 171.75,125.69 171.75,138.92 171.98,139.15 171.98,145.45 171.57,145.86 171.57,146.88
M_A_CLK#0: length 54.4
  TOP w0.178: v6(182.26,111.88) 181.37,111.88 180.87,112.37 DIMM1.139 ; v6(172.5,149.5) CPU1.U34
  L3 w0.089: 172.76,145.06 172.76,145.08 172.82,145.14 172.82,149.18 v6(172.5,149.5)
  L3 w0.178: 172.76,145.06 172.76,138.62 173.08,138.3 173.08,133.65 173.44,133.29 174.38,133.29 174.51,133.17 174.51,132.53 174.38,132.4 173.44,132.4 173.08,132.05 173.08,131.26 173.44,130.91 174.57,130.91 174.74,130.73 174.74,130.2 174.57,130.02 173.44,130.02 173.08,129.66 173.08,128.87 173.44,128.52 174.57,128.52 174.74,128.34 174.74,127.81 174.57,127.63 173.44,127.63 173.08,127.27 173.08,126.05 181.68,117.46 181.68,112.46 v6(182.26,111.88)
M_A_CLK#1: length 54
  TOP w0.178: CPU1.V33 v6(172.5,150.5) ; v6(182.12,110.46) 182.05,110.39 181.08,110.39 180.62,109.93 DIMM1.140
  L3 w0.089: 171.88,146.88 171.88,146.9 171.82,146.95 171.82,148.37 171.1,149.09 171.1,150.09 171.98,150.97 172.8,150.97 172.9,150.86 172.9,150.7 172.7,150.5 v6(172.5,150.5)
  L3 w0.178: 171.88,146.88 171.88,145.99 172.28,145.58 172.28,139.02 172.06,138.8 172.06,137.54 172.17,137.42 172.17,136.89 172.06,136.77 172.06,136.24 172.17,136.13 172.17,135.59 172.06,135.48 172.06,134.94 172.17,134.83 172.17,134.3 172.06,134.18 172.06,133.65 172.17,133.54 172.17,133 172.06,132.89 172.06,129.7 172.17,129.59 172.17,129.05 172.06,128.94 172.06,128.41 172.17,128.29 172.17,127.76 172.06,127.64 172.06,127.11 172.17,127 172.17,126.46 172.06,126.35 172.06,125.82 180.79,117.09 180.79,110.95 181.47,110.26 181.92,110.26 182.12,110.46 v6(182.12,110.46)
M_A_CS#0: length 52.2
  TOP w0.178: v6(178.13,110.67) 178.13,110.61 177.69,110.16 177.3,110.16 177.08,110.38 177.08,113.06 176.37,113.77 DIMM1.149 ; v6(167.46,150.52) 167.46,150.46 CPU1.AC33
  L3 w0.089: v6(167.46,150.52) 167.46,150.2 167.86,149.79 167.86,149.57 168.34,149.09 168.46,149.09 168.87,148.68 168.87,148.34 168.04,147.51
  L3 w0.191: 168.04,147.51 168.04,144.43 169.06,143.41 169.06,124.6 177.55,116.12 177.55,111.26 v6(178.13,110.67)
M_A_CS#1: length 48.3
  TOP w0.178: CPU1.AE35 164.92,148 v6(164.43,147.52) ; v6(172.19,111.38) 173,111.38 173.71,110.67 173.96,110.67 174.21,110.92 174.21,111.18 173.5,111.89 173.5,112.14 174.37,113.01 DIMM1.157
  L3 w0.191: v6(164.43,147.52) 164.33,147.41 164.33,144.19 163.84,143.69 163.84,138.47 165.95,136.35 165.95,123.31 171.91,117.36 171.91,115.8 172.72,114.99 172.72,111.91 v6(172.19,111.38)
M_A_DQ0: length 84.7
  TOP w0.114: CPU1.E18 184.95,165 v6(184.49,164.53) ; DIMM1.8 213.62,107.84 215.44,109.65 215.71,109.65 v6(215.74,109.68)
  L3 w0.089: v6(184.49,164.53) 184.92,164.1 188.7,164.1 189.25,164.65 192.67,164.65
  L3 w0.114: v6(215.74,109.68) 214.96,110.46 214.96,111.25 215.87,112.16 215.87,116.08 215.76,116.2 215.09,116.2 214.97,116.31 214.97,116.54 215.09,116.65 215.76,116.65 215.87,116.77 215.87,116.97 214.35,118.5 214.35,126.3 212.15,128.5 212.15,132.23 210.99,133.39 210.99,141.6 208.23,144.36 208.07,144.36 207.81,144.09 207.65,144.09 207.48,144.26 207.48,144.42 207.75,144.68 207.75,144.84 207.58,145 207.42,145 207.16,144.74 207,144.74 206.84,144.9 206.84,145.06 207.1,145.33 207.1,145.49 206.88,145.71 206.02,145.71 202.75,148.98 202.75,154.24 201.43,155.57 201.43,157.61 200.5,158.54 200.34,158.54 200.24,158.44 200.08,158.44 199.92,158.61 199.92,158.77 200.01,158.86 200.01,159.02 199.85,159.18 199.69,159.18 199.6,159.09 199.44,159.09 199.27,159.25 199.27,159.41 199.37,159.51 199.37,159.67 199.21,159.83 199.04,159.83 198.95,159.74 198.79,159.74 198.63,159.9 198.63,160.06 198.72,160.15 198.72,160.32 194.39,164.65 192.67,164.65
M_A_DQ1: length 84.3
  TOP w0.114: DIMM1.7 213.87,114.29 215.41,112.76 v6(216.68,112.76) ; CPU1.J18 v6(181.5,164.5)
  L3 w0.114: v6(216.68,112.76) 216.76,112.76 217.38,113.38 217.38,116.56 215.45,118.49 214.98,118.96 214.98,126.56 212.78,128.76 212.78,135.51 212.32,135.97 211.74,135.97 211.63,136.09 211.63,136.44 211.74,136.55 212.22,136.55 212.33,136.67 212.33,136.89 212.22,137.01 211.74,137.01 211.63,137.12 211.63,137.35 211.74,137.47 212.1,137.47 212.21,137.58 212.21,137.81 212.1,137.92 211.74,137.92 211.63,138.04 211.63,138.27 211.74,138.38 212.09,138.38 212.2,138.49 212.2,138.72 212.09,138.84 211.74,138.84 211.63,138.95 211.63,141.92 207.17,146.37 206.95,146.37 203.39,149.94 203.39,154.51 202.06,155.83 202.06,157.87 194.42,165.51 183.09,165.51 182.61,165.02 182.02,165.02 v6(181.5,164.5)
M_A_DQ2: length 84.3
  TOP w0.114: v6(181.48,162.46) 181.48,162.52 CPU1.J20 ; v6(212.12,110.06) 211.18,109.12 211.18,108.57 210.62,108.01 DIMM1.20
  L3 w0.089: v6(181.48,162.46) 181.48,162.25 181.77,161.95 182.51,161.95 182.86,162.31 183.74,162.31 184.33,162.9 186.58,162.9 187.13,162.35 190.9,162.35
  L3 w0.114: 190.9,162.35 193.73,162.35 194.06,162.03 194.19,162.03 196.51,159.7 196.51,157.7 200.62,153.59 200.62,147.2 208.81,139.01 208.81,132.64 210.18,131.27 210.18,127.23 211.18,126.23 211.18,118.12 211.29,118 211.52,118 211.64,118.12 211.64,120.85 211.75,120.97 211.98,120.97 212.09,120.85 212.09,114.41 212.59,113.92 212.59,110.52 v6(212.12,110.06)
M_A_DQ3: length 84.3
  TOP w0.114: DIMM1.21 210.37,113.87 v6(212.05,112.19) ; CPU1.H21 182.06,162 v6(182.51,161.55)
  L3 w0.089: v6(182.51,161.55) 183.05,162.09 186.8,162.09 186.98,161.91 190.41,161.91
  L3 w0.114: 190.41,161.91 193.32,161.91 195.86,159.36 195.86,157.45 199.98,153.33 199.98,146.94 208.17,138.75 208.17,132.37 209.48,131.07 209.48,115.81 209.59,115.7 209.82,115.7 209.94,115.81 209.94,120.97 210.05,121.08 210.28,121.08 210.4,120.97 210.4,114.84 211.15,114.09 211.15,112.42 211.38,112.19 v6(212.05,112.19)
M_A_DQ4: length 84.2
  TOP w0.114: DIMM1.4 214.62,107.77 215.52,108.67 v6(215.76,108.67) ; CPU1.H18 181.95,165 v1(181.49,165.46)
  L3 w0.114: v1(181.49,165.46) 181.97,165.94 194.44,165.94 202.38,158 202.38,155.96 203.7,154.64 203.7,151.05 206.27,148.48 206.27,147.72 211.94,142.05 211.94,139.47 213.1,138.32 213.1,128.89 215.3,126.69 215.3,119.09 217.7,116.69 217.7,110.18 216.19,108.67 v6(215.76,108.67)
M_A_DQ5: length 84.2
  TOP w0.114: CPU1.F18 183.91,165 v6(183.48,164.57) ; v6(216.92,114.37) 216.5,113.94 215.15,113.94 214.87,114.22 DIMM1.3
  L3 w0.089: v6(183.48,164.57) 183.89,164.98 192.88,164.98
  L3 w0.114: 192.88,164.98 194.51,164.98 201.74,157.74 201.74,155.7 203.07,154.38 203.07,149.11 203.24,148.93 203.4,148.93 203.54,149.08 203.7,149.08 203.87,148.91 203.87,148.75 203.73,148.61 203.73,148.45 203.89,148.29 204.05,148.29 204.19,148.43 204.35,148.43 204.51,148.27 204.51,148.11 204.37,147.96 204.37,147.8 204.53,147.64 204.7,147.64 204.84,147.78 205,147.78 205.16,147.62 205.16,147.46 205.02,147.32 205.02,147.16 205.18,146.99 205.34,146.99 205.48,147.14 205.65,147.14 205.81,146.97 205.81,146.81 205.67,146.67 205.67,146.51 206.12,146.06 207.04,146.06 211.31,141.78 211.31,133.63 211.42,133.51 211.65,133.51 211.77,133.63 211.77,135.43 211.88,135.55 212.11,135.55 212.22,135.43 212.22,132.6 212.46,132.36 212.46,128.63 214.66,126.43 214.66,118.65 216.92,116.39 216.92,116.2 216.81,116.09 216.41,116.09 216.29,115.97 216.29,115.74 216.41,115.63 216.81,115.63 216.92,115.52 216.92,115.29 216.81,115.17 216.41,115.17 216.29,115.06 216.29,114.83 216.41,114.72 216.81,114.72 216.92,114.6 v6(216.92,114.37)
M_A_DQ6: length 84
  TOP w0.114: v6(182.46,162.54) 182.46,162.56 182.89,163 CPU1.G20 ; DIMM1.16 211.62,108.11 v6(212.11,108.59)
  L3 w0.089: 186.87,162.92 186.7,163.09 184.23,163.09 183.68,162.54 v6(182.46,162.54)
  L3 w0.114: 186.87,162.92 187.21,162.57 193.83,162.57 194.06,162.34 194.32,162.34 196.83,159.83 196.83,157.83 200.94,153.72 200.94,147.33 209.12,139.15 209.12,132.77 210.5,131.4 210.5,127.53 211.53,126.5 211.53,121.53 211.64,121.42 211.87,121.42 211.99,121.53 211.99,123.17 212.1,123.29 212.33,123.29 212.45,123.17 212.45,114.51 212.9,114.05 212.9,111.03 213.82,110.12 213.82,109.04 213.7,108.92 213.47,108.92 213.36,109.04 213.36,109.69 213.25,109.8 213.02,109.8 212.9,109.69 212.9,108.81 212.68,108.59 v6(212.11,108.59)
M_A_DQ7: length 84.3
  TOP w0.114: v6(212.08,112.91) 211.37,113.61 211.37,113.62 DIMM1.17 ; CPU1.F20 v6(184.5,162.5)
  L3 w0.089: 190.67,162.12 187.07,162.12 186.69,162.5 v6(184.5,162.5)
  L3 w0.114: 190.67,162.12 193.56,162.12 196.19,159.49 196.19,157.57 200.3,153.46 200.3,147.07 208.49,138.88 208.49,132.51 209.8,131.2 209.8,121.72 209.91,121.6 210.14,121.6 210.26,121.72 210.26,126.03 210.37,126.15 210.6,126.15 210.71,126.03 210.71,115.2 210.83,115.09 211.06,115.09 211.17,115.2 211.17,117.46 211.28,117.57 211.51,117.57 211.63,117.46 211.63,114.34 211.47,114.18 211.47,113.14 211.7,112.91 v6(212.08,112.91)
M_A_DQ8: length 75.5
  TOP w0.114: v6(209.71,108.46) 209.69,108.46 209.67,108.44 208.89,108.44 208.62,108.17 DIMM1.28 ; CPU1.H22 v6(181.5,161.5)
  L3 w0.089: v6(181.5,161.5) 181.85,161.15 182.67,161.15 183.07,161.54 183.07,161.61 183.31,161.85 183.73,161.85 183.96,161.62 183.96,161.44 184.37,161.03 186.92,161.03 187.26,160.68 187.87,160.68
  L3 w0.114: v6(209.71,108.46) 210.23,108.98 210.23,113.76 208.63,115.36 208.63,130.68 207.29,132.02 207.29,138.39 199.14,146.54 199.14,152.96 195,157.1 195,159.04 193.35,160.68 187.87,160.68
M_A_DQ9: length 75.7
  TOP w0.114: DIMM1.29 208.37,113.08 209.44,112.02 v6(209.72,112.02) ; CPU1.G22 182.48,160.48 v6(182.48,160.47)
  L3 w0.089: v6(182.48,160.47) 182.99,160.47 183.32,160.8 183.67,160.8 183.88,160.59 186.77,160.59 187.15,160.2 187.94,160.2
  L3 w0.114: v6(209.72,112.02) 208.92,112.02 208.37,112.57 208.37,113.74 207.95,114.16 207.95,130.27 206.65,131.57 206.65,133.04 206.53,133.15 206.38,133.15 206.27,133.26 206.27,133.49 206.38,133.61 206.53,133.61 206.65,133.72 206.65,133.95 206.53,134.06 206.38,134.06 206.27,134.18 206.27,134.41 206.38,134.52 206.53,134.52 206.65,134.64 206.65,138.1 204.88,139.87 203.17,139.87 202.4,140.64 202.24,140.64 201.89,140.28 201.72,140.28 201.56,140.44 201.56,140.61 201.92,140.96 201.92,141.12 201.75,141.28 201.59,141.28 201.12,140.81 200.96,140.81 200.79,140.97 200.79,141.13 201.27,141.61 201.27,141.77 200.64,142.4 200.64,144.11 198.49,146.26 198.49,152.62 194.29,156.82 194.29,158.85 192.94,160.2 187.94,160.2
M_A_DQ10: length 75.8
  TOP w0.114: DIMM1.41 205.38,110.84 v6(206.23,109.99) ; CPU1.E24 v6(185.5,158.5)
  L3 w0.114: v6(185.5,158.5) 186.03,158.5 187.67,156.86 192.21,156.86 192.59,156.49 192.59,155.12 196.2,151.51 196.2,145.16 197.45,143.91 197.45,143.75 197.02,143.31 197.02,143.15 197.18,142.99 197.34,142.99 197.78,143.42 197.94,143.42 198.28,143.09 198.28,142.69 198.16,142.57 197.96,142.57 197.85,142.46 197.85,142.23 197.96,142.11 198.16,142.11 198.28,142 198.28,141.77 198.16,141.66 197.96,141.66 197.85,141.54 197.85,141.31 197.96,141.2 198.16,141.2 198.28,141.08 198.28,140.86 198.16,140.74 197.96,140.74 197.85,140.63 197.85,140.4 197.96,140.28 198.16,140.28 198.28,140.17 198.28,139.94 198.16,139.83 197.96,139.83 197.85,139.71 197.85,139.48 197.96,139.37 198.16,139.37 198.28,139.26 198.28,136.3 200.49,134.08 200.49,133.92 200.33,133.76 200.17,133.76 198.59,135.34 198.43,135.34 198.27,135.18 198.27,135.02 205.66,127.63 205.66,109.9 205.77,109.78 206.11,109.78 206.23,109.9 v6(206.23,109.99)
M_A_DQ11: length 75.6
  TOP w0.114: DIMM1.42 205.12,109.7 204.23,110.6 v6(204.06,110.6) ; CPU1.J24 v6(181.5,158.5)
  L3 w0.114: v6(181.5,158.5) 181.83,158.17 182.89,158.17 182.99,158.06 186.16,158.06 187.58,156.64 192.12,156.64 192.37,156.4 192.37,154.89 195.69,151.57 195.69,145.16 196.59,144.26 196.59,139.9 196.71,139.79 196.94,139.79 197.05,139.9 197.05,142 197.16,142.11 197.39,142.11 197.51,142 197.51,138.96 197.9,138.57 197.9,134.76 205.13,127.52 205.13,112.23 205.02,112.11 204.82,112.11 204.7,112 204.7,111.77 204.82,111.66 205.02,111.66 205.13,111.54 205.13,111.31 205.02,111.2 204.74,111.2 204.63,111.08 204.63,110.86 204.74,110.74 205.02,110.74 205.13,110.63 205.13,110.33 204.97,110.17 204.49,110.17 v6(204.06,110.6)
M_A_DQ12: length 75.6
  TOP w0.114: v6(212.09,110.77) 210.86,109.55 210.86,108.77 210.06,107.97 209.89,107.97 209.62,107.71 DIMM1.24 ; CPU1.F21 184.5,161.5 v6(184.55,161.5)
  L3 w0.089: 186.88,161.69 186.67,161.9 184.95,161.9 v6(184.55,161.5)
  L3 w0.114: 186.88,161.69 186.92,161.66 186.92,161.5 187.4,161.01 193.47,161.01 195.32,159.17 195.32,157.23 199.45,153.09 199.45,146.68 207.61,138.52 207.61,132.15 208.94,130.81 208.94,115.5 210.55,113.89 210.55,110.63 210.67,110.51 210.89,110.51 211.01,110.63 211.01,111.32 211.12,111.43 211.35,111.43 211.47,111.32 211.47,110.95 211.65,110.77 v6(212.09,110.77)
M_A_DQ13: length 75.3
  TOP w0.114: CPU1.J21 v1(180.5,161.5) ; v6(209.77,112.76) 209.29,113.23 209.29,113.96 209.37,114.04 DIMM1.25
  L3 w0.089: v1(180.5,161.5) 181.04,160.96 182.98,160.96 183.01,160.99 183.9,160.99 184.1,160.79 186.83,160.79 187.17,160.46 187.88,160.46
  L3 w0.114: v6(209.77,112.76) 208.98,113.54 208.98,114.17 208.27,114.88 208.27,130.4 206.96,131.7 206.96,138.23 204.73,140.47 204.17,140.47 203.79,140.85 203.63,140.85 203.42,140.63 203.26,140.63 203.1,140.79 203.1,140.96 203.31,141.17 203.31,141.33 203.12,141.52 202.96,141.52 202.65,141.21 202.49,141.21 202.33,141.37 202.33,141.53 202.64,141.84 202.64,142 202.48,142.16 202.31,142.16 202.01,141.86 201.84,141.86 201.68,142.02 201.68,142.18 201.99,142.49 201.99,142.65 201.83,142.81 201.67,142.81 201.36,142.5 201.2,142.5 201.04,142.67 201.04,142.83 201.34,143.13 201.34,143.3 200.96,143.68 200.96,144.24 198.81,146.39 198.81,152.82 194.68,156.95 194.68,158.91 193.13,160.46 187.88,160.46
M_A_DQ14: length 74.7
  TOP w0.114: DIMM1.38 206.12,108.49 v6(206.2,108.56) ; CPU1.H24 182.41,159.41 v6(182.41,159.5)
  L3 w0.089: 187.5,158.17 185.69,159.97 185.31,159.97 184.53,159.19 182.74,159.19 182.43,159.5 v6(182.41,159.5)
  L3 w0.114: 187.5,158.17 192.27,158.17 193.26,157.18 193.26,155.96 193.52,155.7 193.52,155.7 197.15,152.07 197.15,145.69 199.31,143.54 199.31,139.84 200.22,138.93 200.22,135.86 206.62,129.47 206.62,113.61 207.04,113.19 207.04,110.58 207.62,110 207.62,109.24 207.73,109.13 208.1,109.13 208.23,109 208.23,108.8 208.1,108.67 207.73,108.67 207.62,108.56 207.62,108.25 207.49,108.13 207.29,108.13 207.16,108.25 207.16,109.8 207.05,109.91 206.82,109.91 206.7,109.8 206.7,109.07 v6(206.2,108.56)
M_A_DQ15: length 75.2
  TOP w0.114: CPU1.F24 v6(184.5,158.5) ; DIMM1.37 206.38,112.5 v6(206.23,112.35)
  L3 w0.089: v6(184.5,158.5) 184.91,158.91 186.02,158.91
  L3 w0.114: 186.02,158.91 187.84,157.09 192.29,157.09 192.8,156.58 192.8,155.43 196.52,151.71 196.52,145.43 198.67,143.28 198.67,136.46 205.46,129.67 205.46,129.51 205.29,129.35 205.13,129.35 200.99,133.5 200.82,133.5 200.66,133.34 200.66,133.17 205.98,127.85 205.98,112.6 v6(206.23,112.35)
M_A_DQ16: length 65.6
  TOP w0.114: v6(204.03,108.37) 203.42,108.37 203.12,108.08 203.13,108.08 DIMM1.50 ; CPU1.J26 v6(180.5,157.5)
  L3 w0.114: v6(204.03,108.37) 203.27,109.13 203.27,127.2 196.38,134.09 196.38,137.93 193.89,140.42 193.89,150.19 189.11,154.97 187.53,154.97 187.18,155.32 187.18,155.46 185.51,157.13 183.36,157.13 183.1,156.87 181.72,156.87 181.67,156.92 181.08,156.92 v6(180.5,157.5)
M_A_DQ17: length 66.5
  TOP w0.114: DIMM1.49 203.38,112.81 v6(204.05,112.13) ; CPU1.J27 v6(180.5,156.5)
  L3 w0.114: v6(180.5,156.5) 180.09,156.91 180.09,157.67 180.33,157.91 182.8,157.91 182.88,157.83 186.08,157.83 187.55,156.36 189.36,156.36 190.02,155.7 190.77,155.7 194.4,152.07 195.12,151.35 195.12,144.96 196.02,144.06 196.02,139.64 197.34,138.32 197.34,134.5 204.58,127.27 204.58,112.64 204.06,112.13 v6(204.05,112.13)
M_A_DQ18: length 65.6
  TOP w0.114: v6(199.36,109.99) 200.13,109.22 DIMM1.62 ; CPU1.G28 v6(183.5,155.5)
  L3 w0.114: v6(199.36,109.99) 199.36,109.91 199.56,109.7 199.98,109.7 200.18,109.91 200.18,110.17 200.3,110.28 200.48,110.28 200.59,110.4 200.59,110.62 200.48,110.74 200.3,110.74 200.18,110.85 200.18,111.12 200.3,111.24 200.5,111.24 200.61,111.35 200.61,111.58 200.5,111.69 200.3,111.69 200.18,111.81 200.18,112.04 200.3,112.15 200.5,112.15 200.61,112.26 200.61,112.49 200.5,112.61 200.3,112.61 200.18,112.72 200.18,112.95 200.3,113.06 200.5,113.06 200.61,113.18 200.61,113.41 200.5,113.52 200.3,113.52 200.18,113.64 200.18,113.86 200.3,113.98 200.5,113.98 200.61,114.09 200.61,114.32 200.5,114.44 200.3,114.44 200.18,114.55 200.18,114.78 200.3,114.89 200.5,114.89 200.61,115.01 200.61,115.24 200.5,115.35 200.3,115.35 200.18,115.46 200.18,115.69 200.3,115.81 200.5,115.81 200.61,115.92 200.61,116.15 200.5,116.26 200.3,116.26 200.18,116.38 200.18,116.61 200.3,116.72 200.5,116.72 200.61,116.84 200.61,117.33 200.5,117.44 199.93,117.44 199.82,117.56 199.82,117.79 199.93,117.9 200.5,117.9 200.61,118.01 200.61,118.3 199.74,119.17 199.74,125.12 193.95,130.9 193.95,136.99 191.32,139.63 191.32,149.26 191.17,149.41 191.01,149.41 190.71,149.11 190.55,149.11 190.39,149.27 190.39,149.43 190.69,149.73 190.69,149.89 185.78,154.8 184.2,154.8 v6(183.5,155.5)
M_A_DQ19: length 66.6
  TOP w0.114: DIMM1.63 199.87,114.19 200.07,113.99 200.07,111.42 v6(199.36,110.7) ; CPU1.H28 v6(181.5,155.5)
  L3 w0.114: v6(199.36,110.7) 199.86,111.21 199.86,113.77 199.42,114.22 199.42,114.66 199.53,114.77 199.74,114.77 199.86,114.89 199.86,115.12 199.74,115.23 199.53,115.23 199.42,115.35 199.42,115.57 199.53,115.69 199.74,115.69 199.86,115.8 199.86,116.03 199.74,116.15 199.53,116.15 199.42,116.26 199.42,116.49 199.53,116.6 199.74,116.6 199.86,116.72 199.86,116.95 199.74,117.06 199.53,117.06 199.42,117.17 199.42,124.99 193.64,130.77 193.64,136.86 190.89,139.6 190.89,146.52 190.35,147.07 190.35,147.23 190.76,147.64 190.76,147.83 190.62,147.96 190.43,147.96 190.03,147.55 189.86,147.55 189.05,148.37 189.05,149.19 189.16,149.3 189.9,149.3 190.04,149.43 190.04,149.62 189.9,149.76 189.16,149.76 189.05,149.87 189.05,150.53 188.5,151.08 188.34,151.08 188.08,151.33 188.08,151.44 187.79,151.73 187.79,151.89 187.9,152 187.9,152.17 187.74,152.33 187.58,152.33 187.47,152.22 187.31,152.22 187.14,152.38 187.14,152.54 187.26,152.65 187.26,152.81 187.09,152.97 186.93,152.97 186.82,152.86 186.66,152.86 186.5,153.02 186.5,153.19 186.61,153.3 186.61,153.46 186.45,153.62 186.29,153.62 186.17,153.51 186.01,153.51 185.85,153.67 185.85,153.83 185.96,153.94 185.96,154.11 185.8,154.27 185.64,154.27 185.53,154.16 185.37,154.16 184.95,154.57 183.99,154.57 183.48,155.08 181.92,155.08 v6(181.5,155.5)
M_A_DQ20: length 65.3
  TOP w0.114: v6(204.06,109.86) 204.55,109.37 204.55,108.22 204.13,107.8 DIMM1.46 ; CPU1.H25 v6(181.5,157.5)
  L3 w0.114: v6(181.5,157.5) 181.5,157.4 181.81,157.09 182.96,157.09 183.22,157.34 185.96,157.34 187.37,155.93 189.14,155.93 189.83,155.25 190.62,155.25 193.52,152.34 193.52,152.05 194.33,151.24 194.33,140.43 196.7,138.06 196.7,134.22 203.59,127.33 203.59,110.32 v6(204.06,109.86)
M_A_DQ21: length 65.9
  TOP w0.114: v6(204.11,113.55) 204.38,113.82 DIMM1.45 ; CPU1.G25 v6(182.5,157.5)
  L3 w0.114: v6(182.5,157.5) 183.05,157.5 183.11,157.56 186.05,157.56 187.46,156.15 189.25,156.15 189.92,155.47 190.69,155.47 193.74,152.43 193.74,152.28 194.27,151.75 194.65,151.38 194.65,140.69 194.76,140.58 194.99,140.58 195.1,140.69 195.1,143.82 195.22,143.93 195.45,143.93 195.56,143.82 195.56,139.65 197.02,138.19 197.02,134.4 197.02,134.39 197.02,134.37 204.11,127.29 v6(204.11,113.55)
M_A_DQ22: length 66
  TOP w0.114: CPU1.E28 185.4,155.4 v6(185.5,155.4) ; DIMM1.58 201.13,108.2 201.12,108.2 v6(201.46,108.54)
  L3 w0.114: v6(185.5,155.4) 191.66,149.24 191.66,139.86 194.39,137.14 194.39,130.92 200.05,125.25 200.05,119.35 200.18,119.22 200.38,119.22 200.51,119.35 200.51,122.23 200.64,122.36 200.84,122.36 200.97,122.23 200.97,118.81 200.97,118.81 200.97,110.05 200.85,109.94 200.66,109.94 200.55,109.82 200.55,109.6 200.66,109.48 200.85,109.48 200.97,109.37 200.97,109.16 200.85,109.04 200.02,109.04 199.91,108.93 199.91,108.7 200.02,108.58 200.85,108.58 200.97,108.47 200.97,108.19 201.09,108.07 201.36,108.07 201.46,108.18 v6(201.46,108.54)
M_A_DQ23: length 66.2
  TOP w0.114: v6(182.5,156.4) 182.4,156.4 CPU1.H27 ; v6(201.44,113.64) 201.12,113.64 200.87,113.89 DIMM1.59
  L3 w0.089: v6(182.5,156.4) 182.5,156.02 182.63,155.9 183.67,155.9 183.97,155.59 183.97,155.46 184.33,155.1 184.82,155.1 185.09,155.37 185.09,155.56 185.33,155.8 185.67,155.8 185.96,155.51 185.96,155.28 186.14,155.1
  L3 w0.114: 186.14,155.1 187.94,153.29 188.11,153.29 188.29,153.48 188.45,153.48 188.61,153.31 188.61,153.15 188.43,152.97 188.43,152.81 188.59,152.65 188.75,152.65 189.11,153.01 189.25,153.01 189.43,152.82 189.43,152.68 189.08,152.32 189.08,152.16 190.72,150.52 190.88,150.52 190.95,150.59 191.11,150.59 191.28,150.42 191.28,150.26 191.21,150.19 191.21,150.03 191.37,149.87 191.53,149.87 191.82,150.16 191.98,150.16 192.14,150 192.14,149.84 191.85,149.55 191.85,149.39 192.02,149.22 192.02,139.96 194.73,137.25 194.73,132.32 196.58,130.47 196.58,130.31 196.42,130.15 196.26,130.15 195.1,131.3 194.94,131.3 194.78,131.14 194.78,130.97 200.52,125.23 200.52,123.01 200.64,122.9 200.87,122.9 200.98,123.01 200.98,124.27 201.1,124.38 201.32,124.38 201.44,124.27 v6(201.44,113.64)
M_A_DQ24: length 59.2
  TOP w0.114: v6(197.07,111.44) 197.27,111.44 198.13,110.59 DIMM1.70 ; CPU1.F29 v6(183.5,153.5)
  L3 w0.114: v6(183.5,153.5) 184.42,153.5 185.93,151.99 185.93,151.24 185.87,151.18 185.87,147.5 186.46,146.92 186.66,146.92 186.92,146.66 186.92,146.43 188.6,144.75 188.6,139.45 191.73,136.32 191.73,130.42 194.71,127.45 194.71,126.19 196.76,124.13 196.76,123.94 196.63,123.81 196.44,123.81 195.16,125.09 194.97,125.09 194.83,124.96 194.83,124.77 197.77,121.83 197.77,112.15 v6(197.07,111.44)
M_A_DQ25: length 59
  TOP w0.114: CPU1.J30 v6(181.5,153.5) ; DIMM1.71 197.87,114.22 198.16,113.94 198.16,113.93 198.17,113.92 198.17,113.69 198.17,113.68 198.17,113.25 v6(199.3,112.12)
  L3 w0.114: v6(181.5,153.5) 181.97,153.97 182.74,153.97 182.9,154.13 183.79,154.13 183.8,154.11 184.42,154.11 186.69,151.84 186.69,151.23 187.07,150.85 187.07,149.94 187.92,149.08 187.92,148.02 188.14,147.8 188.14,146.79 189.35,145.59 189.35,141.91 189.47,141.8 189.81,141.8 189.92,141.68 189.92,141.45 189.81,141.34 189.47,141.34 189.35,141.23 189.35,141 189.47,140.88 189.81,140.88 189.92,140.77 189.92,140.54 189.81,140.43 189.47,140.43 189.35,140.31 189.35,139.64 192.54,136.45 192.54,130.52 195.35,127.71 195.35,126.48 197.46,124.37 197.46,123.21 197.59,123.08 197.78,123.08 197.91,123.21 197.91,123.64 198.05,123.77 198.24,123.77 198.37,123.64 198.37,122.13 198.53,121.97 198.53,112.89 v6(199.3,112.12)
M_A_DQ26: length 58.9
  TOP w0.114: DIMM1.83 194.87,112.25 v6(194.55,111.92) ; CPU1.H31 v6(181.5,151.5)
  L3 w0.114: v6(181.5,151.5) 181.5,150.1 183.96,147.64 183.96,141.9 185.19,140.67 185.19,134.94 185.98,134.15 188.81,134.15 189.13,133.83 189.13,124.71 193.53,120.31 193.53,117.14 194.45,116.22 194.45,112.8 194.33,112.68 194.1,112.68 193.99,112.8 193.99,116.04 193.86,116.17 193.67,116.17 193.53,116.04 193.53,112.46 194.07,111.92 v6(194.55,111.92)
M_A_DQ27: length 58.8
  TOP w0.114: v6(183.54,150.56) 183.99,151 CPU1.F32 ; v6(194.55,109.63) 194.91,109.27 194.91,107.99 194.62,107.71 DIMM1.84
  L3 w0.114: v6(183.54,150.56) 183.07,150.56 182.81,150.3 182.81,149.61 184.51,147.91 184.51,145.9 185.94,144.46 185.94,144.23 185.83,144.11 185.52,144.11 185.39,143.98 185.39,143.79 185.52,143.65 185.83,143.65 185.94,143.54 185.94,139.78 186.63,139.09 186.63,135.4 187.19,134.84 189.02,134.84 189.76,134.09 189.76,124.98 192.34,122.4 192.5,122.4 192.73,122.63 192.89,122.63 193.05,122.47 193.05,122.3 192.83,122.08 192.83,121.92 192.99,121.75 193.15,121.75 193.38,121.98 193.54,121.98 193.7,121.82 193.7,121.66 193.47,121.43 193.47,121.27 193.63,121.11 193.8,121.11 194.02,121.33 194.18,121.33 194.35,121.17 194.35,121.01 194.12,120.78 194.12,120.62 194.42,120.32 194.42,118.49 194.54,118.38 194.77,118.38 194.88,118.49 194.88,119.99 195.01,120.13 195.2,120.13 195.34,119.99 195.34,110.41 v6(194.55,109.63)
M_A_DQ28: length 58.8
  TOP w0.114: CPU1.J29 v6(180.5,153.5) ; DIMM1.66 199.13,108.31 v6(199.38,108.57)
  L3 w0.114: v6(180.5,153.5) 180.91,153.09 182.67,153.09 183.08,153.5 183.08,153.66 183.33,153.91 183.68,153.91 183.71,153.88 184.35,153.88 186.15,152.08 186.15,151.14 186.09,151.08 186.09,150.33 186.5,149.92 186.66,149.92 186.97,149.61 186.97,148.43 187.38,148.03 187.58,148.03 187.91,147.7 187.91,146.37 188.95,145.34 188.95,139.55 192.15,136.35 192.15,130.46 195.03,127.58 195.03,126.35 197.14,124.24 197.14,122.91 198.22,121.84 198.22,109.74 199.38,108.57 v6(199.38,108.57)
M_A_DQ29: length 58.5
  TOP w0.114: DIMM1.67 198.87,114.15 199.01,114.02 199.52,114.02 199.82,113.72 199.82,113.29 v6(199.36,112.83) ; CPU1.G29 v6(182.5,154.5)
  L3 w0.114: v6(182.5,154.5) 183.74,154.5 183.9,154.34 184.5,154.34 186.92,151.92 186.92,151.43 187.28,151.07 187.51,151.07 187.94,150.64 187.94,150.47 188.15,150.25 188.15,148.22 188.75,147.62 188.75,147.38 189.85,146.28 190.07,146.28 190.36,145.99 190.36,139.24 193.02,136.57 193.02,130.59 196.15,127.46 196.15,127.3 195.68,126.82 195.68,126.66 195.84,126.5 196,126.5 196.41,126.91 196.6,126.91 196.74,126.77 196.74,126.59 196.33,126.18 196.33,126.02 196.49,125.85 196.65,125.85 197.08,126.28 197.27,126.28 197.4,126.15 197.4,125.96 196.97,125.53 196.97,125.37 197.14,125.21 197.3,125.21 197.69,125.6 197.88,125.6 198.02,125.47 198.02,125.28 197.62,124.88 197.62,124.72 198.25,124.09 198.51,124.09 198.85,123.74 198.85,113.34 v6(199.36,112.83)
M_A_DQ30: length 58.8
  TOP w0.114: v6(197.3,113.58) 196.59,113.58 195.87,114.29 195.87,114.29 DIMM1.79 ; v6(185.52,151.57) 185.43,151.57 CPU1.E31
  L3 w0.114: v6(185.52,151.57) 185.22,151.27 185.22,150.08 185.64,149.65 185.64,146.77 187.52,144.89 187.52,141.04 187.59,140.97 187.59,140.72 188.28,140.03 188.28,139.24 190.56,136.95 190.56,136.76 190.43,136.63 190.24,136.63 188.63,138.24 188.44,138.24 188.3,138.11 188.3,137.92 191.41,134.81 191.41,130.29 194.39,127.32 194.39,123.47 196.47,121.39 196.66,121.39 196.8,121.52 196.8,121.71 194.79,123.71 194.79,123.88 194.96,124.04 195.12,124.04 197.3,121.86 v6(197.3,113.58)
M_A_DQ31: length 58.8
  TOP w0.114: v6(194.56,110.42) 195.62,109.36 DIMM1.80 ; CPU1.G31 182.9,152 v6(182.47,151.57)
  L3 w0.114: v6(182.47,151.57) 182.47,150.97 182.35,150.86 181.99,150.86 181.87,150.74 181.87,150.51 181.99,150.4 182.35,150.4 182.47,150.29 182.47,149.46 184.19,147.74 184.19,144.98 184.3,144.87 184.64,144.87 184.76,144.75 184.76,144.53 184.64,144.41 184.3,144.41 184.19,144.3 184.19,144.07 184.3,143.95 184.52,143.95 184.63,143.84 184.63,143.61 184.52,143.5 184.3,143.5 184.19,143.38 184.19,143.15 184.3,143.04 184.52,143.04 184.63,142.93 184.63,142.7 184.52,142.58 184.3,142.58 184.19,142.47 184.19,142.29 185.63,140.86 185.63,139.55 186.28,138.89 186.28,136.09 186.17,135.97 185.68,135.97 185.56,135.86 185.56,135.63 185.68,135.52 186.17,135.52 186.28,135.4 186.28,134.64 186.46,134.47 188.94,134.47 189.45,133.96 189.45,124.85 194.1,120.19 194.1,117.22 194.24,117.09 194.43,117.09 194.56,117.22 194.56,117.77 194.7,117.9 194.89,117.9 195.02,117.77 195.02,110.65 194.79,110.42 v6(194.56,110.42)
M_A_DQ32: length 51.7
  TOP w0.114: v6(161.56,149.51) 161.56,149.38 161.95,149 CPU1.AH34 ; DIMM1.174 170.12,108.48 v6(170.16,108.52)
  L3 w0.114: v6(170.16,108.52) 169.88,108.79 169.72,108.79 169.21,108.28 169.04,108.28 168.88,108.44 168.88,108.6 169.4,109.12 169.4,109.28 169.28,109.39 169.28,115.11 160.72,123.67 160.72,130.3 160.83,130.42 160.99,130.42 161.1,130.53 161.1,130.76 160.99,130.87 160.83,130.87 160.72,130.99 160.72,131.17 160.45,131.43 160.45,136.17 160.57,136.28 161.02,136.28 161.14,136.4 161.14,136.63 161.02,136.74 160.57,136.74 160.45,136.86 160.45,139.42 159.73,140.14 159.73,142.84 160.78,143.89 160.78,148.72 v6(161.56,149.51)
M_A_DQ33: length 51.9
  TOP w0.114: DIMM1.173 170.38,113.81 v6(170.16,113.59) ; CPU1.AJ30 v1(161.48,152.52)
  L3 w0.089: 161.69,148.47 162.16,148.94 162.16,150.1 161.48,150.78 v1(161.48,152.52)
  L3 w0.114: 161.69,148.47 161.23,148.02 161.23,143.05 161.09,142.91 161.09,137.68 161.88,136.89 161.88,129.46 161.77,129.35 161.5,129.35 161.39,129.24 161.39,129.01 161.5,128.89 161.77,128.89 161.88,128.78 161.88,128.53 161.77,128.41 161.56,128.41 161.45,128.3 161.45,128.07 161.56,127.96 161.77,127.96 161.88,127.84 161.88,127.61 161.77,127.5 161.56,127.5 161.45,127.38 161.45,127.15 161.56,127.04 161.77,127.04 161.88,126.93 161.88,126.7 161.77,126.58 161.56,126.58 161.45,126.47 161.45,126.24 161.56,126.13 161.77,126.13 161.88,126.01 161.88,125.78 161.77,125.67 161.56,125.67 161.45,125.55 161.45,125.33 161.56,125.21 161.77,125.21 161.88,125.1 161.88,124.87 161.77,124.75 161.56,124.75 161.45,124.64 161.45,124.41 161.56,124.3 161.77,124.3 161.88,124.18 161.88,123.41 162.02,123.27 162.18,123.27 162.29,123.38 162.45,123.38 162.62,123.22 162.62,123.06 162.5,122.95 162.5,122.78 162.67,122.62 162.83,122.62 162.94,122.73 163.1,122.73 163.26,122.57 163.26,122.41 163.15,122.3 163.15,122.14 163.31,121.98 163.47,121.98 163.59,122.09 163.75,122.09 163.91,121.93 163.91,121.76 163.8,121.65 163.8,121.49 163.96,121.33 164.12,121.33 164.23,121.44 164.39,121.44 164.56,121.28 164.56,121.12 164.44,121.01 164.44,120.84 164.61,120.68 164.77,120.68 164.88,120.79 165.04,120.79 165.2,120.63 165.2,120.47 165.09,120.36 165.09,120.2 170.16,115.13 v6(170.16,113.59)
M_A_DQ34: length 51.4
  TOP w0.114: v6(159.46,152.51) 159.95,153 CPU1.AK30 ; DIMM1.187 166.87,114.29 167.65,113.52 v6(167.85,113.52)
  L3 w0.089: 159.98,148.7 159.91,148.77 159.91,150.22 159.94,150.26 159.94,152.02 v6(159.46,152.51)
  L3 w0.114: v6(167.85,113.52) 167.85,114.63 159.38,123.09 159.38,130.62 159.12,130.88 159.12,135.89 158.21,136.81 158.21,138.68 158.32,138.79 158.55,138.79 158.66,138.68 158.66,137.02 158.78,136.91 159.01,136.91 159.12,137.02 159.12,138.86 158.39,139.59 158.39,141.06 158.86,141.53 158.86,143.19 159.98,144.3 159.98,148.7
M_A_DQ35: length 52
  TOP w0.114: CPU1.AL34 159,148.95 v6(158.52,148.47) ; v6(164.9,111.41) 164.9,111.41 165.01,111.41 167.12,109.29 DIMM1.186
  L3 w0.089: v6(158.52,148.47) 158.52,146.4 157.56,145.45 157.56,144.39
  L3 w0.114: v6(164.9,111.41) 165.39,110.92 165.39,110.17 165.5,110.05 166.05,110.05 166.17,110.17 166.17,111.27 166.05,111.39 165.72,111.39 165.61,111.5 165.61,111.73 165.72,111.85 166.05,111.85 166.17,111.96 166.17,114.86 157.8,123.23 157.8,135.26 157.18,135.88 157.18,141.37 157.46,141.66 157.46,143.67 157.57,143.78 157.57,144.38 157.56,144.39
M_A_DQ36: length 51.6
  TOP w0.114: DIMM1.170 171.12,108.07 171.16,108.1 171.16,109.76 v6(170.19,110.72) ; CPU1.AH31 v1(162.48,152.48)
  L3 w0.089: 162.13,148.22 163.09,149.18 163.09,151.64 162.48,152.25 v1(162.48,152.48)
  L3 w0.114: v6(170.19,110.72) 170.94,111.47 170.94,113.92 170.79,114.06 170.79,116 162.61,124.18 162.61,137.06 161.78,137.89 161.78,140.55 161.68,140.65 161.68,147.77 162.13,148.22
M_A_DQ37: length 51.6
  TOP w0.114: DIMM1.169 171.38,114.76 171.37,114.76 171.37,113.48 171.22,113.32 171.22,113.21 v6(170.16,112.15) ; CPU1.AH32 162.05,151.05 162.07,151.05 v6(162.48,151.46)
  L3 w0.089: 161.89,148.33 162.9,149.35 162.9,150.99 162.48,151.41 v6(162.48,151.46)
  L3 w0.114: 161.89,148.33 161.46,147.91 161.46,137.76 162.2,137.02 162.2,124.14 165.74,120.6 165.74,120.44 165.64,120.33 165.64,120.17 165.8,120.01 165.96,120.01 166.07,120.11 166.23,120.11 166.35,119.99 166.35,119.83 166.25,119.73 166.25,119.57 166.41,119.41 166.57,119.41 166.67,119.51 166.83,119.51 167,119.35 167,119.18 166.9,119.09 166.9,118.92 167.06,118.76 167.22,118.76 167.32,118.86 167.48,118.86 167.64,118.7 167.64,118.54 167.54,118.44 167.54,118.28 167.71,118.12 167.87,118.12 167.97,118.21 168.13,118.21 168.23,118.11 168.23,117.95 168.12,117.85 168.12,117.69 168.28,117.52 168.44,117.52 168.55,117.63 168.71,117.63 168.87,117.47 168.87,117.31 168.77,117.2 168.77,117.04 168.93,116.88 169.09,116.88 169.2,116.98 169.36,116.98 169.52,116.82 169.52,116.66 169.41,116.55 169.41,116.39 169.58,116.23 169.74,116.23 169.84,116.34 170,116.34 170.48,115.86 170.48,113.93 170.62,113.79 170.62,112.61 v6(170.16,112.15)
