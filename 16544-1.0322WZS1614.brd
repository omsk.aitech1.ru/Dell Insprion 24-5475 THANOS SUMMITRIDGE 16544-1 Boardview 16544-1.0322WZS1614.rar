# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SMI#: length 168.4
  TOP w0.114: v1(129.46,170.74) 129.47,170.75 RN2407.4 ; v1(121.5,121.11) v3(121.5,122) 121.5,122.14 v1(124.71,125.35) ; v6(156.42,179.48) 156.94,180 CPU1.AN3 ; v1(95.78,59.61) 96.16,59.23 96.22,59.23 96.53,58.93 96.53,58.5 96.33,58.31 R2437.1
  L3 w0.114: v1(121.5,121.11) 121.46,121.06 121.46,114.88 120.57,113.99 120.57,108.25 117.97,105.65 117.97,102.88 108.23,93.14 108.23,90.98 106.28,89.03 106.28,88.08 101.6,83.4 101.6,82.06 100.46,80.92 100.46,77.1 96.97,73.61 96.97,69.72 95.99,68.74 95.99,63.09 94.98,62.09 94.98,60.64 95.76,59.87 95.76,59.64 v1(95.78,59.61)
  L4 w0.114: v1(124.71,125.35) 124.24,125.82 124.24,134.91 126.29,136.96 126.29,144.23 126.03,144.49 126.03,145.64 125.98,145.69 125.98,146.1 126.03,146.15 126.03,153.71 127.13,154.81 127.13,164.29 127.1,164.31 127.1,164.64 128.27,165.81 128.27,169.82 129.19,170.74 v1(129.46,170.74) 131.88,170.74 134.62,173.48 135.08,173.48 135.1,173.51 141.25,173.51 143.51,175.77 143.51,176.2 144.35,177.04 v1(144.35,177.11)
  BOTTOM w0.114: v6(156.42,179.48) 156.13,179.48 155.67,179.94 155.34,179.94 155.04,180.24 155.04,180.73 154.2,181.57 154.2,181.77 153.83,182.14 152.93,182.14 152.81,182.02 152.12,182.02 151.84,182.3 150.98,182.3 149.89,183.39 147.22,183.39 146.5,182.68 145.59,182.68 143.69,180.77 143.69,177.83 144.35,177.16 v1(144.35,177.11)
EC_SPI_CLK: length 64.7
  TOP w0.114: v1(141.25,81.15) 141.25,81.46 137.27,85.43 137.27,88.68 136.29,89.67 136.29,95.41 v1(136.78,95.9)
  L3 w0.114: v1(141.25,81.15) 142.06,81.15 145.67,77.54 145.67,71.4 v1(146.71,70.36)
  BOTTOM w0.114: v1(141.25,81.15) 140.81,81.59 v5(140.81,82.1) ; RN42.1 136.62,96.05 v1(136.78,95.9) ; R2678.1 123.57,61.16 124.46,62.05 124.46,62.89 126.34,64.77 126.34,69.32 128.83,71.81 145.26,71.81 v1(146.71,70.36)
EC_SPI_CLK_R: length 8.1
  TOP w0.114: R2672.2 121.08,61.16 v1(120.98,61.06) 120.29,60.38 120.29,59.92 119.75,59.38 119.75,58.69 118.81,57.74 KBC1.92
  BOTTOM w0.114: v1(120.98,61.06) 121.08,61.16 R2672.2 121.84,61.16 v2(122.76,62.08)
EC_SPI_CS0_N: length 62.7
  TOP w0.114: v1(142.06,80.49) 142.06,81.13 137.62,85.57 137.62,88.83 136.63,89.81 136.63,94.96 v1(136.8,95.13)
  L3 w0.114: v1(145.67,70.41) 144.7,71.37 144.7,75.11 142.47,77.34 142.47,80.09 v1(142.06,80.49)
  BOTTOM w0.114: v1(142.06,80.49) 142.24,80.49 v5(142.92,79.81) ; v1(145.67,70.41) 144.63,71.45 129.68,71.45 126.7,68.46 126.7,64.62 124.82,62.74 124.82,61.9 123.7,60.78 123.43,60.78 R2676.1 ; v1(136.8,95.13) 136.79,95.13 135.97,95.96 RN42.2
EC_SPI_CS0_N_R: length 7.6
  TOP w0.114: R2674.2 120.8,59.89 v1(120.78,59.92) 120.09,59.23 120.09,58.12 118.92,56.94 KBC1.90
  BOTTOM w0.114: R2676.2 120.8,59.94 v1(120.78,59.92) 119.99,59.92 v2(119.81,60.1)
EC_SPI_SI: length 62.8
  TOP w0.114: v1(134.82,95) 134.7,94.87 134.7,88.29 135.9,87.08 135.9,84.42 139.88,80.44 v1(140.46,80.44)
  L3 w0.114: v1(144.6,70.33) 144.09,70.84 144.09,74.5 141,77.6 141,79.91 v1(140.46,80.44)
  BOTTOM w0.114: v1(140.46,80.44) 140.32,80.44 v5(139.66,79.79) ; R2679.1 125.67,61.98 125.81,61.98 127.05,63.22 127.05,68.33 129.81,71.09 143.84,71.09 v1(144.6,70.33) ; RN43.2 133.76,96.06 v1(134.82,95)
EC_SPI_SI_R: length 9.5
  TOP w0.114: KBC1.87 120.23,55.74 120.55,56.06 120.55,56.45 120.48,56.53 120.48,57.44 120.8,57.76 121.51,57.76 121.73,57.98 R2673.2 121.44,58.83 v1(120.88,58.27)
  BOTTOM w0.114: R2679.2 121.51,58.9 v1(120.88,58.27) 120.88,58.78 v2(120.6,59.05)
EC_SPI_SO: length 68.3
  TOP w0.114: v1(134.9,95.81) 135.29,95.42 135.29,94.8 135.04,94.56 135.04,88.43 136.25,87.22 136.25,86.94 136.25,84.56 139.7,81.1 v1(139.93,81.1)
  L3 w0.114: v1(143.46,69.98) 143.51,70.03 143.51,72.92 140.92,75.51 140.92,76.73 140.58,77.08 140.58,79.01 139.93,79.65 v1(139.93,81.1)
  BOTTOM w0.114: v5(138.88,81.01) 139.83,81.01 v1(139.93,81.1) ; RN43.1 134.41,96.3 v1(134.9,95.81) ; v1(143.46,69.98) 143.17,70.27 131.61,70.27 129.31,67.97 129.31,63.88 128.12,62.69 128.12,60.91 127.73,60.53 126.11,60.53 125.72,60.13 125.72,59.6 124.68,58.57 124.68,55.36 124.85,55.19 124.85,54.27 125.1,54.01 125.1,53.61 124.3,52.8 123.91,52.8 123.32,53.39 123.19,53.39 R2677.1
EC_SPI_SO_R: length 7.1
  TOP w0.114: KBC1.86 120.09,55.34 120.93,54.51 v1(121.08,54.51) 121.08,54.13 121.78,53.43 R2675.2
  BOTTOM w0.114: v1(121.08,54.51) 121.27,54.32 R2677.2 122.78,55.11 v2(122.78,55.22)
EC_SWI#: length 166.7
  TOP w0.114: R2439.1 99.37,63.52 98.98,63.91 98.5,63.91 v1(98.45,63.96) ; v1(130.71,174.49) 130.48,174.49 130.43,174.44 RN2408.3 ; CPU1.AP1 156,182.21 v1(156.5,182.7)
  L3 w0.114: v1(98.45,63.96) 97.92,64.49 97.92,66.71 98.16,66.95 98.16,72.51 100.88,75.22 100.88,80.74 102.02,81.89 102.02,83.22 106.72,87.92 107.15,87.92 112.43,93.2 112.43,94.14 115.62,97.33 116.84,97.33 119.13,99.62 119.15,99.62 120.11,100.58 v1(120.11,101.2)
  L4 w0.114: v1(156.5,182.7) 156.29,182.7 155.75,182.17 153.5,182.17 152.75,182.91 150.78,182.91 148.49,180.62 148.49,180.39 147.45,179.35 147.22,179.35 146.94,179.07 142.52,179.07 142.36,179.23 132.84,179.23 131.79,178.18 131.79,175.57 v1(130.71,174.49) 130.48,174.49 130.33,174.35 125.74,174.35 123.08,171.68 123.08,168.84 122.45,168.22 122.45,138.56 121.11,137.21 121.11,130.19 120.96,130.04 120.96,128.17 119.62,126.83 119.62,118.92 121.93,116.61 121.93,103.31 121.51,102.89 121.51,102.22 120.48,101.19 120.12,101.19 v1(120.11,101.2)
  BOTTOM w0.114: v1(98.45,63.96) 98.5,63.96 98.58,64.03 v2(99.39,64.03)
EC_VBKUP: length 5.1
  TOP w0.203: v1(109.68,58.34) 109.68,58.62 110.21,59.16 110.21,59.54 109.65,60.1 KBC1.114
  BOTTOM w0.508: v2(108.86,58.75) 109.27,58.34 v1(109.68,58.34) 109.68,57.54 R2469.1
EC_VCC1D8V_S5: length 6.4
  TOP w0.203: KBC1.88 119.2,56.14 119.21,56.16 119.99,56.16 v1(120.09,56.26)
  TOP w0.508: v1(120.79,55.5) 120.93,55.64 R2412.2 121.93,55.58 R2425.1
  BOTTOM w0.508: v2(119.46,55.74) 119.57,55.74 v1(120.09,56.26) 120.09,56.21 v1(120.79,55.5)
EC_VDD3D3: length 36.1
  TOP w0.203: KBC1.4 v1(101.02,58.14)
  TOP w0.508: R2425.2 123.57,54.41 v1(123.7,54.53) ; R2457.2 97.68,60.31 98.27,59.72 C1010.1 98.4,59.69 99.74,59.69 v3(99.84,59.6) 99.97,59.47 99.97,58.96 100.78,58.14 v1(101.02,58.14)
  L3 w0.508: v1(101.02,58.14) 101.05,58.12 101.6,58.12 102.41,58.93 103.43,58.93 104.75,60.25 105.66,60.25 106.35,59.56 106.35,59.16 107.83,57.68 112.55,57.68 112.56,57.67 113.47,57.67 113.91,57.23 113.91,56.32 116.64,53.59 121.41,53.59 122.35,54.53 v1(123.7,54.53)
  BOTTOM w0.508: v1(101.02,58.14) 101.03,58.13 C1006.1
EC_VSBY: length 4.5
  TOP w0.203: v3(121.07,50.32) 120.72,50.32 120.62,50.42 119.34,50.42 118.82,50.95 KBC1.75
  TOP w0.254: v3(121.07,50.32) 121.74,49.66 R2466.1
ECRST#: length 7.7
  TOP w0.114: KBC1.85 117.22,54.94 116.46,55.7 v1(116.46,56.08)
  BOTTOM w0.114: Q8.E 114.16,56.12 R182.2 116.42,56.12 v1(116.46,56.08) 116.54,56.16 v2(116.54,57.02) 116.66,57.15 C275.1 R2631.2
ECSCI#_KBC: length 6.1
  TOP w0.114: R2433.1 97.56,48.77 v3(97.84,49.05) 98.01,49.05 98.5,48.56 101.33,48.56 101.74,48.14 KBC1.29
ECSMI#_KBC: length 6.2
  TOP w0.114: KBC1.11 101.4,55.34 v3(100.2,56.55) 99.21,57.53 R2437.2
ECSWI#_KBC: length 7.3
  TOP w0.114: R2439.2 100.41,62.97 v3(102.34,62.97) 103.75,62.97 104.27,62.46 105.41,62.46 106.05,61.82 KBC1.123
EDCA0_0: length 23
  TOP w0.13: VRAMA1.C13 107.08,189.38 106.92,189.22 106.92,187.97 106.17,187.22 105.76,187.22 105.38,186.84 95.38,186.84 95.12,186.59 94.39,186.59 93.73,187.25 93.4,187.25 93.3,187.34 87.64,187.34 GPU1.R41
EDCA0_1: length 23.9
  TOP w0.13: GPU1.F42 88.26,194.26 89.61,194.26 91.62,196.27 91.62,196.27 93.9,198.55 93.9,198.57 95.96,200.63 106.14,200.63 106.8,199.97 106.8,199.5 106.87,199.43 106.87,198.83 107.11,198.59 107.11,198.59 VRAMA1.C2
EDCA0_2: length 14.9
  TOP w0.13: v6(85.55,187.2) 85.55,187.05 GPU1.R39 ; VRAMA1.R13 v6(97.3,190)
  L6 w0.089: 95.48,190.63 95.65,190.45 96.28,190.45 96.33,190.4 97.12,190.4 97.3,190.22 v6(97.3,190)
  L6 w0.11: v6(85.55,187.2) 86,187.65 92.22,187.65 92.82,188.25 95.2,190.63 95.48,190.63
EDCA0_3: length 17.4
  TOP w0.13: GPU1.H38 84.65,193.05 v6(84.65,193.2) ; VRAMA1.R2 v6(97.3,198)
  L6 w0.11: v6(84.65,193.2) 85.4,193.95 86.64,193.95 87.1,194.41 89.83,194.41 94.68,199.27 96.3,199.27 96.34,199.23 96.66,199.23 97.3,198.59 v6(97.3,198)
EDCA1_0: length 34.8
  TOP w0.13: VRAMA2.R2 93.19,225.01 93.19,225.01 93.28,224.92 94.14,224.92 94.16,224.9 94.51,224.9 94.52,224.92 94.78,224.92 96.1,223.6 96.1,214.37 90.75,209.02 90.75,206.22 84.24,199.71 84.24,198.24 GPU1.B38
EDCA1_1: length 32.1
  TOP w0.13: VRAMA2.R13 83.66,224.86 82.59,224.86 81.68,223.96 81.68,221.48 81.62,221.41 81.62,209.05 81.62,209.05 81.62,208.26 78.71,205.35 78.71,203.9 78.65,203.84 77.34,202.52 77.34,197.64 GPU1.C29
EDCA1_2: length 25.9
  TOP w0.13: GPU1.D35 81.85,196.45 v6(82,196.45) ; v6(92.5,215.3) VRAMA2.C2
  L6 w0.11: v6(92.5,215.3) 93.08,215.3 93.73,214.65 93.73,214.35 93.74,214.34 93.74,212.98 91,210.24 91,208.54 82.45,199.99 82.45,196.9 v6(82,196.45)
EDCA1_3: length 27.2
  TOP w0.13: VRAMA2.C13 v6(83.7,215.3) ; GPU1.G27 75.85,193.85 v6(76,193.85)
  L6 w0.11: v6(76,193.85) 76.41,194.26 76.41,194.83 76.16,195.08 76.16,202.12 84.93,210.89 84.93,214.07 v6(83.7,215.3)
EDCB0_0: length 23
  TOP w0.13: v6(72.4,194.65) 72.25,194.65 GPU1.F24 ; v6(74.8,215.32) 74.8,215.33 VRAMB1.R13
  L6 w0.11: v6(74.8,215.32) 74.8,215.3 73.57,214.07 73.08,213.58 73.08,203.83 72.38,203.13 72.38,194.67 v6(72.4,194.65)
EDCB0_1: length 27
  TOP w0.13: GPU1.J19 66.55,192.25 v6(66.4,192.25) ; VRAMB1.R2 66,215.33 v6(66.01,215.33)
  L6 w0.11: v6(66.4,192.25) 67.19,193.03 67.19,195.73 67.41,195.96 67.41,199.61 67.24,199.78 67.24,210.02 64.58,212.69 64.58,214.49 65.04,214.96 65.59,214.96 65.96,215.33 v6(66.01,215.33)
EDCB0_2: length 29.4
  TOP w0.13: GPU1.A18 65.8,203.74 65.48,204.07 65.48,208.67 63.65,210.5 63.65,212.12 63.1,212.67 63.1,223.88 64.02,224.8 64.39,224.8 64.49,224.89 65.16,224.89 VRAMB1.C2
EDCB0_3: length 33.2
  TOP w0.13: VRAMB1.C13 74.4,225.33 74.81,224.92 75.97,224.92 76.94,223.96 76.94,211.22 76.42,210.7 73.43,207.71 73.43,207.12 73.37,207.06 73.37,203.92 72.66,203.21 72.66,199.65 72.58,199.57 72.58,196.78 GPU1.D24
EDCB1_0: length 24.5
  TOP w0.13: GPU1.E15 62.95,195.55 v6(62.8,195.55) ; VRAMB2.C2 v6(55.5,215.3)
  L6 w0.11: v6(62.8,195.55) 62.8,198.81 62.66,198.94 62.66,202.83 56.73,208.76 56.73,214.65 56.39,214.98 55.82,214.98 v6(55.5,215.3)
EDCB1_1: length 25.1
  TOP w0.13: VRAMB2.C13 v6(46.7,215.3) ; v6(58,196.55) 58.05,196.55 GPU1.D9
  L6 w0.089: v6(46.7,215.3) 47.1,214.9 47.66,214.9 47.9,214.66 47.9,213.81 48.54,213.17 48.54,212.77
  L6 w0.11: v6(58,196.55) 58,196.75 57.3,197.45 57.3,198.88 49.38,206.8 49.38,211.94 48.54,212.77
EDCB1_2: length 30.3
  TOP w0.13: GPU1.A12 61,202.97 60.19,203.78 60.19,206.13 58.16,208.16 58.16,212.46 58.96,213.26 58.96,223.84 57.86,224.94 57.48,224.94 57.48,224.94 57.13,224.94 57.12,224.94 56.87,224.94 56.85,224.93 56.55,224.93 56.53,224.94 56.26,224.94 VRAMB2.R2
EDCB1_3: length 33.2
  TOP w0.13: GPU1.B5 54.56,198.24 54.56,200.59 49.59,205.56 49.59,207.67 48,209.26 47.99,209.26 46.27,210.98 46.27,210.99 44.99,212.27 44.99,224.27 45.59,224.86 46.66,224.86 VRAMB2.R13
EDCC0_0: length 33.8
  TOP w0.13: VRAMC1.C13 24.95,203.15 25.13,203.33 25.13,203.85 25.13,203.86 25.13,204.47 26.46,205.8 36.15,205.8 39.76,202.2 40.39,202.2 41.38,201.21 41.49,201.21 42.14,200.56 44.3,200.56 49.41,195.44 51.76,195.44 GPU1.E2
EDCC0_1: length 30.3
  TOP w0.13: VRAMC1.C2 25.07,193.73 25.07,193.45 25.07,192.91 25.08,192.89 25.08,192.12 26.16,191.04 36.74,191.04 36.84,191.13 37.69,191.13 37.97,191.41 38.13,191.41 38.56,191.84 41.84,191.84 43.67,190.01 44.84,190.01 45.85,189 GPU1.M1
EDCC0_2: length 25.5
  TOP w0.13: GPU1.J4 54,191.45 v6(53.45,192) ; v6(34.7,203.3) VRAMC1.R13
  L6 w0.089: 36.84,202.1 35.33,202.1 35.1,202.33 35.1,202.9 v6(34.7,203.3)
  L6 w0.11: v6(53.45,192) 53.25,192 52.41,192.84 50.98,192.84 50.21,193.61 50.21,194.22 43.58,200.84 38.1,200.84 36.84,202.1
EDCC0_3: length 26.3
  TOP w0.13: GPU1.R5 54.45,187.05 v6(54.45,187.2) ; v6(34.7,194.5) VRAMC1.R2
  L6 w0.11: v6(34.7,194.5) 34.7,193.85 35.27,193.28 35.67,193.28 35.68,193.27 35.8,193.27 36.49,192.58 37.65,192.58 37.75,192.48 37.75,192.3 37.86,192.19 38.52,192.19 38.63,192.3 38.63,192.49 38.74,192.59 39.37,192.59 39.48,192.49 39.48,192.3 39.59,192.19 40.24,192.19 40.36,192.31 40.36,192.49 40.47,192.6 41.16,192.6 41.27,192.49 41.27,192.31 41.38,192.2 42.01,192.2 42.14,192.33 42.14,192.49 42.24,192.59 43.43,192.59 48.71,187.31 51.15,187.31 51.43,187.04 54.29,187.04 v6(54.45,187.2)
EDCC1_0: length 33.6
  TOP w0.13: VRAMC2.R13 25.08,175.22 25.08,174.03 26.54,172.57 31.72,172.57 31.95,172.8 38.52,172.8 42.34,176.62 42.49,176.62 42.49,176.62 44.97,176.62 45.45,177.1 49.9,177.1 50.24,177.44 53.24,177.44 GPU1.AD4
EDCC1_1: length 29.4
  TOP w0.13: VRAMC2.R2 25.13,184.83 25.13,185.54 25.2,185.61 25.2,185.98 26.12,186.9 37.51,186.9 39.69,184.72 42.07,184.72 42.2,184.59 50.91,184.59 GPU1.V1
EDCC1_2: length 26.2
  TOP w0.13: GPU1.W9 58.2,183.15 v6(57.75,183.6) ; VRAMC2.C2 v6(34.7,184.8)
  L6 w0.11: v6(57.75,183.6) 56.97,182.82 55.16,182.82 54.76,182.43 50.35,182.43 49.98,182.8 45.78,182.8 44.73,183.85 44.45,183.85 43.06,185.24 35.71,185.24 35.68,185.21 35.33,185.21 35.32,185.2 35.11,185.2 v6(34.7,184.8)
EDCC1_3: length 23.6
  TOP w0.13: VRAMC2.C13 v6(34.7,175.2) ; v6(55.35,177.6) 55.35,177.75 GPU1.AD6
  L6 w0.089: 35.57,176.54 35.29,176.54 35.1,176.35 35.1,175.83 34.7,175.43 v6(34.7,175.2)
  L6 w0.11: v6(55.35,177.6) 55.19,177.76 50.26,177.76 50.12,177.62 45.32,177.62 44.77,177.07 43.7,177.07 43.27,176.65 37.93,176.65 37.82,176.54 35.57,176.54
EDCD0_0: length 27.5
  TOP w0.13: v6(56.15,174) 56.6,174.45 GPU1.AG7 ; VRAMD1.R13 v6(34.7,166.3)
  L6 w0.11: v6(34.7,166.3) 36.03,164.97 37.17,164.97 41.83,169.63 42.66,169.63 46.58,173.54 50.08,173.54 50.36,173.82 50.82,173.82 50.9,173.74 53.69,173.74 53.94,173.99 54.69,173.99 55.09,173.59 55.18,173.59 55.52,173.59 55.52,173.59 55.74,173.59 v6(56.15,174)
EDCD0_1: length 29.1
  TOP w0.13: GPU1.AR4 53.55,168.15 v6(53.55,168) ; VRAMD1.R2 v6(34.7,157.5)
  L6 w0.089: 36.88,156.28 35.69,156.28 35.67,156.3 35.33,156.3 35.1,156.53 35.1,157.08 34.7,157.48 v6(34.7,157.5)
  L6 w0.11: v6(53.55,168) 53.07,168.48 52.25,168.48 51.67,167.9 49.74,167.9 40.6,158.76 40.35,158.76 40.09,159.02 39.92,159.02 39.47,158.57 39.47,158.39 39.81,158.06 39.81,157.8 39.41,157.41 39.2,157.41 38.79,157.81 38.64,157.81 38.15,157.32 38.15,157.18 38.56,156.76 38.56,156.6 38.11,156.16 37.8,156.16 37.37,156.59 37.17,156.59 36.88,156.3 36.88,156.28
EDCD0_2: length 33.1
  TOP w0.13: VRAMD1.C13 25.14,166.34 25.14,167.48 26.47,168.81 27.53,168.81 27.78,169.06 36.54,169.06 37.66,167.94 40.34,167.94 40.41,168.02 41.38,168.02 44.3,170.94 46.02,172.66 52.36,172.66 GPU1.AJ3
EDCD0_3: length 35.2
  TOP w0.13: GPU1.AV2 51.76,165.76 50.3,165.76 43.79,159.25 40.95,159.25 38.2,156.5 38.2,155.9 36.2,153.9 26.4,153.9 25.05,155.25 25.05,155.85 25.04,155.86 25.04,156.12 25.07,156.15 25.07,156.45 25.07,156.73 VRAMD1.C2
EDCD1_0: length 17.4
  TOP w0.13: VRAMD2.C2 v6(52,152.7) ; v6(56.86,165.38) 56.98,165.38 GPU1.AV8
  L6 w0.089: v6(52,152.7) 51.6,153.1 51.03,153.1 50.8,153.33 50.8,154.78 50.95,154.93
  L6 w0.11: 50.95,154.93 52.4,156.37 52.4,157.74 55.1,160.44 55.1,161.04 55.68,161.62 55.68,162.36 56.01,162.69 56.01,163.35 56.03,163.37 56.03,163.73 56.01,163.75 56.01,164.27 56.03,164.29 56.03,164.71 56.7,165.38 v6(56.86,165.38)
EDCD1_1: length 15.3
  TOP w0.13: VRAMD2.C13 v6(60.8,152.7) ; v6(62.8,164.45) 62.95,164.45 GPU1.AW15
  L6 w0.089: v6(60.8,152.7) 60.57,152.7 60.17,153.1 59.83,153.1 59.64,153.29 59.6,153.33 59.6,154.13 59.6,154.78 59.59,154.79
  L6 w0.11: v6(62.8,164.45) 62.39,164.04 62.39,163.73 62.39,163.72 62.39,163.38 62.39,163.37 62.39,161.97 61.79,161.36 61.79,158.46 59.59,156.26 59.59,154.79
EDCD1_2: length 24.4
  TOP w0.13: GPU1.BB6 55.74,161.74 55.74,160.39 54.68,159.33 54.68,159.25 52.8,157.38 51.52,156.1 51.16,156.1 49.06,154 49.06,144.14 50,143.2 50.39,143.2 50.46,143.13 51.17,143.13 VRAMD2.R2
EDCD1_3: length 23.9
  TOP w0.13: GPU1.BA15 62.81,162.51 62.81,161.95 62.69,161.82 62.69,160.25 62.81,160.12 62.81,155 63.39,154.42 63.71,154.1 63.81,154 63.81,152.26 64.5,151.56 64.5,145.55 62.04,143.09 61.98,143.09 61.97,143.08 61.63,143.08 61.62,143.09 61.58,143.09 61.57,143.1 60.8,143.1 60.47,142.77 VRAMD2.R13
EDP_CABLE_DET: length 90.9
  TOP w0.114: v1(112.03,47.78) 112.85,46.96 KBC1.55 ; LAUOC1.25 135.25,7.93 135.01,8.17 v3(135.01,8.8) 135.04,8.8 v1(135.64,9.39)
  L4 w0.114: v1(112.03,47.78) 111.16,46.91 111.16,46.84 110.18,45.86 109.92,45.86 108.48,44.42 108.48,44.39 105.66,41.57 105.66,40.75 101.52,36.62 101.52,36.2 99.35,34.02 95.69,34.02 94.98,33.31 94.98,21.35 95.17,21.15 95.17,20.74 98.77,17.15 98.77,15.38 105.53,8.62 109.44,8.62 111.1,6.96 113.37,6.96 114.16,7.75 116.08,7.75 116.1,7.78 123.19,7.78 124.21,8.8 126,8.8 127.03,7.77 128.55,7.77 129.39,8.61 132.38,8.61 132.39,8.61 132.78,8.61 133.56,9.39 v1(135.64,9.39)
EFUSE_PWR: length 2.3
  TOP w0.305: PCH1.Y21 v6(167.4,39.4)
  BOTTOM w0.508: R161.2 167.37,39.37 v6(167.4,39.4) 167.6,39.6 v2(168.25,39.6)
EGPIO97: length 43.6
  TOP w0.114: CPU1.AW12 146.43,171 142.74,167.3 142.74,166.56 141.68,165.51 140.85,165.06 140.67,164.97 139.7,164.97 139.62,164.89 138.96,164.89 138.77,164.7 137.81,164.7 137.81,164.69 135.71,164.69 135.23,164.21 v1(135.23,164.13) ; v1(135.33,144.98) 135.33,145.64 v3(134.97,146) 134.85,146.12 RN2402.4
  L3 w0.114: v1(135.33,144.98) 132.84,147.47 132.84,151.47 132.25,152.07 132.25,155.36 133.21,156.32 133.21,157.2 134.05,158.05 134.05,159.68 133.64,160.1 133.64,162.54 v1(135.23,164.13)
ESPI_RESET_L/KBRST_L: length 4.9
  TOP w0.114: CPU1.AN24 157,158.93 v6(157.5,158.42)
  BOTTOM w0.114: v6(157.5,158.42) 157.12,158.04 155.98,158.04 v2(155.75,158.27) 155.35,158.27 155.02,157.94 155.02,157.19 R37.1
FB_VDDC_VR: length 80.6
  TOP w0.114: v6(68.86,170.97) 68.86,171.01 69.25,171.4 GPU1.AL21
  L6 w0.102: v6(68.86,170.97) 69.06,170.76 70.59,170.76 71.07,170.28 71.07,158.19 70.48,157.61 70.48,154.31 71.55,153.24 v1(71.55,152.83)
  BOTTOM w0.114: PR252.2 118.76,156.17 118.41,156.51 117.99,156.51 117.26,157.25 117.26,157.29 114.73,159.82 114,159.82 113.4,160.41 111.23,160.41 108.76,157.94 v2(108.76,157.73) 108.76,155.61 105.92,152.77 105.92,150.57 105.59,150.24 100.69,150.24 97.22,153.71 78.52,153.71 77.57,152.76 75.52,152.76 74.29,151.54 72.85,151.54 v1(71.55,152.83)
FB_VDDCI: length 87.9
  TOP w0.114: GPU1.AK23 70.3,172.2 v6(69.96,171.86) ; PR261.1 v3(116.38,137.38) 116.35,137.38 116.07,137.1 109.99,137.1 108.64,138.46 106.4,138.46 102.79,142.07 102.79,147.62 105.79,150.62 105.79,155.47 104.95,156.32 v1(103.99,156.32)
  L6 w0.102: v6(69.96,171.86) 71.65,170.17 71.65,163.35 72.19,162.81 72.19,154.97 v1(71.91,154.69)
  BOTTOM w0.114: v1(71.91,154.69) 72.38,154.21 72.38,152.99 72.85,152.53 73.99,152.53 74.96,153.49 76.73,153.49 77.64,154.39 98.77,154.39 100.69,156.32 v1(103.99,156.32)
FB_VSSC: length 97.4
  TOP w0.114: v1(118.14,157.25) 118.9,157.25 119.56,156.59 119.56,155.5 119.1,155.04 PR254.2 ; v6(68.8,171.75) 69.25,172.2 GPU1.AK21 ; v1(118.85,144.5) 118.85,144.4 120.3,142.95 PR263.1
  L6 w0.102: v6(68.8,171.75) 68.91,171.75 69.42,172.27 70.13,172.27 70.67,171.72 70.67,171.52 71.96,170.24 71.96,163.33 72.39,162.9 72.39,154.46 v1(71.7,153.77)
  BOTTOM w0.114: v1(118.85,144.5) 118.09,145.26 118.09,150.52 116.96,151.65 116.96,154.35 117.55,154.94 118.94,154.94 119.21,155.2 119.21,156.79 118.59,157.4 118.31,157.4 118.16,157.25 v1(118.14,157.25) 117.98,157.4 117.63,157.4 114.88,160.15 v5(114.88,160.38) 114.51,160.75 111.09,160.75 108.61,158.27 108.54,158.27 106.09,155.83 100.69,155.83 98.91,154.05 78.05,154.05 77.14,153.14 75.18,153.14 74.04,151.99 72.9,151.99 72.04,152.85 72.04,153.44 v1(71.7,153.77)
FDT_OVRD_GPIO: length 141.1
  TOP w0.114: Q36.C 116.12,82.09 R459.2 117.08,82.05 v1(117.34,82.32) ; v6(157.48,174.5) 157.48,174.51 157.46,174.53 CPU1.AN8 ; R134.1 R130.1 140.03,145.03 140.72,145.72 v1(140.72,146.56)
  L4 w0.114: v1(142.88,89.69) 142.88,91.19 142.44,91.62 142.44,95.22 143.87,96.65 143.87,114.5 144.27,114.91 144.27,126.8 144.02,127.05 144.02,143.08 140.72,146.38 v1(140.72,146.56) 143.59,149.43 143.59,153.8 143.87,154.08 143.87,157.95 147.45,161.53 147.45,164.72 148.13,165.4 148.13,169.91 149.16,170.94 150.57,170.94 155.56,175.93 158.75,175.93 158.98,175.7 158.98,175.29 158.69,175.01 157.99,175.01 v6(157.48,174.5)
  BOTTOM w0.114: v1(142.88,89.69) v5(140.53,89.69) 139.42,89.69 138.75,89.01 134,89.01 133.49,89.52 129.66,89.52 128.31,90.88 122.81,90.88 122.06,90.13 122.06,86.91 120.82,85.67 118.94,85.67 117.84,84.56 117.84,83.42 117.35,82.93 117.35,82.33 v1(117.34,82.32)
FDT_OVRD_GPIO_C: length 35.9
  TOP w0.114: v1(116.71,80.19) 116.15,80.75 R459.1
  L3 w0.114: v1(116.71,80.19) 118.62,78.29 118.62,74.17 119.51,73.28 124.4,73.28 125.96,71.72 125.96,63.37 128.02,61.31 128.02,58.43 127.23,57.63 127.23,55.91 JMP1.1
  BOTTOM w0.114: v5(116.08,80.77) 116.13,80.77 v1(116.71,80.19)
FWH_ID0: length 7
  TOP w0.114: LPC1.6 123.17,79.34 127.29,79.34 v3(127.48,79.15) 127.64,78.99 R458.2
G2042_VDDCR_C: length 6.1
  TOP w0.356: U17.3 131.25,205.94 130.94,206.25 C450.1
  TOP w0.508: C450.1 130.94,207.14 131.44,207.65 R2605.2 131.32,208.15 R2606.2 129.92,208.41 129.92,209.51 v3(129.96,209.55)
GPIO_6_TACH: length 88
  TOP w0.114: GPU1.AE34 81,176.71 v6(80.7,176.4) ; R2634.2 110.19,140.87 v1(109.91,140.59)
  L4 w0.114: v1(109.91,140.59) 109.91,141.12 111.33,142.55 111.33,151.4 110.31,152.42 110.31,156.57 110.32,156.59 110.32,158.93 109.73,159.53 109.73,165.23 109.67,165.28 109.67,166.09 110.28,166.7 111.35,166.7 114.19,169.55 114.19,182.4 v1(110.36,186.23)
  L6 w0.102: v6(80.7,176.4) 81.45,176.4 81.86,176.81 89.26,176.81 90.09,175.97 99.82,175.97 110.08,186.23 v1(110.36,186.23)
  BOTTOM w0.114: v6(80.7,176.4) 81.14,175.95 TP2505.1
GPP_CLK0N: length 201.4
  TOP w0.102: v1(160.34,61.08) 159.97,60.71 159.97,58.59 159.06,57.68 ; v3(159.33,57.4) 159.06,57.68 ; 159.06,57.68 157.05,55.67 157.05,55.35 PCH1.A9
  L4 w0.102: v1(149.58,184.28) 149.43,184.43 148.44,184.43 146.02,182.02 130.03,182.02 121.84,173.83 121.84,169.21 121.21,168.58 121.21,139.31 118.77,136.87 118.77,131.69 118.34,131.26 118.34,117.99 119.15,117.18 119.15,114.64 120.7,113.09 120.7,111.28 115.27,105.84 115.27,100.63 113.82,99.19 113.82,94.79 115.85,92.76 115.85,88.29 114.76,87.2 114.76,84.23 119.13,79.86 119.13,69.81 120.18,68.76 128.19,68.76 134.39,62.56 139.16,62.56 139.93,63.33 150.95,63.33 151.96,64.34 157.73,64.34 158.26,63.81 158.4,63.81 158.62,63.6 158.62,63.46 158.83,63.24 158.97,63.24 159.19,63.03 159.19,62.89 159.4,62.67 159.54,62.67 159.76,62.45 159.76,62.31 159.97,62.1 159.97,61.45 v1(160.34,61.08)
  BOTTOM w0.102: R2653.1 150.51,184.45 149.76,184.45 v1(149.58,184.28)
GPP_CLK0N_R: length 18.8
  TOP w0.102: CPU1.AG6 v6(162.5,177.5)
  L4 w0.102: v6(162.5,177.5) 162.1,177.9 161.25,177.9 160.99,177.65 160.24,177.65 159.31,178.58 159.31,182.67 156.28,185.7 153.99,185.7 153.59,185.31 153.59,184.86 v1(153.71,184.74)
  BOTTOM w0.102: v2(153.06,184) 152.81,184.25 ; 152.81,184.25 152.76,184.2 152.36,184.2 R2653.2 ; 152.81,184.25 153.3,184.74 v1(153.71,184.74)
GPP_CLK0P: length 201.4
  TOP w0.102: PCH1.A8 156.84,55.24 156.84,55.75 159.77,58.67 159.77,59.77 ; 159.77,59.77 v3(159.36,59.77) ; 159.77,59.77 159.77,60.74 v1(159.4,61.1)
  L4 w0.102: v1(150.22,184.94) 149.5,184.94 149.2,184.63 148.35,184.63 145.94,182.22 129.95,182.22 121.64,173.91 121.64,169.3 121.01,168.66 121.01,139.4 118.57,136.96 118.57,131.78 118.14,131.34 118.14,117.91 118.95,117.09 118.95,114.55 120.5,113 120.5,111.36 115.06,105.93 115.06,100.72 113.61,99.27 113.61,94.71 115.65,92.68 115.65,88.37 114.55,87.28 114.55,84.14 118.92,79.77 118.92,69.72 120.09,68.55 128.11,68.55 134.31,62.36 139.24,62.36 140.02,63.13 151.03,63.13 152.04,64.14 157.65,64.14 159.77,62.01 159.77,61.47 v1(159.4,61.1)
  BOTTOM w0.102: R2652.1 150.89,184.66 150.5,184.66 v1(150.22,184.94)
GPP_CLK0P_R: length 18.4
  TOP w0.102: CPU1.AG5 v6(162.5,178.5)
  L4 w0.102: v6(162.5,178.5) 162.1,178.1 161.16,178.1 160.91,177.85 160.32,177.85 159.51,178.66 159.51,182.75 156.36,185.91 153.9,185.91 153.06,185.06 v1(152.86,185.06)
  BOTTOM w0.102: R2652.2 152.01,184.77 152.37,184.4 152.67,184.4 152.86,184.59 v1(152.86,185.06)
GPU_AUX_ZVSS: length 1.4
  TOP w0.114: GPU1.AY24 72,164 v6(72.4,163.6)
  BOTTOM w0.114: R720.1 72.39,163.59 v6(72.4,163.6)
GPU_BLON_PWM: length 12.1
  TOP w0.114: GPU1.AL26 74.37,171.4 v6(74.75,171.02)
  BOTTOM w0.114: R2579.1 80,162.8 v2(79.58,163.22) 79.57,163.23 R504.2 78.23,165.54 78.23,166.5 76.04,168.69 76.04,169.87 75.73,170.18 75.46,170.18 74.75,170.89 v6(74.75,171.02)
GPU_DP_ZVDD_08: length 4.7
  TOP w0.114: GPU1.AT36 82.61,167.39 v6(83.44,167.39)
  BOTTOM w0.114: R718.2 81.88,170.08 82.68,169.29 v2(82.68,168.49) 82.68,168.15 v6(83.44,167.39)
GPU_DP_ZVSS: length 2.2
  TOP w0.114: v6(83.2,165.37) 82.78,165.8 GPU1.AV36
  BOTTOM w0.114: R719.2 83.97,164.61 v6(83.2,165.37)
GPU_DPLUS: length 224.6
  TOP w0.114: GPU1.AC35 81.8,179.15 81.46,178.81 v6(81.46,178.79) ; v1(83.44,53.34) 83.82,52.96 84.2,52.96 85.52,51.64 93.95,51.64 94.11,51.49 v1(94.23,51.49) ; KBC1.108 112.05,57.92 110.29,56.16 110.29,55.6 v1(110.29,55.6)
  L3 w0.114: v1(111.05,51.64) 111.05,51.69 110.84,51.9 109.3,51.9 108.82,51.9 108.11,52.61 98.7,52.61 97.99,51.89 94.92,51.89 94.51,51.49 v1(94.23,51.49)
  L4 w0.114: v1(110.29,55.6) 111.07,55.6 111.86,54.82 111.86,52.5 111.1,51.74 111.1,51.69 v1(111.05,51.64) ; v1(104.9,183.59) 98.16,176.85 98.16,169.71 99.93,167.94 100.1,167.94 100.46,167.58 100.46,165.67 100.17,165.37 100.17,157.92 101.78,156.31 101.78,150.65 102.06,150.37 102.64,150.37 105,148.01 105,145.76 105.96,144.8 105.96,135.99 105.4,135.43 105.4,129.32 111.51,123.21 111.51,119.63 110.24,118.36 110.24,112.64 103.36,105.77 97.02,105.77 90.14,98.89 90.14,86.59 83.1,79.55 83.1,54.64 83.44,54.31 v1(83.44,53.34)
  L6 w0.102: v1(104.9,183.59) 99.52,178.21 92.25,178.21 92.15,178.31 81.94,178.31 81.46,178.79 v6(81.46,178.79)
  BOTTOM w0.114: v1(111.05,51.64) 110.9,51.64 110.66,51.4 C1121.1 ; v2(94.9,51.96) 94.7,51.96 v1(94.23,51.49)
GPU_EDP_AUX_SCL: length 6.9
  TOP w0.102: 10.52,154.28 9.86,154.28 9.24,154.9 7.89,154.9 7.75,154.75 DISPC2.18 ; 10.52,154.28 v3(10.52,153.9) ; 10.52,154.28 12.6,154.28 C955.2
GPU_EDP_AUX_SCL_C: length 153.1
  TOP w0.102: GPU1.AU27 75.1,166.3 74.92,166.3 74.7,166.08 74.7,158.17 72.48,155.96 71.81,155.96 v1(71.65,156.11) ; C955.1 14.67,153.89 v1(14.73,153.95)
  L4 w0.102: v1(14.73,153.95) 15.09,154.31 16.69,154.31 16.99,154 20.26,154 24.82,149.45 24.82,148.66 24.82,139.78 28.19,136.4 30.04,136.4 34.24,132.2 34.24,118.19 33.88,117.84 33.88,115.1 35.2,113.79 69.26,113.79 69.95,114.49 69.95,121.37 68.66,122.67 68.66,137.78 65.66,140.77 v1(65.66,141.12)
  BOTTOM w0.102: v1(65.66,141.12) 65.96,140.71 66.06,140.69 66.23,140.69 66.51,140.97 69.47,140.97 69.98,141.48 69.98,146.02 68.12,147.87 68.12,149.91 70.15,151.94 70.15,154.92 70.58,155.35 ; v1(71.65,156.11) 71.65,155.98 71.37,155.7 70.93,155.7 70.58,155.35 ; 70.58,155.35 v2(70.33,155.6)
GPU_EDP_AUX_SDA: length 6.9
  TOP w0.102: 11.68,154.48 12.54,154.48 C956.2 ; 11.68,154.48 v3(11.68,154.86) ; 11.68,154.48 9.95,154.48 9.33,155.1 7.89,155.1 7.75,155.25 DISPC2.19
GPU_EDP_AUX_SDA_C: length 153
  TOP w0.102: C956.1 14.67,154.93 v1(14.73,154.86) ; v1(71.7,155.42) 72.03,155.75 72.57,155.75 74.9,158.08 74.9,166 75,166.1 75.1,166.1 GPU1.AV27
  L4 w0.102: v1(65.51,140.21) 65.56,140.26 65.89,140.26 68.45,137.69 68.45,122.58 69.75,121.29 69.75,114.57 69.17,114 35.28,114 34.09,115.19 34.09,117.75 34.44,118.11 34.44,132.28 30.12,136.61 28.27,136.61 25.02,139.86 25.02,140.17 25.12,140.26 25.12,140.57 25.02,140.67 25.02,140.97 25.12,141.07 25.12,141.38 25.02,141.48 25.02,141.78 25.12,141.88 25.12,142.18 25.02,142.28 25.02,145.56 25.12,145.66 25.12,145.96 25.02,146.06 25.02,146.37 25.12,146.47 25.12,146.77 25.02,146.87 25.02,147.17 25.12,147.27 25.12,147.58 25.02,147.68 25.02,147.98 25.02,149.53 24.65,149.9 24.65,150.04 24.43,150.26 24.29,150.26 24.08,150.47 24.08,150.61 23.86,150.83 23.72,150.83 23.51,151.04 23.51,151.18 23.29,151.4 23.15,151.4 21.75,152.79 21.75,152.93 21.54,153.15 21.4,153.15 21.18,153.37 21.18,153.51 20.97,153.72 20.83,153.72 20.35,154.2 17.07,154.2 16.77,154.51 15.96,154.51 15.86,154.61 15.56,154.61 15.46,154.51 15.09,154.51 v1(14.73,154.86)
  BOTTOM w0.102: v1(65.51,140.21) 65.92,140.51 66.04,140.49 66.32,140.49 66.6,140.77 69.55,140.77 70.18,141.39 70.18,146.1 68.33,147.96 68.33,149.83 69.77,151.27 ; v1(71.7,155.42) 71.6,155.42 71.53,155.5 71.02,155.5 70.36,154.84 70.36,151.86 69.77,151.27 ; v2(70,151.03) 69.77,151.27
GPU_EDP_HPD: length 196.8
  TOP w0.114: R2750.1 91.69,161.59 v1(91.64,161.54) ; DISPC2.3 8.28,147.25 8.59,146.94 8.59,146.93 10.09,145.44 v1(10.74,145.44)
  L6 w0.102: v1(10.74,145.44) 10.74,141.5 11.4,140.84 13.08,140.84 15.62,138.3 15.62,136.88 18.47,134.04 19.17,134.04 19.48,133.73 19.48,131.9 20.29,131.09 20.29,130.68 21.25,129.72 21.25,124.89 21.44,124.7 21.44,116.59 28.55,109.47 98.12,109.47 98.58,109.93 102.87,109.93 107.37,114.43 107.37,122.05 105.94,123.47 105.94,133.02 106.91,133.99 106.91,134.6 106.41,135.1 106.4,135.1 104.75,136.75 104.75,138.76 104.47,139.04 104.47,142.51 103.94,143.05 103.94,143.05 99.24,147.75 99.22,147.75 95.84,151.13 95.83,151.13 91.74,155.22 91.74,161.44 v1(91.64,161.54)
  BOTTOM w0.114: R2748.2 R2749.2 84.71,160.66 84.84,160.78 v2(87.49,160.78) 90.88,160.78 v1(91.64,161.54)
GPU_EDP_HPD3: length 8.3
  TOP w0.114: v6(77.2,166.95) 76.75,167.4 GPU1.AT29
  BOTTOM w0.114: R2748.1 80.01,161.7 v2(79.81,161.9) 79.38,161.9 77.98,163.3 77.98,165.99 77.2,166.77 v6(77.2,166.95)
GPU_EDP_HPD4: length 8.4
  TOP w0.114: GPU1.AU29 76.75,166.6 v6(77.2,166.15)
  BOTTOM w0.114: v6(77.2,166.15) 77.73,165.62 77.73,164.58 v2(77.44,164.29) 77.44,163.4 80.19,160.66 R2749.1
GPU_EDP_IN0N: length 7.9
  TOP w0.102: C920.2 12.66,146.09 11.84,146.09 ; v3(11.84,146.48) 11.84,146.09 ; 11.84,146.09 11.15,146.09 8.14,149.1 7.89,149.1 7.75,149.25 DISPC2.7
GPU_EDP_IN0N_C: length 142.8
  TOP w0.102: 70.23,151.28 70.23,151.8 70.41,151.98 70.41,156.98 72.3,158.87 72.3,163 72.2,163.1 GPU1.BA24 ; 70.23,151.28 v3(69.85,151.28) ; 70.23,151.28 70.23,149.46 69.87,149.1 69.32,149.1 v1(68.96,149.45) ; v1(14.86,146.41) 14.84,146.43 C920.1
  L4 w0.102: v1(14.86,146.41) 15.21,146.05 16.59,146.05 17.63,145.01 17.63,144.45 20.7,141.38 20.7,130.33 22.12,128.91 22.12,118.42 22.34,118.21 22.48,118.21 22.69,117.99 22.69,117.85 22.91,117.64 23.05,117.64 23.27,117.42 23.27,117.28 23.48,117.07 23.62,117.07 23.84,116.85 23.84,116.71 29.4,111.15 70.38,111.15 72.59,113.36 72.59,122.63 71.35,123.88 71.35,140.05 70.23,141.17 70.23,146.07 68.05,148.25 68.05,148.84 68.3,149.1 68.61,149.1 v1(68.96,149.45)
GPU_EDP_IN0P: length 7.9
  TOP w0.102: C919.2 12.62,145.89 11.06,145.89 10.2,146.75 ; 10.2,146.75 8.05,148.9 7.89,148.9 7.75,148.75 DISPC2.6 ; 10.2,146.75 v3(9.91,146.46)
GPU_EDP_IN0P_C: length 142.9
  TOP w0.102: v3(72.03,157.76) 71.75,158.04 ; 71.75,158.04 72.5,158.79 72.5,163 72.6,163.1 GPU1.BA25 ; 71.75,158.04 70.61,156.9 70.61,151.89 70.43,151.71 70.43,149.38 69.95,148.89 69.32,148.89 v1(68.96,148.54) ; C919.1 14.84,145.51 v1(14.86,145.49)
  L4 w0.102: v1(14.86,145.49) 15.21,145.85 16.5,145.85 17.42,144.92 17.42,144.37 20.5,141.29 20.5,130.24 21.92,128.82 21.92,118.34 29.31,110.95 70.47,110.95 72.8,113.28 72.8,122.72 71.55,123.96 71.55,140.13 70.43,141.25 70.43,146.15 68.25,148.34 68.25,148.76 68.38,148.89 68.61,148.89 v1(68.96,148.54)
GPU_EDP_IN1N: length 11.4
  TOP w0.102: 11.79,148.1 16.35,148.1 C922.2 ; 11.79,148.1 11.02,148.1 8.52,150.6 7.89,150.6 7.75,150.75 DISPC2.10 ; 11.79,148.1 v3(11.79,148.49)
GPU_EDP_IN1N_C: length 140.8
  TOP w0.102: v1(20.31,145.97) 19.89,146.39 19.89,146.85 19.54,147.2 ; GPU1.BB24 71.45,161.85 71.27,161.85 71.05,161.63 71.05,159.62 69.62,158.19 69.62,153.04 69.44,152.86 69.04,152.86 v1(68.73,153.16) ; C922.1 18,148.11 18.63,148.11 19.54,147.2 ; v3(19.81,147.47) 19.54,147.2
  L4 w0.102: v1(20.31,145.97) 19.99,145.64 19.99,145.3 20.2,145.08 20.83,145.08 21.41,144.5 21.41,131.27 22.81,129.87 23.47,129.87 23.67,130.07 23.67,131.05 23.92,131.29 24.4,131.29 24.65,131.05 24.65,128.03 31.19,121.49 31.19,114.81 34.14,111.86 70.07,111.86 71.88,113.67 71.88,122.2 70.64,123.44 70.64,139.65 69.44,140.84 69.44,145.53 68.74,146.23 68.6,146.23 68.39,146.45 68.39,146.59 68.17,146.8 68.03,146.8 67.82,147.02 67.82,147.16 67.6,147.38 67.46,147.38 67.25,147.59 67.25,147.73 67.03,147.95 67.03,152.08 67.76,152.81 68.38,152.81 v1(68.73,153.16)
GPU_EDP_IN1P: length 11.6
  TOP w0.102: 10.16,148.67 10.93,147.9 16.36,147.9 16.79,147.47 C921.2 ; 10.16,148.67 8.44,150.4 7.89,150.4 7.75,150.25 DISPC2.9 ; 10.16,148.67 v3(9.88,148.39)
GPU_EDP_IN1P_C: length 140.6
  TOP w0.102: v3(70.23,157.63) 69.82,157.63 ; 69.82,157.63 69.82,152.96 69.52,152.65 69.14,152.65 v1(68.73,152.25) ; 69.82,157.63 69.82,158.11 71.25,159.53 71.25,161.55 71.35,161.65 71.45,161.65 GPU1.BC24 ; v1(19.4,145.97) 19.68,146.26 19.68,146.76 18.54,147.9 18.16,147.9 C921.1
  L4 w0.102: v1(68.73,152.25) 68.38,152.6 67.84,152.6 67.23,151.99 67.23,148.03 69.65,145.62 69.65,140.93 70.84,139.73 70.84,123.53 72.09,122.28 72.09,113.59 70.15,111.66 34.05,111.66 30.99,114.72 30.99,121.4 24.45,127.94 24.45,130.96 24.32,131.09 24,131.09 23.88,130.96 23.88,129.99 23.55,129.67 22.72,129.67 21.21,131.18 21.21,144.42 20.74,144.88 20.12,144.88 19.79,145.21 19.79,145.59 v1(19.4,145.97)
GPU_EDP_IN2N: length 7.4
  TOP w0.102: 11.68,150.27 10.62,150.27 8.78,152.1 7.89,152.1 7.75,152.25 DISPC2.13 ; 11.68,150.27 12.67,150.27 C924.2 ; 11.68,150.27 v3(11.68,150.67)
GPU_EDP_IN2N_C: length 144.8
  TOP w0.102: 68.55,155.4 69.04,155.88 69.04,159.05 70.03,160.05 70.03,161.23 70.22,161.43 70.47,161.43 GPU1.BC23 ; 68.55,155.4 68.2,155.04 68.2,146.43 67.36,145.59 67.36,144.2 67.06,143.89 66.65,143.89 v1(66.24,143.48) ; 68.55,155.4 v3(68.83,155.12) ; C924.1 13.95,150.59 14.3,150.24 15.85,150.24 v1(16.18,150.57)
  L4 w0.102: v1(16.18,150.57) 16.54,150.22 17.48,150.22 18.97,148.73 19.11,148.73 19.32,148.51 19.32,148.37 19.54,148.16 19.68,148.16 19.9,147.94 19.9,147.8 20.11,147.59 20.25,147.59 20.47,147.37 20.47,147.23 22.33,145.37 22.33,145.07 22.43,144.97 22.43,144.66 22.33,144.56 22.33,144.26 22.43,144.16 22.43,143.86 22.33,143.76 22.33,143.45 22.43,143.35 22.43,143.05 22.33,142.95 22.33,140.37 22.43,140.27 22.43,139.96 22.33,139.86 22.33,137.87 22.43,137.77 22.43,137.47 22.33,137.37 22.33,137.06 22.43,136.96 22.43,136.66 22.33,136.56 22.33,136.25 22.43,136.15 22.43,135.85 22.33,135.75 22.33,135.14 22.84,134.62 25.1,134.62 25.26,134.78 25.56,134.78 25.66,134.88 25.97,134.88 26.07,134.78 29.58,134.78 32.92,131.44 32.92,121.41 32.08,120.57 32.08,114.94 34.44,112.57 69.77,112.57 71.17,113.98 71.17,121.89 69.93,123.14 69.93,139.12 67.03,142.01 67.03,143.63 66.82,143.84 66.6,143.84 v1(66.24,143.48)
GPU_EDP_IN2P: length 7.4
  TOP w0.102: DISPC2.12 7.75,151.75 7.89,151.9 8.7,151.9 10,150.59 ; 10,150.59 10.53,150.06 12.61,150.06 C923.2 ; 10,150.59 v3(9.73,150.32)
GPU_EDP_IN2P_C: length 144.8
  TOP w0.102: 68.83,157.61 68.83,155.96 68,155.13 68,146.52 67.16,145.68 67.16,144.28 66.97,144.09 66.55,144.09 v1(66.24,144.4) ; 68.83,157.61 v3(68.45,157.61) ; 68.83,157.61 68.83,159.14 69.82,160.13 69.82,161.32 70.25,161.75 70.25,161.85 GPU1.BB23 ; v1(16.18,149.66) 16.18,149.68 15.82,150.03 14.45,150.03 14.09,149.68 C923.1
  L4 w0.102: v1(16.18,149.66) 16.54,150.01 17.4,150.01 22.12,145.29 22.12,135.05 22.76,134.42 25.18,134.42 25.34,134.58 29.5,134.58 32.72,131.36 32.72,121.5 31.88,120.66 31.88,114.85 34.36,112.37 69.85,112.37 71.37,113.89 71.37,121.98 70.13,123.22 70.13,139.2 67.23,142.1 67.23,143.71 66.9,144.04 66.6,144.04 v1(66.24,144.4)
GPU_EDP_IN3N: length 10.7
  TOP w0.102: C954.2 16.35,152.86 12.01,152.86 ; 12.01,152.86 10.09,152.86 9.35,153.6 7.89,153.6 7.75,153.75 DISPC2.16 ; 12.01,152.86 v3(12.01,153.24)
GPU_EDP_IN3N_C: length 141.7
  TOP w0.102: v3(66.9,153.59) 67.31,153.59 ; 67.31,153.59 67.31,147.03 67.2,146.91 66.8,146.91 v1(66.75,146.86) ; 67.31,153.59 67.31,159.42 68.61,160.71 68.61,163.43 68.97,163.8 69.2,163.8 GPU1.AY21 ; v1(20.09,152.45) 19.76,152.12 19.52,152.12 18.74,152.9 18.04,152.9 C954.1
  L4 w0.102: v1(20.09,152.45) 20.52,152.02 20.73,152.02 21.26,151.49 21.4,151.49 21.62,151.28 21.62,151.13 21.83,150.92 21.97,150.92 22.19,150.7 22.19,150.56 22.41,150.35 22.55,150.35 22.76,150.13 22.76,149.99 23.8,148.95 23.8,148.65 23.9,148.55 23.9,148.25 23.8,148.15 23.8,147.84 23.9,147.74 23.9,147.44 23.8,147.34 23.8,147.03 23.9,146.93 23.9,146.63 23.8,146.53 23.8,142.5 23.9,142.4 23.9,142.1 23.8,142 23.8,141.69 23.9,141.59 23.9,141.29 23.8,141.19 23.8,140.88 23.9,140.78 23.9,140.48 23.8,140.38 23.8,140.04 28.25,135.59 29.79,135.59 30.01,135.37 30.15,135.37 30.37,135.15 30.37,135.01 30.58,134.8 30.72,134.8 30.94,134.58 30.94,134.44 31.15,134.23 31.29,134.23 31.51,134.01 31.51,133.87 32.95,132.43 33.09,132.43 33.3,132.22 33.3,132.08 33.63,131.75 33.63,121.01 33.22,120.6 33.22,120.1 33.32,120 33.32,119.7 33.22,119.6 33.22,117.43 33.32,117.34 33.32,117.03 33.22,116.93 33.22,116.63 33.32,116.53 33.32,116.22 33.22,116.12 33.22,115.82 33.32,115.72 33.32,115.42 33.22,115.32 33.22,115.01 34.95,113.28 69.47,113.28 70.46,114.27 70.46,121.59 69.16,122.89 69.16,138.78 65.18,142.77 65.18,145.63 66.14,146.59 66.14,146.61 66.44,146.91 66.7,146.91 v1(66.75,146.86)
GPU_EDP_IN3P: length 10.7
  TOP w0.102: C953.2 16.77,152.32 16.44,152.65 13.64,152.65 ; 13.64,152.65 v3(13.64,152.25) ; 13.64,152.65 10.01,152.65 9.26,153.4 7.89,153.4 7.75,153.25 DISPC2.15
GPU_EDP_IN3P_C: length 141.6
  TOP w0.102: 67.51,156.21 67.51,146.94 66.7,146.13 v1(66.7,145.95) ; 67.51,156.21 v3(67.89,156.21) ; 67.51,156.21 67.51,159.33 68.81,160.63 68.81,163.35 69.06,163.6 70.2,163.6 GPU1.AY23 ; v1(20.09,151.54) 19.71,151.92 19.43,151.92 18.65,152.69 18.04,152.69 C953.1
  L4 w0.102: v1(20.09,151.54) 20.37,151.82 20.65,151.82 23.6,148.87 23.6,139.95 28.17,135.38 29.71,135.38 33.43,131.67 33.43,121.09 33.02,120.68 33.02,114.93 34.87,113.08 69.55,113.08 70.66,114.19 70.66,121.67 69.37,122.97 69.37,138.86 65.38,142.85 65.38,145.54 65.84,146 66.65,146 v1(66.7,145.95)
GPU_GPIO_1: length 54.1
  TOP w0.114: GPU1.V38 84.65,183.75 v6(84.65,183.6) ; v1(95.1,203.4) 94.81,203.69 R507.2
  L6 w0.102: v6(84.65,183.6) 84.93,183.6 85.75,182.78 86.25,182.78 86.28,182.81 86.62,182.81 86.94,182.48 86.94,181.99 87.55,181.39 89.57,181.39 89.97,181.78 89.97,183.01 90.37,183.41 99.72,183.41 102.9,186.59 103.89,186.59 105.18,187.88 105.18,188.65 105.97,189.43 105.97,190.35 105.69,190.63 105.69,191.82 106.2,192.33 106.2,195.73 105.26,196.67 105.26,196.67 104.89,197.03 104.89,197.78 104.93,197.81 104.93,198.15 104.78,198.3 104.78,200.06 102.17,202.67 96.31,202.67 96.06,202.91 96.06,202.92 95.58,203.4 v1(95.1,203.4)
  BOTTOM w0.114: v1(95.1,203.4) 94.41,203.4 v2(94.11,203.71) 93.88,203.94 R508.1
GPU_GPIO_8_ROMSO: length 45.9
  TOP w0.114: GPU1.AN30 77.95,169.8 78.43,169.32 v6(78.44,169.32) ; RN2411.2 110.6,163.46 v1(110.74,163.32)
  BOTTOM w0.114: v1(110.74,163.32) 110.74,162.18 109.47,160.9 109.11,160.9 108.2,159.99 v2(108.2,159.56) 106.72,158.08 101.08,158.08 99.17,156.17 96.54,156.17 95.19,157.51 95.19,157.52 92.71,160 92.71,162.09 91.74,163.06 82.81,163.06 81.28,164.59 81.28,165.61 80.1,166.79 79.54,166.79 78.97,167.37 78.97,168.78 v6(78.44,169.32)
GPU_GPIO_8_ROMSO_R: length 7.2
  TOP w0.114: R516.1 R515.2 111.19,163 111.8,163.62 RN2411.3 112.31,164.04 112.78,163.58 v3(113.46,163.58) 113.54,163.58 113.59,163.53 115.9,163.53 U28.2
GPU_GPIO_9_ROMSI: length 57.3
  TOP w0.114: GPU1.AP32 79.15,169 79.52,168.63 79.58,168.63 v6(79.6,168.61) ; v1(125.15,163.65) 125.74,163.06 125.74,161.37 124.88,160.52 RN2410.3
  BOTTOM w0.114: v1(125.15,163.65) 124.64,164.15 110.35,164.15 109.71,163.51 109.71,163.49 109.07,162.86 108.02,162.86 107.19,162.03 107.19,161.67 104.9,159.38 100.97,159.38 100.3,160.05 v2(98.04,160.05) 96.39,160.05 94.23,162.2 94.23,162.72 92.49,164.47 90.68,164.47 90.2,164.95 85.41,164.95 85.2,165.16 84.32,165.16 83.29,166.18 82.91,166.18 82.3,166.8 81.08,166.8 80.11,167.77 80.11,168.1 v6(79.6,168.61)
GPU_GPIO_9_ROMSI_R: length 7.2
  TOP w0.114: U28.5 120.99,160.54 120.33,159.88 R518.1 R517.2 v3(121.79,158.37) 121.94,158.37 123.18,159.61 RN2410.2
GPU_GPIO_10_ROMSCK: length 58.2
  TOP w0.114: v6(78.51,170.21) 78.37,170.21 77.98,170.6 GPU1.AM30 ; v1(125.15,162.74) 125.15,162.41 124.38,161.64 RN2410.4
  BOTTOM w0.114: v1(125.15,162.74) 124.26,163.63 111.13,163.63 110.95,163.81 110.5,163.81 110.05,163.37 110.05,163.35 109.22,162.52 109.13,162.52 107.72,161.11 107.72,161.06 105.7,159.04 96.61,159.04 v2(95.89,159.77) 95.21,160.45 95.21,160.47 94.93,160.74 94.91,160.74 93.89,161.76 93.89,162.58 92.41,164.06 89.4,164.06 89.25,163.91 87.13,163.91 86.31,164.73 85.32,164.73 85.11,164.95 84.23,164.95 83.21,165.96 82.8,165.96 82.19,166.58 81.82,166.58 81.82,166.58 80.9,166.58 80.29,167.19 79.56,167.19 79.19,167.56 79.19,169.15 78.85,169.49 78.51,169.82 v6(78.51,170.21)
GPU_GPIO_10_ROMSCK_R: length 3.3
  TOP w0.114: U28.6 122.01,162.27 122.17,162.43 v3(122.81,162.43) 123.05,162.19 123.05,161.3 RN2410.1
GPU_GPIO_11: length 27.2
  TOP w0.114: GPU1.V43 110.9,184.2 v3(111.41,184.71) 112.41,185.71 R528.2 112.99,186.24 113.83,187.08 113.83,187.14 R527.1
GPU_GPIO_12: length 30.9
  TOP w0.114: GPU1.V42 88.21,184.61 89.41,184.61 89.6,184.42 109.87,184.42 111.18,185.72 v3(111.18,187.03) 111.18,190.25 111.69,190.76 R524.2 112.86,190.76 R525.1
GPU_GPIO_13: length 37.6
  TOP w0.114: v1(111.76,189.96) 111.76,189.5 R521.2 112.8,189.14 R520.1 ; GPU1.V41 86.9,184.35 v6(86.45,184.8)
  L3 w0.114: v1(111.76,189.96) 111.76,192.53 109.58,194.71 94.64,194.71 86.45,186.53 v6(86.45,184.8)
  BOTTOM w0.114: v2(112.34,190.55) 112.34,190.55 v1(111.76,189.96)
GPU_GPIO_15: length 5.5
  TOP w0.114: GPU1.AJ31 78.6,173.24 v6(78.97,172.87)
  BOTTOM w0.114: v2(81.41,173.01) 81.09,173.33 79.65,173.33 79.2,172.87 v6(78.97,172.87) 78.64,172.54 78.64,171.81 79.12,171.32 R2702.1
GPU_GPIO_19_CTF: length 105
  TOP w0.114: v1(111,121.01) 111,121.06 v3(111.79,121.85) 112.31,122.36 R2577.1 113.79,123.58 R602.1 ; v6(79.17,179.99) 79.17,179.98 79.1,179.98 78.6,179.49 GPU1.AC31
  L4 w0.114: v1(111,121.01) 110.72,121.28 110.72,123.4 106.98,127.14 105.44,127.14 104.98,127.59 104.98,129.14 104.98,129.49 104.98,129.49 104.98,135.6 105.51,136.14 105.51,140.77 105.54,140.8 105.54,144.11 103.48,146.18 103.48,148.35 101.36,150.47 101.36,156.14 98.96,158.54 98.96,164.08 96.7,166.35 96.7,167.72 97.36,168.39 97.36,177.15 v1(103.81,183.59)
  L6 w0.102: v1(103.81,183.59) 99.59,179.37 79.78,179.37 v6(79.17,179.99)
GPU_GPIO_19_CTF_R: length 7.4
  TOP w0.114: D11.3 115.64,121.85 v3(114.97,122.52) 114.71,122.78 R602.2 115.27,124.16 R603.1 116.35,124.16 R604.1
GPU_GPIO_20: length 80.9
  TOP w0.114: R531.2 101.92,211.9 v1(101.6,211.58) ; v6(79.85,171.6) 80.2,171.95 GPU1.AK33
  L6 w0.102: v6(79.85,171.6) 81.65,171.6 82.03,171.21 82.37,171.21 82.63,171.47 82.63,171.72 82.86,171.96 83.63,171.96 83.68,172.01 87.52,172.01 87.97,171.55 107.27,171.55 111.87,176.16 111.87,184.5 112.7,185.33 112.7,187.22 112.5,187.43 112.5,193.14 112.34,193.29 112.34,200.94 107.8,205.49 106.58,205.49 105.79,206.27 105.79,206.74 105.24,207.29 104.05,208.48 101.6,210.93 v1(101.6,211.58)
  BOTTOM w0.114: R532.1 v5(100.88,209.93) 100.88,210.86 v1(101.6,211.58)
GPU_GPIO_22_ROMCSB: length 39.3
  TOP w0.114: R534.2 R533.1 108.94,165.02 109.22,164.74 109.22,164.52 v1(109.25,164.49) 109.51,164.75 110.54,164.75 RN2411.1 ; v6(79.6,169.42) 79.48,169.42 79.09,169.8 GPU1.AN32
  BOTTOM w0.114: v1(109.25,164.49) 109.11,164.49 108.83,164.22 100.49,164.22 v2(99.06,162.79) 97.84,161.57 95.35,161.57 94.58,162.35 94.58,162.87 92.28,165.16 85.5,165.16 85.03,165.63 85.03,165.82 84.69,166.17 84.39,166.17 84.16,166.4 83,166.4 81.79,167.61 81.58,167.61 80.92,168.28 80.75,168.28 v6(79.6,169.42)
GPU_GPIO_22_ROMCSB_R: length 4.2
  TOP w0.114: RN2411.4 112.44,164.69 112.65,164.9 R552.2 114.25,164.9 v3(114.3,164.85) 114.43,164.85 114.47,164.81 U28.1
GPU_GPIO_29: length 77.4
  TOP w0.114: GPU1.AG31 78.6,174.75 v6(79.05,175.2) ; v1(99.54,211.91) 99,212.46 R536.2
  L6 w0.102: v1(99.54,211.91) 99.54,211.84 104.43,206.96 104.9,206.48 104.9,206.01 106.24,204.67 107.11,204.67 108.05,203.73 108.05,202.86 110.41,200.51 110.72,200.51 111.53,199.69 111.53,192.96 110.77,192.2 110.77,187.99 111.66,187.1 111.66,185.65 100.45,174.45 99.18,174.45 97.96,173.23 88.27,173.23 86.7,174.79 79.46,174.79 v6(79.05,175.2)
  BOTTOM w0.114: v1(99.54,211.91) 100.08,211.38 v5(100.08,211.02) 100.08,209.14 99.62,208.69 R535.1
GPU_GPIO_30_PCC_R: length 91.4
  TOP w0.114: v1(103.15,220.52) 103.47,220.84 R485.1 ; v6(78.25,175.2) 77.8,174.75 GPU1.AG30
  L6 w0.102: v6(78.25,175.2) 79.03,174.42 82.48,174.42 83.31,173.59 86.63,173.59 88.27,171.96 105.73,171.96 106.17,172.4 106.17,172.9 111.46,178.19 111.46,184.67 112.29,185.5 112.29,187.05 111.28,188.06 111.28,190.32 111.94,190.98 111.94,200.36 111.35,200.94 110.55,200.94 108.46,203.03 108.46,204.22 107.59,205.08 106.41,205.08 105.31,206.18 105.31,206.65 104.59,207.36 100.3,211.65 100.3,213.79 103.48,216.97 103.48,220.19 v1(103.15,220.52)
  BOTTOM w0.114: v5(102.31,220.52) v1(103.15,220.52)
GPU_HDMI_OUT0N: length 6.7
  TOP w0.102: 9.65,164.49 9.01,164.49 8.92,164.4 7.89,164.4 7.75,164.25 DISPC2.37 ; 9.65,164.49 v3(9.65,164.08) ; 9.65,164.49 12.64,164.49 C912.2
GPU_HDMI_OUT0N_C: length 155.2
  TOP w0.102: GPU1.BB32 79.35,161.85 79.53,161.85 79.75,161.63 79.75,157.06 78.44,155.75 ; v1(14.81,164.05) 14.72,164.13 C912.1 ; v1(71.12,142.62) 71.42,142.93 72.5,142.93 74.45,144.87 74.45,151.76 78.44,155.75 ; 78.44,155.75 v3(78.71,155.47)
  L6 w0.102: v1(14.81,164.05) 15.22,164.46 17.61,164.46 20.51,161.56 20.51,154.32 23.1,151.73 23.1,149.72 26.35,146.47 26.35,144.51 26.58,144.28 27.29,144.28 27.39,144.18 27.39,143.87 27.29,143.77 26.58,143.77 26.35,143.54 26.35,143.06 26.58,142.83 27.29,142.83 27.39,142.73 27.39,142.42 27.29,142.32 26.58,142.32 26.35,142.1 26.35,138.29 27.61,137.03 29.69,137.03 34.15,132.57 34.15,119.34 36.16,117.33 36.16,115.89 38.24,113.8 69.56,113.8 70.12,114.36 70.12,120.22 68.75,121.59 68.75,140.32 69.88,141.45 69.88,142.42 70.43,142.97 70.65,142.97 70.75,142.97 v1(71.12,142.62)
GPU_HDMI_OUT0P: length 6.7
  TOP w0.102: 11.43,164.69 8.93,164.69 8.84,164.6 7.89,164.6 7.75,164.75 DISPC2.38 ; 11.43,164.69 v3(11.43,165.07) ; 11.43,164.69 12.64,164.69 C911.2
GPU_HDMI_OUT0P_C: length 155.1
  TOP w0.102: v1(14.81,165.09) 14.77,165.05 C911.1 ; v1(71.09,143.56) 71.53,143.13 72.42,143.13 74.24,144.96 74.24,151.84 79.55,157.15 79.55,158.42 ; 79.55,158.42 v3(79.15,158.42) ; 79.55,158.42 79.55,161.55 79.45,161.65 79.35,161.65 GPU1.BC32
  L6 w0.102: v1(14.81,165.09) 15.22,164.67 17.7,164.67 18.03,164.34 18.19,164.34 18.4,164.13 18.4,163.97 18.62,163.75 18.78,163.75 18.99,163.54 18.99,163.38 19.21,163.16 19.37,163.16 19.58,162.95 19.58,162.79 20.73,161.65 20.73,161.34 20.84,161.23 20.84,160.92 20.73,160.81 20.73,160.51 20.84,160.4 20.84,160.09 20.73,159.98 20.73,159.67 20.84,159.56 20.84,159.26 20.73,159.15 20.73,154.41 23.32,151.82 23.32,149.81 26.57,146.56 26.57,144.6 26.67,144.49 27.38,144.49 27.61,144.27 27.61,143.78 27.38,143.55 26.67,143.55 26.57,143.45 26.57,143.15 26.67,143.05 27.38,143.05 27.61,142.82 27.61,142.33 27.38,142.11 26.67,142.11 26.57,142.01 26.57,138.38 27.7,137.25 29.78,137.25 34.37,132.66 34.37,119.43 36.37,117.42 36.37,115.98 38.33,114.02 69.44,114.02 69.9,114.48 69.9,120.13 68.53,121.5 68.53,140.41 69.66,141.54 69.66,142.51 70.34,143.19 70.64,143.19 70.74,143.19 v1(71.09,143.56)
GPU_HDMI_OUT1N: length 10.5
  TOP w0.102: 9.53,162.9 v3(9.53,162.51) ; 9.53,162.9 7.89,162.9 7.75,162.75 DISPC2.34 ; 9.53,162.9 11.49,162.9 12.18,162.2 16.14,162.2 C914.2
GPU_HDMI_OUT1N_C: length 150.7
  TOP w0.102: 73.56,148.41 73.56,147.37 73.33,147.14 71.63,147.14 v1(71.35,147.42) ; 73.56,148.41 v3(73.18,148.41) ; 73.56,148.41 73.56,152.31 78.35,157.1 78.35,161.55 78.25,161.65 78.15,161.65 GPU1.BC30 ; C914.1 17.86,162.21 18.47,162.21 18.95,161.74 18.95,161.09 v1(18.68,160.82)
  L6 w0.102: v1(71.35,147.42) 71.65,147.12 72.34,147.12 72.82,146.63 72.82,141.6 69.48,138.26 69.48,121.93 70.85,120.56 70.85,114.06 69.86,113.07 35.85,113.07 32.85,116.06 32.85,132.63 30,135.48 27.53,135.48 25.34,137.68 25.34,146.14 21.55,149.92 21.55,152.23 19.77,154.01 19.77,158.56 18.97,159.36 18.97,160.52 v1(18.68,160.82)
GPU_HDMI_OUT1P: length 10.5
  TOP w0.102: 11.18,163.1 v3(11.18,163.5) ; 11.18,163.1 7.89,163.1 7.75,163.25 DISPC2.35 ; 11.18,163.1 11.57,163.1 12.27,162.41 16.13,162.41 C913.2
GPU_HDMI_OUT1P_C: length 150.8
  TOP w0.102: v3(19.18,162.38) 18.88,162.09 ; 18.88,162.09 19.15,161.82 19.15,161.19 19.48,160.86 v1(19.48,160.78) ; 18.88,162.09 18.56,162.42 17.86,162.42 C913.1 ; GPU1.BB30 78.15,161.85 78.33,161.85 78.56,161.63 78.56,157.02 73.76,152.22 73.76,147.29 73.41,146.94 71.75,146.94 v1(71.32,146.51)
  L6 w0.102: v1(71.32,146.51) 71.72,146.9 72.25,146.9 72.61,146.54 72.61,141.69 69.27,138.35 69.27,121.84 70.64,120.47 70.64,114.15 69.77,113.28 35.94,113.28 33.07,116.15 33.07,132.72 30.09,135.7 27.62,135.7 25.55,137.77 25.55,146.23 21.77,150.01 21.77,152.32 19.99,154.1 19.99,158.65 19.19,159.45 19.19,160.49 v1(19.48,160.78)
GPU_HDMI_OUT2N: length 7.1
  TOP w0.102: C916.2 12.58,160.26 11.79,160.26 10.65,161.4 9.68,161.4 ; 9.68,161.4 v3(9.68,161.01) ; 9.68,161.4 7.89,161.4 7.75,161.25 DISPC2.31
GPU_HDMI_OUT2N_C: length 154.6
  TOP w0.102: C916.1 14.77,159.84 v1(14.81,159.8) ; GPU1.AY29 77,164 77.1,163.9 77.1,158.39 ; 77.1,158.39 77.1,156.88 72.87,152.65 72.87,149.28 72.54,148.95 71.81,148.95 v1(71.5,149.25) ; 77.1,158.39 v3(76.71,158.39)
  L6 w0.102: v1(14.81,159.8) 15.22,160.22 17,160.22 18.81,158.41 18.81,151.14 19.18,150.77 19.18,150.77 24.32,145.63 24.32,137.58 27.19,134.71 27.19,128.49 28.87,126.81 30.19,126.81 31.84,125.16 31.84,115.63 35.14,112.33 70.22,112.33 71.59,113.7 71.59,120.87 70.98,121.48 70.22,122.24 70.22,137.86 73.71,141.35 73.71,148.29 73.06,148.93 71.82,148.93 v1(71.5,149.25)
GPU_HDMI_OUT2P: length 7.2
  TOP w0.102: 11.46,160.88 11.88,160.46 12.58,160.46 C915.2 ; 11.46,160.88 v3(11.73,161.16) ; 11.46,160.88 10.74,161.6 7.89,161.6 7.75,161.75 DISPC2.32
