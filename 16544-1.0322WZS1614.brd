# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_FAN_TACH_SIO: length 218.6
  TOP w0.114: R258.2 18.92,174.88 v1(19.18,175.13) ; v1(101.14,47.24) 101.24,47.34 KBC1.31
  L3 w0.114: v1(101.14,47.24) 101.14,47.29 100.89,47.55 97.04,47.55 96.72,47.22 94.27,47.22 93.63,46.58 93.14,46.58 92.61,46.06 89.6,46.06 v1(83.95,51.71)
  L6 w0.102: v1(83.95,51.71) 83.84,51.71 79.88,55.67 79.88,103.6 78.46,105.03 25.91,105.03 23.47,107.47 18.44,107.47 13.46,112.44 13.46,113.04 7.24,119.26 7.24,159.08 9.68,161.52 9.68,165.63 v1(19.18,175.13)
  BOTTOM w0.114: v2(102.01,46.99) 101.4,46.99 v1(101.14,47.24)
CPU_NB_FB_P: length 82.8
  TOP w0.127: v1(218.44,228.73) 218.29,228.73 217.42,227.86 217.42,226.29 216.66,225.53 PR72.1
  L4 w0.127: v1(218.44,228.73) 218.67,228.96 218.67,228.98 219.07,229.39 220.6,229.39 220.62,229.36 220.65,229.36 221.06,228.96 221.06,228.93 221.67,228.32 221.67,217.42 212.88,208.64 211.81,208.64 v1(211.79,208.61)
  BOTTOM w0.127: R30.1 197.14,168.5 197.14,169.83 197.26,169.94 PR71.1 197.78,170.78 198.75,171.75 198.75,174.42 198.42,174.75 198.42,183.74 197.4,184.77 v2(197.4,192.18) 197.4,192.65 201.45,196.7 203.02,196.7 206.17,199.85 206.17,202.18 209.02,205.02 209.02,207.44 210.19,208.61 v1(211.79,208.61)
CPU_NB_FB_P_R: length 13.1
  TOP w0.127: CPU1.E15 v6(184.51,167.52)
  L3 w0.127: v1(194.26,166.65) 193.65,167.26 190.98,167.26 190.75,167.03 185,167.03 v6(184.51,167.52)
  BOTTOM w0.127: R30.2 195.03,167.28 v2(194.82,167.28) 194.26,166.73 v1(194.26,166.65)
CSA0B_0: length 32.3
  TOP w0.13: GPU1.Y34 81.45,182.25 v6(81.45,182.4) ; VRAMA1.G12 104.1,190.36 v6(103.73,189.98)
  BOTTOM w0.13: v6(103.73,189.98) 103.72,189.98 103.71,190 102.9,190 102.33,189.43 102.33,188.22 102.65,187.89 102.65,185.27 102.86,185.06 102.86,183.74 102.55,183.43 102.15,183.43 102.03,183.56 102.03,183.99 101.9,184.12 101.63,184.12 101.5,183.99 101.5,183.56 101.27,183.34 88.89,183.34 87.49,181.94 81.91,181.94 v6(81.45,182.4)
CSA1B_0: length 39
  TOP w0.13: VRAMA2.L12 v6(84.5,221.7) ; GPU1.M27 75.85,189.85 v6(76,189.85)
  BOTTOM w0.13: v6(84.5,221.7) 84.5,220.98 83.89,220.37 82,220.37 79.67,218.05 79.67,211.41 79.8,211.28 80.09,211.28 80.22,211.15 80.22,210.88 80.09,210.75 79.8,210.75 79.67,210.62 79.67,210.24 76.1,206.67 76.1,196.36 76.6,195.86 76.6,190.45 v6(76,189.85)
CSB0B_0: length 37.4
  TOP w0.13: v6(74.8,190.65) 74.65,190.65 GPU1.L26 ; VRAMB1.G12 74,221.73 v6(74,221.7)
  BOTTOM w0.13: v6(74,221.7) 74,221.11 74.84,220.26 77.3,220.26 78.65,218.91 78.65,210.4 75.54,207.29 75.54,191.56 74.8,190.82 v6(74.8,190.65)
CSB1B_0: length 41.9
  TOP w0.13: VRAMB2.L12 v6(47.5,221.7) ; GPU1.K12 v6(60.4,191.45)
  BOTTOM w0.13: v6(60.4,191.45) 60.04,191.81 59.8,193 59.8,195.62 56.51,200.29 42.8,214 42.8,218.78 43.91,219.89 44.48,220.46 47.11,220.46 47.2,220.56 47.2,220.81 v6(47.5,221.7)
CSC0B_0: length 41.8
  TOP w0.13: GPU1.M10 v6(58.55,189.6) ; v6(28.3,202.5) VRAMC1.G12
  BOTTOM w0.13: v6(58.55,189.6) 58.16,189.99 57.2,190.17 54.53,190.17 51.16,192.04 36,207.2 31.22,207.2 30.6,206.58 29.54,205.52 29.54,203.15 29.19,202.8 v6(28.3,202.5)
CSC1B_0: length 37.8
  TOP w0.13: GPU1.AF11 59.35,175.35 v6(59.35,175.2) ; VRAMC2.L12 v6(28.3,176)
  BOTTOM w0.13: v6(28.3,176) 29,176 29.64,175.36 29.64,172.69 31.41,170.92 39.52,170.92 43.07,174.46 54.83,174.46 54.99,174.62 58.78,174.62 v6(59.35,175.2)
CSD0B_0: length 39.8
  TOP w0.13: GPU1.AG12 60.15,174.15 v6(60.15,174) ; VRAMD1.G12 v6(28.3,165.5)
  BOTTOM w0.13: v6(28.3,165.5) 29.02,165.5 29.59,166.07 29.59,169.31 30.61,170.33 38.59,170.33 38.72,170.2 38.72,169.91 38.85,169.78 39.12,169.78 39.25,169.91 39.25,170.2 39.38,170.33 39.76,170.33 43.32,173.89 53.65,173.89 54.14,173.4 59.55,173.4 v6(60.15,174)
CSD1B_0: length 30.4
  TOP w0.13: GPU1.AP20 68.05,169 67.6,168.55 67.6,168.48 v6(67.59,168.47) ; VRAMD2.L12 59.99,146.29 v6(59.99,146.33)
  BOTTOM w0.089: 67.84,160.68 68.34,161.18 68.34,161.83 68.51,162 68.51,164.18 68.34,164.35 68.34,167.67 67.59,168.43 v6(67.59,168.47)
  BOTTOM w0.13: v6(59.99,146.33) 59.99,146.35 60,146.36 60,147.1 60.58,147.67 61.79,147.67 62.11,147.35 64.75,147.35 67.65,150.25 67.65,160.49 67.84,160.68
CTF_TRIP: length 5
  TOP w0.114: R603.2 116.35,125.59 116.69,125.93 v3(117.25,125.93) 117.98,125.2 C653.1 118.45,125.23 Q50.B
CYPD2122_WP: length 76.2
  TOP w0.114: v1(114.2,51.82) 114.17,51.79 114,51.79 112.52,50.32 112.52,48.56 112.71,48.38 112.71,48.35 114.85,46.21 KBC1.60 ; LAUOC1.16 v3(130.75,11.44) 130.75,12.49 v1(130.81,12.55) ; R2733.2 121.57,51.14 121.49,51.14 121.45,51.18 v1(120.95,51.18)
  L4 w0.114: v1(120.95,51.18) 120.95,50.97 121.72,50.2 121.72,48.38 124.48,45.62 133.58,45.62 138.43,40.77 138.43,24.94 133.91,20.42 133.91,16.56 130.81,13.46 v1(130.81,12.55)
  L6 w0.102: v1(114.2,51.82) 114.22,51.84 115.52,51.84 115.97,51.39 120.74,51.39 v1(120.95,51.18)
DC_19V:
  vias: v2(31.95,116.28) v4(28.14,115.21) v4(28.17,113.94) v4(29.29,115.21) v4(29.26,113.94) v4(29.26,112.78) v4(30.4,113.94) v4(30.4,112.78) v4(31.65,112.78)
DDBIA0_0: length 19.9
  TOP w0.13: VRAMA1.D13 106.08,189.18 106.08,188.05 105.2,187.17 96.24,187.17 95.49,187.92 94.12,187.92 94.01,187.81 90.58,187.81 90.49,187.9 88.8,187.9 GPU1.P43
DDBIA0_1: length 25.5
  TOP w0.13: VRAMA1.D2 106.1,198.81 106.1,199.4 105.75,199.75 105.1,200.4 96.06,200.4 94.55,198.89 94.55,197.85 90.4,193.7 90.25,193.7 89.89,193.34 86.74,193.34 GPU1.H40
DDBIA0_2: length 14.7
  TOP w0.13: GPU1.P40 86.45,188.25 v6(86.45,188.4) ; v6(98.1,190) VRAMA1.P13
  L6 w0.089: 95.09,191.2 97.05,191.2 98.1,190.15 v6(98.1,190)
  L6 w0.11: v6(86.45,188.4) 86.49,188.44 91.85,188.44 94.61,191.2 95.09,191.2
DDBIA0_3: length 17.2
  TOP w0.13: VRAMA1.P2 v6(98.1,198.8) ; v6(85.55,194.4) 85.55,194.25 GPU1.F39
  L6 w0.089: v6(98.1,198.8) 97.7,199.2 97.7,199.92
  L6 w0.11: 97.7,199.92 97.57,200.05 94.39,200.05 89.34,195 86.15,195 v6(85.55,194.4)
DDBIA1_0: length 36.1
  TOP w0.13: VRAMA2.P2 92.9,224.5 93.34,224.06 94.54,224.06 95.38,223.22 95.38,213.98 93.8,212.4 92.76,212.4 89.8,209.44 89.8,206.61 83.34,200.15 83.34,196.74 GPU1.D36
DDBIA1_1: length 29.5
  TOP w0.13: GPU1.A30 78,198.9 78,202.08 79.59,203.68 79.66,203.74 79.66,204.95 82.93,208.22 82.93,210.06 82.21,210.77 82.21,223.55 82.62,223.96 82.98,223.96 83.12,224.1 83.7,224.1 VRAMA2.P13
DDBIA1_2: length 28
  TOP w0.13: GPU1.E35 81.85,195.55 v6(82,195.55) ; v6(93.3,216.1) VRAMA2.D2
  L6 w0.11: v6(93.3,216.1) 93.7,215.7 94.27,215.7 94.55,215.42 94.55,211.43 91.83,208.7 91.83,208.29 82.92,199.39 82.92,196.47 v6(82,195.55)
DDBIA1_3: length 29.3
  TOP w0.13: v6(77.2,193.05) 76.75,192.6 GPU1.H29 ; VRAMA2.D13 v6(84.5,216.1)
  L6 w0.11: v6(77.2,193.05) 76.79,193.46 76.79,194.9 76.58,195.11 76.58,198.74 77.01,199.16 77.01,201.89 85.54,210.42 85.54,213.67 85.72,213.85 85.72,215.45 85.48,215.7 84.9,215.7 v6(84.5,216.1)
DDBIB0_0: length 24.6
  TOP w0.13: v6(74,216.13) VRAMB1.P13 ; GPU1.G24 72.25,193.85 v6(72.4,193.85)
  L6 w0.11: v6(74,216.13) 74,215.95 72.79,214.74 72.79,212.87 72.33,212.41 72.33,204 71.99,203.66 71.99,194.26 v6(72.4,193.85)
DDBIB0_1: length 26.3
  TOP w0.13: GPU1.H19 66.55,193.05 v6(66.4,193.05) ; VRAMB1.P2 v6(65.21,216.14)
  L6 w0.11: v6(66.4,193.05) 66.81,193.46 66.81,198.85 66.46,199.2 66.46,209.98 63.95,212.49 63.95,214.29 65.2,215.55 65.2,216.09 65.21,216.1 v6(65.21,216.14)
DDBIB0_2: length 30.3
  TOP w0.13: GPU1.C19 66.35,197.55 66.35,203.67 66.43,203.75 66.43,210.31 63.6,213.13 63.6,223.1 64.6,224.1 65.17,224.1 65.6,224.53 VRAMB1.D2
DDBIB0_3: length 31.2
  TOP w0.13: VRAMB1.D13 74.83,224.1 74.83,224.09 74.84,224.07 75.95,224.07 76.68,223.34 76.68,212.31 72.49,208.11 72.49,207.5 72.42,207.44 72.42,203.88 72.35,203.8 72.35,199.67 72.35,199.67 72.35,197.45 GPU1.C24
DDBIB1_0: length 28.9
  TOP w0.13: VRAMB2.D2 v6(56.3,216.1) ; v6(64,192.25) 64.15,192.25 GPU1.J17
  L6 w0.089: v6(56.3,216.1) 56.7,215.7 57.6,215.7 58,215.3
  L6 w0.11: 58,215.3 58,208.69 62.98,203.71 62.98,199.16 63.26,198.89 63.26,193 v6(64,192.25)
DDBIB1_1: length 30.4
  TOP w0.13: v6(59.2,192.25) 59.35,192.25 GPU1.J11 ; VRAMB2.D13 v6(47.5,216.1)
  L6 w0.089: 49.4,212.62 48.7,213.33 48.7,215.47 48.47,215.7 47.9,215.7 47.5,216.1 v6(47.5,216.1)
  L6 w0.1: v6(59.2,192.25) 58.45,193 58.45,193.51
  L6 w0.11: 58.45,193.51 58.45,197.49 57.8,198.14 57.8,199.45 50.14,207.11 50.14,211.89 49.4,212.62
DDBIB1_2: length 31.4
  TOP w0.13: GPU1.C12 60.56,197.34 60.56,202.33 59.25,203.64 59.25,205.73 57.2,207.78 57.2,211.87 57.18,211.9 57.18,212.37 58.38,213.58 58.38,223.22 57.54,224.06 56.34,224.06 VRAMB2.P2
DDBIB1_3: length 31.2
  TOP w0.13: VRAMB2.P13 46.7,224.1 46.12,224.1 45.98,223.96 45.62,223.96 45.22,223.56 45.22,213.49 49.17,209.54 49.17,209.54 50.1,208.6 50.11,208.6 50.54,208.17 50.54,206.03 54.13,202.44 54.15,202.44 55,201.59 GPU1.A5
DDBIC0_0: length 31.7
  TOP w0.13: VRAMC1.D13 25.75,203.15 25.9,203.3 25.9,203.88 26.02,204 26.02,204.21 26.04,204.23 26.04,204.43 26.7,205.1 35.93,205.1 37.58,203.44 37.65,203.44 39.27,201.83 39.73,201.83 40.08,201.47 40.08,201.17 41.66,199.59 43.92,199.59 48.51,195 GPU1.E1
DDBIC0_1: length 31.5
  TOP w0.13: VRAMC1.D2 25.77,193.83 25.94,193.66 25.94,192.25 26.57,191.62 36.42,191.62 37.6,192.8 38.14,192.8 38.15,192.79 38.48,192.79 38.49,192.8 42.22,192.8 44.07,190.95 44.66,190.95 46.17,189.44 52.66,189.44 GPU1.M3
DDBIC0_2: length 30.4
  TOP w0.13: v6(57.75,190.8) 58.2,190.35 GPU1.L9 ; v6(33.9,202.5) VRAMC1.P13
  L6 w0.089: v6(33.9,202.5) 34.3,202.1 34.3,201.54 34.53,201.3 35.33,201.3 35.33,201.3 36.39,201.3 36.77,201.3 36.9,201.16
  L6 w0.11: v6(57.75,190.8) 56.98,191.57 52.49,191.57 51.7,192.36 51.01,192.36 43.29,200.08 37.99,200.08 36.9,201.16
DDBIC0_3: length 29.1
  TOP w0.13: v6(57.75,186) 57.75,185.85 GPU1.U9 ; v6(33.9,193.7) VRAMC1.P2
  L6 w0.089: v6(33.9,193.7) 33.91,193.7 34.3,193.31 34.3,192.42 35.03,191.69 35.46,191.69 35.59,191.57 35.66,191.57 35.69,191.59
  L6 w0.11: v6(57.75,186) 57.04,186.71 51.15,186.71 50.84,187.02 50.32,187.02 50.1,186.8 48.15,186.8 43.61,191.35 35.93,191.35 35.69,191.59
DDBIC1_0: length 31.1
  TOP w0.13: VRAMC2.P13 25.93,175.17 25.93,174.07 26.58,173.41 37.79,173.41 41.94,177.56 42.1,177.56 44.84,177.56 45,177.72 52.62,177.72 GPU1.AD3
DDBIC1_1: length 30.2
  TOP w0.13: GPU1.W3 52.45,183.65 49.49,183.65 49.49,183.65 41.81,183.65 41.68,183.78 39.46,183.78 36.85,186.39 26.89,186.39 25.91,185.4 25.91,184.8 25.73,184.63 VRAMC2.P2
DDBIC1_2: length 27.5
  TOP w0.13: VRAMC2.D2 v6(33.9,184.8) ; GPU1.W8 56.95,183.45 v6(56.95,183.6)
  L6 w0.089: v6(33.9,184.8) 33.97,184.8 34.3,185.13 34.3,185.86 34.87,186.44 35.4,186.44 35.41,186.44
  L6 w0.11: v6(56.95,183.6) 56.44,183.09 54.87,183.09 54.69,182.9 53.23,182.9 53.15,182.98 53.04,182.98 52.87,183.15 51.48,183.15 51.1,183.53 50.51,183.53 50.2,183.22 46.16,183.22 42.93,186.44 35.41,186.44
DDBIC1_3: length 24.7
  TOP w0.13: VRAMC2.D13 v6(33.9,176) ; GPU1.AD7 56.6,178.05 v6(56.15,177.6)
  L6 w0.11: v6(33.9,176) 35.05,177.15 36.84,177.15 37.22,177.53 43.09,177.53 43.37,177.81 44.78,177.81 45.07,178.1 50.17,178.1 50.31,177.97 55.14,177.97 55.18,178.01 55.74,178.01 v6(56.15,177.6)
DDBID0_0: length 29.5
  TOP w0.13: VRAMD1.P13 v6(33.9,165.5) ; v6(56.95,172.8) 56.95,172.95 GPU1.AJ8
  L6 w0.089: v6(33.9,165.5) 33.9,165.31 34.3,164.91 34.3,164.53 34.53,164.3 35.67,164.3 35.7,164.34 36.4,164.34 36.42,164.31
  L6 w0.11: v6(56.95,172.8) 56.53,173.22 55.04,173.22 54.63,173.63 54.14,173.63 53.9,173.38 51.51,173.38 50.99,172.87 46.98,172.87 38.59,164.47 36.66,164.47 36.5,164.31 36.42,164.31
DDBID0_1: length 28.6
  TOP w0.13: VRAMD1.P2 v6(33.9,156.7) ; GPU1.AR5 54.45,168.15 v6(54.45,168)
  L6 w0.089: 34.39,155.4 34.3,155.49 34.3,156.4 34,156.7 v6(33.9,156.7)
  L6 w0.11: 34.39,155.4 38.49,155.4 47.23,164.14 47.23,164.78 50.03,167.58 54.03,167.58 v6(54.45,168)
DDBID0_2: length 30.3
  TOP w0.13: VRAMD1.D13 25.9,166.3 25.9,166.88 26.02,167 26.02,167.35 26.71,168.05 28.7,168.05 29.37,168.71 36.09,168.71 37.47,167.34 40.13,167.34 40.41,167.06 41.76,167.06 44.04,169.34 46.7,172 51.1,172 GPU1.AK1
DDBID0_3: length 36.2
  TOP w0.13: GPU1.AT4 53.26,166.66 50.23,166.66 44.89,161.32 44.52,161.32 43.4,160.2 40.74,160.2 37.97,157.44 37.97,156.57 36.02,154.62 26.46,154.62 25.91,155.17 25.91,156.69 VRAMD1.D2
DDBID1_0: length 16.8
  TOP w0.13: GPU1.AW6 56.05,164.9 v6(55.6,164.45) ; VRAMD2.D2 51.2,151.9 v6(51.19,151.9)
  L6 w0.11: v6(55.6,164.45) 55,163.85 55,161.68 54.41,161.09 54.41,160.83 51.45,157.86 51.45,156.49 49.94,154.99 49.94,153.06 51.1,151.9 51.19,151.9 v6(51.19,151.9)
DDBID1_1: length 15.1
  TOP w0.13: VRAMD2.D13 v6(60,151.9) ; GPU1.AY14 61.75,163.55 v6(61.6,163.55)
  L6 w0.089: 58.96,154.53 58.9,154.47 58.9,154.34 58.8,154.24 58.8,153.19 60,151.99 v6(60,151.9)
  L6 w0.11: 58.96,154.53 58.96,156.7 61.56,159.3 61.56,161.86 62.08,162.38 62.08,163.07 v6(61.6,163.55)
DDBID1_2: length 25.5
  TOP w0.13: VRAMD2.P2 51.2,143.9 50.6,143.9 49.6,144.9 49.6,153.94 51.11,155.45 52.15,155.45 55.35,158.65 55.35,158.8 56.66,160.11 56.66,163.28 57.13,163.75 57.15,163.75 GPU1.AY8
DDBID1_3: length 21.1
  TOP w0.13: GPU1.BC14 62.2,159.34 62.3,159.24 62.3,156.06 62.08,155.84 62.08,154.82 63.35,153.55 63.35,152.14 64.23,151.26 64.23,146.21 61.95,143.93 60.82,143.93 60.4,143.5 VRAMD2.P13
DDCVGACLK: length 60.9
  TOP w0.114: GPU1.AD34 81.45,177.75 v6(81.45,177.6)
  L6 w0.102: v1(100,205.13) 100.2,205.33 103.02,205.33 105.28,203.07 105.28,202.54 106.12,201.7 106.82,201.7 108.51,200.01 108.51,197.66 109.27,196.9 109.27,193.22 109.63,192.86 109.63,191.11 108.92,190.4 108.92,186.84 99.87,177.8 92.18,177.8 91.87,178.1 81.96,178.1 v6(81.45,177.6)
  BOTTOM w0.114: v1(100,205.13) 100,204.34 100.25,204.09 v2(100.58,204.09) 100.78,204.09 R481.2
DDCVGADAT: length 69.6
  TOP w0.114: GPU1.AD33 80.65,177.75 v6(80.65,177.6)
  L6 w0.102: v1(98.64,211.55) 98.48,211.38 98.48,209.53 99.54,208.46 99.54,208.08 101.88,205.74 103.28,205.74 105.69,203.33 105.69,202.75 106.02,202.41 106.78,202.41 108.76,200.43 108.76,197.87 109.47,197.15 109.47,193.57 109.88,193.17 109.88,187.17 100.08,177.37 87.55,177.37 87.38,177.19 81.06,177.19 v6(80.65,177.6)
  BOTTOM w0.114: v1(98.64,211.55) 98.47,211.38 v5(97.66,211.38) 97.26,211.38 95.67,209.79 R482.2
DDI0_CRT_HPD: length 279.9
  TOP w0.114: DISPC1.3 85.09,60.25 85.62,59.72 85.62,59.49 88.11,57 v1(88.32,57) ; CPU1.H9 v6(182.5,174.5)
  L3 w0.114: v6(182.5,174.5) 182.5,174.17 183.01,173.66 183.01,172.41 183.33,172.09 184.67,172.09 185.04,172.46 185.04,172.77 186.18,173.91 187.98,173.91 189.08,175.01 193.12,175.01 197.52,179.41 197.52,191.93 190.49,198.96 156.73,198.96 156.6,198.84 131.1,198.84 129,196.74 129,194.42 114.12,179.54 114.12,168.09 113.2,167.18 113.2,156.15 111.07,154.02 111.07,152.97 112.52,151.51 112.52,143.79 111.96,143.23 111.96,138.25 107.06,133.35 107.06,123.22 107.65,122.63 107.65,110.67 103.35,106.38 103.35,106.35 103.1,106.1 103.07,106.1 102.31,105.33 100.76,105.33 97.89,102.46 v1(97.89,102.08)
  L4 w0.114: v1(97.89,102.08) 94.84,99.03 94.84,85.19 87.68,78.03 87.68,57.33 88.01,57 v1(88.32,57)
  BOTTOM w0.114: R2680.2 188.28,175.92 183.34,175.92 183.08,175.67 183.08,175.11 182.5,174.52 v6(182.5,174.5) ; v5(97.19,101.38) v1(97.89,102.08)
DDI0_VGA_AUX_CPU_N: length 210.3
  TOP w0.102: 89.81,69.8 87.33,69.8 85.62,68.1 84.91,68.1 84.76,68.25 DISPC1.19 ; 89.81,69.8 91.09,69.8 91.75,69.14 92.73,69.14 94.25,70.66 94.97,70.66 v1(95.35,71.04) ; 89.81,69.8 v3(89.81,70.18) ; CPU1.H10 v6(181.54,173.46)
  L3 w0.102: v6(181.54,173.46) 181.63,173.55 181.63,173.79 181.5,173.92 181.02,173.92 180.75,174.19 180.75,174.5 180.65,174.6 180.65,174.9 180.75,175 180.75,175.3 180.65,175.4 180.65,175.71 180.75,175.81 180.75,176.11 180.65,176.21 180.65,176.52 180.75,176.62 180.75,178.66 179.25,180.16 176.32,180.16 173.02,183.46 173.02,186.02 168.88,190.17 145.52,190.17 140.26,184.91 132.14,184.91 121.74,174.52 121.74,161.48 122.99,160.23 122.99,137.02 121.82,135.86 121.82,130.4 121.36,129.95 121.36,124.59 120.62,123.85 120.62,119.17 120.14,118.69 120.14,118.55 119.93,118.33 119.79,118.33 119.57,118.12 119.57,117.98 119.36,117.76 119.22,117.76 118.77,117.31 118.77,116.63 118.87,116.53 118.87,116.23 118.77,116.13 118.77,115.83 118.87,115.73 118.87,115.42 118.77,115.32 118.77,115.02 118.87,114.92 118.87,114.61 118.77,114.51 118.77,108.48 115.93,105.64 115.93,105.33 116.02,105.23 116.02,104.93 115.93,104.83 115.93,104.53 116.02,104.43 116.02,104.12 115.93,104.02 115.93,103.72 116.02,103.62 116.02,103.31 115.93,103.22 115.93,102.03 107.37,93.47 107.37,91.77 107.15,91.55 107.15,91.41 106.93,91.2 106.79,91.2 106.58,90.98 106.58,90.84 106.36,90.63 106.22,90.63 106.01,90.41 106.01,90.27 105.79,90.06 105.65,90.06 102.06,86.46 102.06,86.32 101.84,86.11 101.7,86.11 101.49,85.89 101.49,85.75 101.27,85.54 101.13,85.54 100.92,85.32 100.92,85.18 100.7,84.97 100.56,84.97 99.16,83.57 99.16,77.58 95.89,74.31 95.89,72.69 94.56,71.37 94.56,70.8 94.65,70.71 95.02,70.71 v1(95.35,71.04)
DDI0_VGA_AUX_CPU_P: length 210.3
  TOP w0.102: CPU1.G10 v6(182.5,173.5) ; 88.75,69.6 87.41,69.6 85.71,67.89 84.91,67.89 84.77,67.75 DISPC1.18 ; 88.75,69.6 v3(88.75,69.22) ; 88.75,69.6 91.01,69.6 91.67,68.94 92.81,68.94 94.34,70.46 95.02,70.46 v1(95.35,70.13)
  L3 w0.102: v1(95.35,70.13) 94.97,70.51 94.56,70.51 94.36,70.71 94.36,71.46 95.68,72.78 95.68,74.39 98.96,77.67 98.96,83.65 107.16,91.85 107.16,93.56 115.72,102.12 115.72,105.72 118.57,108.57 118.57,117.4 120.42,119.25 120.42,123.93 121.16,124.67 121.16,130.03 121.62,130.49 121.62,135.94 122.78,137.11 122.78,160.15 121.54,161.39 121.54,174.6 132.05,185.12 140.17,185.12 145.43,190.37 168.96,190.37 173.23,186.11 173.23,183.54 176.4,180.37 179.33,180.37 180.95,178.75 180.95,174.28 181.11,174.12 181.59,174.12 181.85,173.86 182.24,173.5 v6(182.5,173.5)
DDI0_VGA_DATA_CPU_N0: length 6.7
  TOP w0.102: v3(87.27,60.17) 86.98,59.88 ; 86.98,59.88 87.33,59.53 88,59.53 C1134.1 ; 86.98,59.88 86.57,60.29 86.57,61.33 85.8,62.1 84.89,62.1 84.75,62.25 DISPC1.7
DDI0_VGA_DATA_CPU_N0_R: length 243.9
  TOP w0.102: v1(187.81,183.4) 187.61,183.4 187.27,183.06 187.27,182.85 186.59,182.17 186.59,181.41 CPU1.C2 ; v1(90.35,60.02) 89.92,59.59 89.54,59.59 C1134.2
  L3 w0.102: v1(90.35,60.02) 90.75,59.61 91,59.61 93.22,61.83 93.22,63.48 93.07,63.63 92.75,63.63 92.48,63.9 92.48,64.28 92.75,64.54 93.07,64.54 93.22,64.69 93.22,64.9 93.07,65.05 92.75,65.05 92.48,65.32 92.48,65.7 92.75,65.97 93.07,65.97 93.22,66.12 93.22,70.17 91.62,71.77 91.62,80.37 92.89,81.64 92.89,88.65 106.02,101.79 106.02,104.67 111.71,110.36 111.71,114.46 111.56,114.61 111.24,114.61 110.97,114.88 110.97,115.25 111.24,115.52 111.56,115.52 111.71,115.67 111.71,118.77 112.19,119.25 112.57,119.25 113.03,118.79 113.24,118.79 113.39,118.94 113.39,119.15 112.93,119.61 112.93,119.99 114.79,121.84 115.16,121.84 115.62,121.39 115.83,121.39 115.98,121.54 115.98,121.75 115.53,122.2 115.53,122.58 116.26,123.31 116.26,133.99 116.99,134.73 116.99,138.4 118.62,140.03 118.62,142.77 118.03,143.35 118.03,147.71 118.3,147.98 118.47,147.98 118.62,148.12 118.62,148.33 118.47,148.48 118.3,148.48 118.03,148.75 118.03,149.13 118.3,149.4 118.47,149.4 118.62,149.55 118.62,149.76 118.47,149.91 118.3,149.91 118.03,150.17 118.03,150.85 118.62,151.43 118.62,154.97 118.47,155.12 117.74,155.12 117.47,155.39 117.47,155.76 117.74,156.03 118.47,156.03 118.62,156.18 118.62,158.35 118.21,158.75 118.21,158.75 116.76,160.2 116.76,178.23 132.99,194.46 140.97,194.46 141.12,194.61 141.12,195.13 141.39,195.4 141.77,195.4 142.04,195.13 142.04,194.61 142.19,194.46 142.71,194.46 143.07,194.82 169.99,194.82 170.45,195.28 175.51,195.28 175.61,195.38 175.61,196.08 175.83,196.3 176.31,196.3 176.53,196.08 176.53,195.38 176.63,195.28 177.22,195.28 177.33,195.38 177.33,196.02 177.55,196.24 178.02,196.24 178.24,196.02 178.24,195.38 179.6,194.01 179.6,190.07 179.96,189.71 180.17,189.71 180.56,190.1 180.94,190.1 181.21,189.83 181.21,189.45 180.82,189.06 180.82,188.85 180.97,188.7 181.18,188.7 181.57,189.09 181.95,189.09 182.22,188.82 182.22,188.44 181.83,188.05 181.83,187.84 181.98,187.69 182.19,187.69 182.58,188.08 182.95,188.08 183.22,187.81 183.22,187.43 182.84,187.05 182.84,186.84 182.98,186.69 183.19,186.69 183.58,187.08 183.96,187.08 184.23,186.81 184.23,186.43 183.84,186.04 183.84,185.83 185.6,184.07 187.13,184.07 v1(187.81,183.4)
  BOTTOM w0.102: v5(91.03,60.13) 90.45,60.13 v1(90.35,60.02)
DDI0_VGA_DATA_CPU_N1: length 5.5
  TOP w0.102: 86.78,63 87.57,62.21 87.94,62.21 C1136.1 ; 86.78,63 v3(87.07,63.3) ; 86.78,63 86.18,63.6 84.89,63.6 84.75,63.75 DISPC1.10
DDI0_VGA_DATA_CPU_N1_R: length 243.5
  TOP w0.102: CPU1.B3 187.6,180.4 187.6,180.62 188.04,181.05 188.27,181.05 189.81,182.6 189.81,183.01 v1(190.25,183.44) ; v1(90.3,62.76) 89.78,62.24 89.48,62.24 C1136.2
  L3 w0.102: v1(190.25,183.44) 189.89,183.79 189.89,184.23 189.34,184.78 185.98,184.78 185.5,185.27 185.5,186.55 180.72,191.32 180.72,193.15 180.87,193.3 181.65,193.3 181.91,193.57 181.91,193.94 181.65,194.21 180.87,194.21 180.72,194.36 180.72,194.87 178.57,197.02 174.22,197.02 174,196.79 174,196.17 173.89,196.07 173.59,196.07 173.49,196.17 173.49,196.79 173.27,197.02 172.59,197.02 172.32,196.75 172.32,196.14 172.17,195.99 171.96,195.99 171.82,196.14 171.82,196.75 171.55,197.02 164.87,197.02 164.6,196.75 164.6,195.68 164.45,195.53 164.24,195.53 164.09,195.68 164.09,196.75 163.83,197.02 163.45,197.02 163.18,196.75 163.18,195.68 163.03,195.53 162.82,195.53 162.67,195.68 162.67,196.75 162.4,197.02 157.52,197.02 156.03,195.53 144.98,195.53 144.39,196.11 134.94,196.11 134,195.17 132.67,195.17 116.05,178.55 116.05,155.21 116.97,154.3 116.97,151.55 117.3,151.22 117.3,142.81 115.94,141.45 115.94,141.14 116.41,140.68 116.41,140.54 116.19,140.32 116.05,140.32 115.58,140.78 115.27,140.78 114.68,140.19 114.68,139.17 114.33,138.82 114.33,138.14 114.55,137.92 115.11,137.92 115.21,137.82 115.21,137.52 115.11,137.41 114.55,137.41 114.33,137.19 114.33,126.6 113.92,126.2 113.92,125.04 109.63,120.75 109.63,117.86 110.26,117.22 110.26,115.74 110.11,115.59 109.92,115.59 109.65,115.32 109.65,114.94 109.92,114.67 110.11,114.67 110.26,114.52 110.26,109.93 104.42,104.09 104.42,101.2 92.18,88.96 92.18,81.99 90.91,80.72 90.91,71.14 91.67,70.38 91.67,67.34 91.01,66.68 91.01,66.3 91.28,66.04 91.6,66.04 91.74,65.89 91.74,65.68 91.6,65.53 91.28,65.53 91.01,65.26 91.01,64.88 91.28,64.61 91.6,64.61 91.74,64.47 91.74,62.57 91.53,62.36 90.7,62.36 v1(90.3,62.76)
  BOTTOM w0.102: v5(91.01,62.82) 90.98,62.82 90.35,62.82 v1(90.3,62.76)
DDI0_VGA_DATA_CPU_N2: length 5.1
  TOP w0.102: 87.4,65.03 88.02,65.03 C1138.1 ; 87.4,65.03 85.86,65.03 85.78,65.1 84.89,65.1 84.75,65.25 DISPC1.13 ; 87.4,65.03 v3(87.4,65.43)
DDI0_VGA_DATA_CPU_N2_R: length 245.5
  TOP w0.102: CPU1.A4 189.49,178.51 190.65,178.51 191.77,179.63 194.96,179.63 195.2,179.87 195.2,180.14 v1(194.84,180.49) ; C1138.2 90.26,65.4 v1(90.32,65.46)
  L3 w0.102: v1(194.84,180.49) 195.25,180.9 195.25,181.52 195.61,181.87 195.61,188.24 194.92,188.93 186.92,188.93 185.17,190.68 185.17,196.65 183.57,198.25 157.02,198.25 155.68,196.9 145.33,196.9 144.9,197.33 130.61,197.33 129.84,196.57 129.84,194.25 114.83,179.24 114.83,167.54 113.92,166.62 113.92,166.32 114.02,166.22 114.02,165.92 113.92,165.82 113.92,165.51 114.02,165.41 114.02,165.11 113.92,165.01 113.92,164.7 114.02,164.6 114.02,164.3 113.92,164.2 113.92,159.12 114.02,159.02 114.02,158.72 113.92,158.62 113.92,158.31 114.02,158.21 114.02,157.91 113.92,157.81 113.92,157.51 114.02,157.41 114.02,157.1 113.92,157 113.92,155.86 111.79,153.72 111.79,153.29 113.28,151.79 113.28,146.57 113.38,146.48 113.38,146.17 113.28,146.07 113.28,145.77 113.38,145.67 113.38,145.36 113.28,145.26 113.28,143.02 113,142.74 113,128.31 110.1,125.4 110.1,125.26 109.88,125.05 109.74,125.05 109.52,124.83 109.52,124.69 109.31,124.47 109.17,124.47 108.95,124.26 108.95,124.12 108.74,123.9 108.6,123.9 108.31,123.61 108.31,122.99 108.36,122.93 108.36,110.32 108.22,110.17 108.22,110.03 108,109.82 107.86,109.82 107.65,109.6 107.65,109.46 107.43,109.25 107.29,109.25 107.07,109.03 107.07,108.89 106.86,108.67 106.72,108.67 103.13,105.08 103.13,104.94 102.91,104.73 102.77,104.73 102.56,104.51 102.56,104.37 102.34,104.16 102.2,104.16 101.98,103.94 101.98,103.8 101.77,103.59 101.63,103.59 99.67,101.63 99.48,101.63 97.76,99.91 97.76,99.77 97.55,99.55 97.41,99.55 97.19,99.34 97.19,99.2 96.97,98.98 96.83,98.98 96.62,98.77 96.62,98.63 96.4,98.41 96.26,98.41 92.67,94.82 92.67,94.68 92.46,94.46 92.32,94.46 92.1,94.25 92.1,94.11 91.88,93.89 91.74,93.89 91.53,93.68 91.53,93.54 91.31,93.32 91.17,93.32 90.96,93.11 90.96,82.5 89.11,80.66 89.11,79.74 89.21,79.64 89.21,79.33 89.11,79.23 89.11,78.93 89.21,78.83 89.21,78.52 89.11,78.43 89.11,78.12 89.21,78.02 89.21,77.72 89.11,77.62 89.11,72.54 89.21,72.44 89.21,72.13 89.11,72.03 89.11,71.73 89.21,71.63 89.21,71.33 89.11,71.23 89.11,70.92 89.21,70.82 89.21,70.52 89.11,70.42 89.11,70.11 88.82,69.82 88.82,66.76 88.93,66.66 88.93,66.35 88.82,66.25 88.82,65.95 89.7,65.07 89.94,65.07 v1(90.32,65.46)
  BOTTOM w0.102: v1(194.84,180.49) v2(194.84,179.81)
DDI0_VGA_DATA_CPU_N3: length 5.5
  TOP w0.102: 87.38,67.71 88,67.71 C1140.1 ; 87.38,67.71 87.13,67.71 86.02,66.6 84.89,66.6 84.75,66.75 DISPC1.16 ; 87.38,67.71 v3(87.38,68.1)
DDI0_VGA_DATA_CPU_N3_R: length 244.1
  TOP w0.102: CPU1.C6 v6(187.46,176.52) ; v1(90.33,68.25) 90.15,68.06 C1140.2
  L3 w0.102: v6(187.46,176.52) 187.88,176.9 188.07,176.89 189.53,178.36 189.53,179.16 192.62,182.25 193.93,182.25 195.1,183.41 195.1,185.66 193.86,186.89 186.16,186.89 182.63,190.42 182.63,191.62 182.77,191.76 184.16,191.76 184.43,192.03 184.43,192.41 184.16,192.68 182.77,192.68 182.63,192.83 182.63,193.04 182.77,193.19 184.16,193.19 184.43,193.45 184.43,193.83 184.16,194.1 182.77,194.1 182.63,194.25 182.63,196.76 181.66,197.73 157.22,197.73 155.89,196.39 145.12,196.39 144.69,196.82 131.01,196.82 130.35,196.17 130.35,194.04 115.34,179.03 115.34,152.16 116.59,150.92 116.59,145.73 115.32,144.46 115.32,142.37 113.51,140.56 113.51,126.8 113.21,126.49 113.21,126.12 111.22,124.13 110.96,124.13 108.89,122.06 108.89,109.94 102.84,103.89 102.84,100.87 91.47,89.49 91.47,82.29 89.74,80.56 89.74,71.21 90.96,69.99 90.96,67.96 90.79,67.79 90.69,67.79 90.33,68.15 v1(90.33,68.25)
  BOTTOM w0.102: v5(91.03,68.24) 90.34,68.24 v1(90.33,68.25)
DDI0_VGA_DATA_CPU_P0: length 6.7
  TOP w0.102: C1133.1 88,59.33 87.25,59.33 86.37,60.21 86.37,60.66 ; 86.37,60.66 86.37,61.25 85.72,61.9 84.89,61.9 84.75,61.75 DISPC1.6 ; 86.37,60.66 v3(85.98,60.66)
DDI0_VGA_DATA_CPU_P0_R: length 243.9
  TOP w0.102: CPU1.D2 186.39,181.39 186.39,182.25 187.07,182.93 187.07,183.22 v1(186.89,183.4) ; C1133.2 89.66,59.39 89.94,59.39 v1(90.32,59)
  L3 w0.102: v1(186.89,183.4) 186.89,183.79 186.82,183.87 185.51,183.87 183.64,185.74 183.64,186.12 184.03,186.51 184.03,186.72 183.88,186.87 183.67,186.87 183.28,186.48 182.9,186.48 182.63,186.75 182.63,187.13 183.02,187.52 183.02,187.73 182.87,187.88 182.66,187.88 182.27,187.49 181.89,187.49 181.63,187.76 181.63,188.14 182.01,188.53 182.01,188.74 181.86,188.89 181.65,188.89 181.27,188.5 180.89,188.5 180.62,188.77 180.62,189.14 181.01,189.53 181.01,189.74 180.86,189.89 180.65,189.89 180.26,189.51 179.88,189.51 179.4,189.98 179.4,193.93 178.04,195.29 178.04,195.93 177.93,196.03 177.63,196.03 177.53,195.93 177.53,195.29 177.31,195.07 176.54,195.07 176.32,195.29 176.32,196 176.22,196.1 175.92,196.1 175.82,196 175.82,195.29 175.6,195.07 170.54,195.07 170.08,194.61 143.15,194.61 142.8,194.26 142.1,194.26 141.83,194.53 141.83,195.05 141.68,195.2 141.47,195.2 141.33,195.05 141.33,194.53 141.06,194.26 133.08,194.26 116.97,178.15 116.97,160.28 118.3,158.95 118.3,158.95 118.82,158.43 118.82,156.1 118.55,155.83 117.83,155.83 117.68,155.68 117.68,155.47 117.83,155.32 118.55,155.32 118.82,155.05 118.82,151.35 118.24,150.77 118.24,150.26 118.39,150.11 118.55,150.11 118.82,149.84 118.82,149.46 118.55,149.2 118.39,149.2 118.24,149.05 118.24,148.84 118.39,148.69 118.55,148.69 118.82,148.42 118.82,148.04 118.55,147.77 118.39,147.77 118.24,147.62 118.24,143.43 118.82,142.85 118.82,139.95 117.2,138.32 117.2,134.64 116.46,133.91 116.46,123.23 115.73,122.5 115.73,122.29 116.19,121.83 116.19,121.45 115.92,121.18 115.54,121.18 115.08,121.64 114.87,121.64 113.13,119.9 113.13,119.69 113.59,119.23 113.59,118.86 113.32,118.59 112.94,118.59 112.49,119.04 112.28,119.04 111.92,118.68 111.92,117.57 112.01,117.47 112.01,117.17 111.92,117.07 111.92,116.76 112.01,116.66 112.01,116.36 111.92,116.26 111.92,115.59 111.65,115.32 111.32,115.32 111.18,115.17 111.18,114.96 111.32,114.81 111.65,114.81 111.92,114.54 111.92,114.24 112.01,114.14 112.01,113.83 111.92,113.74 111.92,113.43 112.01,113.33 112.01,113.03 111.92,112.93 111.92,112.62 112.01,112.52 112.01,112.22 111.92,112.12 111.92,110.27 111.7,110.06 111.7,109.92 111.48,109.7 111.34,109.7 111.13,109.49 111.13,109.35 110.91,109.13 110.77,109.13 110.56,108.92 110.56,108.78 110.34,108.56 110.2,108.56 107.94,106.29 107.94,106.15 107.72,105.94 107.58,105.94 107.37,105.72 107.37,105.58 107.15,105.37 107.01,105.37 106.79,105.15 106.79,105.01 106.58,104.8 106.44,104.8 106.22,104.58 106.22,101.7 93.09,88.57 93.09,81.55 91.82,80.28 91.82,76.77 91.92,76.67 91.92,76.36 91.82,76.26 91.82,71.86 93.42,70.26 93.42,66.03 93.15,65.76 92.83,65.76 92.68,65.62 92.68,65.41 92.83,65.26 93.15,65.26 93.42,64.99 93.42,64.61 93.15,64.34 92.83,64.34 92.68,64.19 92.68,63.98 92.83,63.83 93.15,63.83 93.42,63.57 93.42,61.75 91.08,59.41 90.73,59.41 v1(90.32,59)
  BOTTOM w0.102: v1(90.32,59) 90.71,59 v5(90.97,58.75)
DDI0_VGA_DATA_CPU_P1: length 5.5
  TOP w0.102: 87.3,62.2 87.49,62.01 87.94,62.01 C1135.1 ; 87.3,62.2 v3(87.02,61.93) ; 87.3,62.2 86.1,63.4 84.89,63.4 84.75,63.25 DISPC1.9
DDI0_VGA_DATA_CPU_P1_R: length 243.5
  TOP w0.102: v1(189.33,183.44) 189.61,183.16 189.61,182.68 188.18,181.25 187.95,181.25 187.4,180.7 187.4,180.4 CPU1.C3 ; v1(90.3,61.75) 90.01,62.04 89.55,62.04 C1135.2
  L3 w0.102: v1(90.3,61.75) 90.7,62.15 91.62,62.15 91.95,62.48 91.95,64.55 91.68,64.82 91.36,64.82 91.21,64.97 91.21,65.18 91.36,65.33 91.68,65.33 91.95,65.59 91.95,65.97 91.68,66.24 91.36,66.24 91.21,66.39 91.21,66.6 91.87,67.26 91.87,70.46 91.11,71.22 91.11,80.64 92.38,81.91 92.38,88.87 104.62,101.12 104.62,104 110.46,109.85 110.46,110.15 110.56,110.25 110.56,110.56 110.46,110.65 110.46,110.96 110.56,111.06 110.56,111.36 110.46,111.46 110.46,111.77 110.56,111.87 110.56,112.17 110.46,112.27 110.46,114.61 110.2,114.88 110,114.88 109.86,115.03 109.86,115.24 110,115.38 110.2,115.38 110.46,115.65 110.46,117.31 109.83,117.94 109.83,120.67 110.43,121.26 110.57,121.26 110.78,121.48 110.78,121.62 111,121.83 111.14,121.83 111.35,122.05 111.35,122.19 111.57,122.41 111.71,122.41 111.92,122.62 111.92,122.76 114.12,124.96 114.12,126.11 114.53,126.52 114.53,137.11 114.63,137.21 115.2,137.21 115.42,137.43 115.42,137.9 115.2,138.13 114.63,138.13 114.53,138.23 114.53,138.73 114.88,139.09 114.88,140.11 115.36,140.58 115.5,140.58 115.96,140.12 116.27,140.12 116.61,140.45 116.61,140.76 116.15,141.23 116.15,141.37 117.5,142.72 117.5,151.31 117.17,151.64 117.17,154.38 116.26,155.3 116.26,178.47 132.76,194.97 134.09,194.97 135.03,195.91 144.31,195.91 144.89,195.33 156.11,195.33 157.6,196.81 162.32,196.81 162.47,196.66 162.47,195.59 162.74,195.33 163.12,195.33 163.38,195.59 163.38,196.66 163.53,196.81 163.74,196.81 163.89,196.66 163.89,195.59 164.16,195.33 164.54,195.33 164.81,195.59 164.81,196.66 164.95,196.81 171.46,196.81 171.61,196.66 171.61,196.05 171.88,195.78 172.26,195.78 172.53,196.05 172.53,196.66 172.68,196.81 173.18,196.81 173.29,196.71 173.29,196.09 173.51,195.87 173.98,195.87 174.2,196.09 174.2,196.71 174.3,196.81 178.49,196.81 180.52,194.78 180.52,194.28 180.79,194.01 181.56,194.01 181.71,193.86 181.71,193.65 181.56,193.5 180.79,193.5 180.52,193.23 180.52,191.24 185.29,186.46 185.29,185.19 185.9,184.58 189.26,184.58 189.69,184.15 189.69,183.79 v1(189.33,183.44)
  BOTTOM w0.102: v1(90.3,61.75) 90.42,61.75 90.71,61.45 v5(90.94,61.45)
DDI0_VGA_DATA_CPU_P2: length 5.1
  TOP w0.102: DISPC1.12 84.75,64.75 84.89,64.9 85.7,64.9 85.77,64.83 86.28,64.83 ; 86.28,64.83 v3(86.28,64.44) ; 86.28,64.83 88.02,64.83 C1137.1
DDI0_VGA_DATA_CPU_P2_R: length 245.2
  TOP w0.102: v3(195.5,179.32) 195.22,179.6 ; 195.22,179.6 195.4,179.78 195.4,180.04 v1(195.86,180.49) ; 195.22,179.6 195.05,179.43 191.85,179.43 190.74,178.31 189.4,178.31 189.11,178.6 188.4,178.6 CPU1.B4 ; C1137.2 90.24,64.46 v1(90.32,64.54)
  L3 w0.102: v1(195.86,180.49) 195.45,180.9 195.45,181.43 195.81,181.79 195.81,188.32 195,189.13 187,189.13 185.37,190.76 185.37,196.73 183.65,198.45 156.94,198.45 155.59,197.1 145.41,197.1 144.98,197.54 130.52,197.54 129.64,196.65 129.64,194.34 114.63,179.32 114.63,167.62 113.72,166.71 113.72,155.94 111.58,153.81 111.58,153.2 113.08,151.71 113.08,143.1 112.8,142.82 112.8,128.39 108.1,123.7 108.1,122.9 108.16,122.84 108.16,110.45 108.07,110.37 108.07,110.32 99.59,101.83 99.39,101.83 90.75,93.19 90.75,82.58 88.91,80.74 88.91,70.2 88.62,69.91 88.62,65.86 89.61,64.87 89.99,64.87 v1(90.32,64.54)
DDI0_VGA_DATA_CPU_P3: length 5.5
  TOP w0.102: 86.52,66.82 86.1,66.4 84.89,66.4 84.75,66.25 DISPC1.15 ; 86.52,66.82 87.21,67.51 88,67.51 C1139.1 ; 86.52,66.82 v3(86.79,66.55)
DDI0_VGA_DATA_CPU_P3_R: length 244
  TOP w0.102: v1(90.33,67.23) 90.25,67.15 C1139.2 ; CPU1.C5 v6(187.5,177.52)
  L3 w0.102: v1(90.33,67.23) 90.69,67.59 90.87,67.59 91.16,67.88 91.16,70.08 89.94,71.3 89.94,80.48 91.67,82.2 91.67,89.41 103.05,100.79 103.05,103.81 109.09,109.86 109.09,121.97 111.05,123.93 111.3,123.93 111.52,124.14 111.66,124.14 111.88,124.36 111.88,124.5 112.09,124.71 112.23,124.71 112.45,124.93 112.45,125.07 112.66,125.29 112.8,125.29 113.02,125.5 113.02,125.64 113.41,126.03 113.41,126.41 113.72,126.71 113.72,140.48 115.52,142.28 115.52,144.37 116.79,145.64 116.79,151 115.54,152.25 115.54,178.94 130.56,193.96 130.56,196.09 131.09,196.62 131.86,196.62 131.96,196.52 132.27,196.52 132.37,196.62 132.67,196.62 132.77,196.52 133.08,196.52 133.17,196.62 133.48,196.62 133.58,196.52 133.88,196.52 133.98,196.62 144.6,196.62 145.04,196.19 145.34,196.19 145.44,196.09 145.74,196.09 145.84,196.19 146.15,196.19 146.25,196.09 146.55,196.09 146.65,196.19 146.96,196.19 147.06,196.09 147.36,196.09 147.46,196.19 155.97,196.19 157.3,197.52 181.57,197.52 182.42,196.67 182.42,194.17 182.69,193.9 184.08,193.9 184.23,193.75 184.23,193.54 184.08,193.39 182.69,193.39 182.42,193.12 182.42,192.74 182.69,192.48 184.08,192.48 184.23,192.33 184.23,192.12 184.08,191.97 182.69,191.97 182.42,191.7 182.42,190.34 186.07,186.69 193.78,186.69 194.89,185.57 194.89,183.5 193.84,182.45 192.53,182.45 189.33,179.25 189.33,178.45 188.66,177.77 187.99,177.1 187.88,177.11 v6(187.5,177.52)
  BOTTOM w0.102: v5(90.89,66.83) 90.48,67.23 v1(90.33,67.23)
DDI1_DATA_CPU_N0: length 7.5
  TOP w0.102: v3(86.64,79.04) 86.23,79.04 ; 86.23,79.04 86.23,79.63 87.23,80.63 88.35,80.63 C1126.1 ; 86.23,79.04 86.23,78.23 85.39,77.39 84.89,77.39 84.75,77.25 DISPC1.37
DDI1_DATA_CPU_N0_R: length 205.1
  TOP w0.102: CPU1.D5 186,178 186.46,177.54 v6(186.46,177.52) ; 91.29,80.62 89.95,80.62 C1126.2 ; 91.29,80.62 92.36,80.62 93.43,81.69 93.95,81.69 v1(94.36,81.28) ; 91.29,80.62 v3(91.29,80.24)
  L3 w0.102: v6(186.46,177.52) 186.46,177.69 186.26,177.89 186,177.89 185.67,178.22 185.67,179.81 185.95,180.09 185.95,181.33 180.33,186.95 180.19,186.95 179.41,186.17 179.1,186.17 178.76,186.51 178.76,186.82 179.54,187.6 179.54,187.74 177.03,190.25 177.03,191.3 176.9,191.42 176.65,191.42 176.52,191.3 176.52,189.98 176.3,189.76 175.83,189.76 175.61,189.98 175.61,190.98 175.51,191.08 174.21,191.08 172.38,192.91 143.56,192.91 143.48,192.84 133.71,192.84 118.39,177.51 118.39,160.88 119.84,159.44 119.85,159.44 120.24,159.04 120.24,138.94 118.97,137.67 118.97,134.33 117.88,133.23 117.88,121.02 113.61,116.76 113.61,108.6 112.09,107.08 112.09,102.67 97.51,88.09 95.74,88.09 95.28,87.62 95.28,84.29 95.78,83.78 95.78,82.02 95.46,81.7 94.78,81.7 v1(94.36,81.28)
DDI1_DATA_CPU_N1: length 6.5
  TOP w0.102: C1128.1 88.37,78.45 87.59,78.45 87.12,77.98 87.12,77.22 85.8,75.9 84.89,75.9 84.75,75.75 DISPC1.34
DDI1_DATA_CPU_N1_R: length 206.2
  TOP w0.102: CPU1.D8 v6(185.5,175.5) ; v3(91.41,78.05) 91.41,78.45 ; 91.41,78.45 89.94,78.45 C1128.2 ; 91.41,78.45 92.1,78.45 v1(92.46,78.09)
  L3 w0.102: v1(92.46,78.09) 92.83,78.46 93.02,78.46 93.37,78.82 93.37,80.8 93.85,81.28 93.85,85.64 93.95,85.74 93.95,86.05 93.85,86.15 93.85,86.45 93.95,86.55 93.95,86.86 93.85,86.95 93.85,87.26 93.95,87.36 93.95,87.66 93.85,87.76 93.85,88.32 107.67,102.13 107.67,104.72 112.9,109.96 112.9,117.16 117.17,121.43 117.17,133.53 118.21,134.57 118.21,138.11 119.53,139.43 119.53,158.72 117.68,160.58 117.68,177.82 133.41,193.55 143.18,193.55 143.43,193.8 170.57,193.8 171.03,194.26 177.52,194.26 178.49,193.29 178.49,189.86 186.89,181.45 186.89,177.22 185.9,176.22 185.9,175.9 v6(185.5,175.5)
DDI1_DATA_CPU_N2: length 6.1
  TOP w0.102: 85.95,74.78 85.57,74.4 84.89,74.4 84.75,74.25 DISPC1.31 ; 85.95,74.78 87.46,76.29 88.37,76.29 C1130.1 ; 85.95,74.78 v3(86.23,74.5)
DDI1_DATA_CPU_N2_R: length 206.2
  TOP w0.102: v3(91.41,75.87) 91.41,76.25 ; 91.41,76.25 89.89,76.25 89.6,75.96 C1130.2 ; 91.41,76.25 92.87,76.25 93.4,76.78 94.02,76.78 v1(94.36,76.44) ; CPU1.G8 v6(183.5,175.5)
  L3 w0.089: 183.72,178.97 183.72,178.94 183.73,178.94 183.73,178.28 183.91,178.1 183.91,177.84 183.81,177.74 183.81,177.47 183.91,177.37 183.91,175.63 183.78,175.5 v6(183.5,175.5)
  L3 w0.102: v1(94.36,76.44) 94.72,76.8 95.39,76.8 96.09,77.5 96.09,80.01 97.71,81.64 97.71,84.37 98.27,84.93 98.27,86.71 113.79,102.23 113.79,106.75 115.44,108.4 115.44,115.34 116.99,116.89 116.99,117.49 119.3,119.8 119.3,132.64 120.45,133.79 120.45,136.77 121.67,137.99 121.67,159.65 119.89,161.43 119.89,175.52 128.88,184.52 129.02,184.52 129.24,184.73 129.24,184.87 129.45,185.09 129.59,185.09 129.81,185.31 129.81,185.45 130.03,185.66 130.17,185.66 130.38,185.88 130.38,186.02 130.6,186.23 138.98,186.23 142.52,189.78 142.66,189.78 142.88,189.99 142.88,190.13 143.09,190.35 143.23,190.35 143.45,190.56 143.45,190.7 143.67,190.92 143.81,190.92 144.02,191.13 144.02,191.27 144.24,191.49 170.27,191.49 170.49,191.27 170.49,191.13 170.7,190.92 170.84,190.92 171.06,190.7 171.06,190.56 171.28,190.35 171.42,190.35 171.63,190.13 171.63,189.99 171.85,189.78 171.99,189.78 172.72,189.05 173.03,189.05 173.55,189.56 173.69,189.56 173.91,189.34 173.91,189.2 173.39,188.69 173.39,188.37 173.73,188.04 174.04,188.04 174.55,188.55 174.7,188.55 174.91,188.34 174.91,188.19 174.4,187.68 174.4,187.37 174.73,187.03 175.05,187.03 175.56,187.55 175.71,187.55 175.92,187.33 175.92,187.19 175.41,186.67 175.41,186.36 175.58,186.19 175.58,186.05 175.79,185.83 175.93,185.83 176.15,185.61 176.15,185.47 176.37,185.26 176.51,185.26 176.72,185.04 176.72,184.9 176.94,184.69 177.08,184.69 177.63,184.13 177.94,184.13 178.39,184.58 178.53,184.58 178.75,184.36 178.75,184.22 178.3,183.77 178.3,183.46 179.82,181.94 180.13,181.94 180.23,181.84 180.53,181.84 180.63,181.94 180.94,181.94 181.04,181.84 181.34,181.84 181.44,181.94 182.06,181.94 182.27,181.72 182.27,181.58 182.49,181.37 182.63,181.37 183.72,180.27 183.72,178.97
DDI1_DATA_CPU_N3: length 5.9
  TOP w0.102: 86.08,73.15 85.83,72.9 84.76,72.9 84.61,72.75 DISPC1.28 ; 86.08,73.15 v3(86.36,72.87) ; 86.08,73.15 87.08,74.15 88.33,74.15 C1132.1
DDI1_DATA_CPU_N3_R: length 206.2
  TOP w0.102: CPU1.F9 v6(184.5,174.5) ; v1(92.43,73.71) 92.01,74.13 91.36,74.13 ; 91.36,74.13 v3(91.36,73.74) ; 91.36,74.13 89.92,74.13 C1132.2
  L3 w0.089: v6(184.5,174.5) 184.9,174.9 184.9,178.98 184.66,179.23 184.66,179.8 184.65,179.81 184.65,179.83
  L3 w0.102: v1(92.43,73.71) 92.85,74.13 93.18,74.13 93.51,74.47 93.51,77.94 94.28,78.71 94.28,79.38 97,82.09 97,84.68 97.56,85.24 97.56,87.11 112.9,102.46 112.9,106.88 114.73,108.7 114.73,116.26 118.59,120.12 118.59,132.94 119.68,134.03 119.68,137.18 120.95,138.45 120.95,159.34 119.15,161.15 119.15,177.21 134.07,192.13 143.87,192.13 143.94,192.2 172.06,192.2 176.7,187.56 177.01,187.56 177.79,188.35 177.93,188.35 178.15,188.13 178.15,187.98 177.37,187.2 177.37,186.89 179.41,184.85 179.41,184.71 179.63,184.49 179.77,184.49 179.98,184.28 179.98,184.14 180.2,183.92 180.34,183.92 180.55,183.71 180.55,183.57 180.77,183.35 180.91,183.35 181.13,183.13 182.19,183.13 184.65,180.67 184.65,179.83
DDI1_DATA_CPU_P0: length 7.5
  TOP w0.102: C1125.1 88.37,80.83 87.15,80.83 86.69,80.37 ; v3(86.41,80.64) 86.69,80.37 ; 86.69,80.37 86.03,79.71 86.03,78.32 85.31,77.6 84.9,77.6 84.75,77.75 DISPC1.38
DDI1_DATA_CPU_P0_R: length 205.2
  TOP w0.102: 92.81,81.36 92.28,80.82 89.95,80.82 C1125.2 ; 92.81,81.36 v3(92.53,81.64) ; 92.81,81.36 93.34,81.89 94.06,81.89 v1(94.36,82.19) ; CPU1.D4 186,178.86 186.38,178.49 v6(186.49,178.49)
  L3 w0.102: v1(94.36,82.19) 94.65,81.91 95.38,81.91 95.58,82.11 95.58,83.69 95.07,84.2 95.07,87.71 95.66,88.29 97.43,88.29 111.89,102.75 111.89,107.16 113.41,108.69 113.41,116.84 117.68,121.11 117.68,133.32 118.77,134.41 118.77,137.75 120.04,139.02 120.04,158.95 119.76,159.23 119.75,159.23 118.19,160.8 118.19,177.6 133.63,193.04 143.4,193.04 143.48,193.12 172.46,193.12 174.3,191.28 175.59,191.28 175.81,191.06 175.81,190.06 175.91,189.96 176.22,189.96 176.32,190.06 176.32,191.38 176.57,191.63 176.99,191.63 177.23,191.38 177.23,190.34 179.75,187.83 179.75,187.51 178.96,186.73 178.96,186.59 179.18,186.37 179.32,186.37 180.11,187.15 180.42,187.15 186.16,181.41 186.16,180.01 185.88,179.73 185.88,178.31 186.09,178.1 186.29,178.1 186.49,178.3 v6(186.49,178.49)
DDI1_DATA_CPU_P1: length 6.9
  TOP w0.102: DISPC1.35 84.75,76.25 84.89,76.1 85.72,76.1 86.52,76.9 ; 86.52,76.9 v3(86.23,77.19) ; 86.52,76.9 86.92,77.3 86.92,78.06 87.51,78.65 88.37,78.65 C1127.1
DDI1_DATA_CPU_P1_R: length 206.3
  TOP w0.102: C1127.2 89.94,78.65 90.58,78.65 ; v3(90.58,79.04) 90.58,78.65 ; 90.58,78.65 92.1,78.65 v1(92.46,79.01) ; CPU1.D7 v6(186.5,175.5)
  L3 w0.102: v6(186.5,175.5) 186.1,175.9 186.1,176.14 187.1,177.13 187.1,181.53 178.69,189.94 178.69,193.38 177.6,194.46 170.94,194.46 170.48,194.01 143.35,194.01 143.1,193.75 133.32,193.75 117.47,177.9 117.47,160.49 119.33,158.64 119.33,139.51 118.01,138.19 118.01,134.65 116.97,133.61 116.97,121.51 112.7,117.25 112.7,110.04 107.47,104.81 107.47,102.22 93.65,88.4 93.65,81.36 93.17,80.88 93.17,78.9 92.93,78.67 92.8,78.67 v1(92.46,79.01)
DDI1_DATA_CPU_P2: length 6.1
  TOP w0.102: 87.68,76.49 87.38,76.49 85.49,74.6 84.89,74.6 84.75,74.75 DISPC1.32 ; 87.68,76.49 v3(87.68,76.89) ; 87.68,76.49 88.37,76.49 C1129.1
DDI1_DATA_CPU_P2_R: length 206.2
  TOP w0.102: v3(90.58,76.83) 90.58,76.45 ; 90.58,76.45 92.79,76.45 93.32,76.99 93.99,76.99 v1(94.36,77.36) ; 90.58,76.45 89.97,76.45 89.6,76.82 C1129.2 ; CPU1.F8 v6(183.5,174.5)
  L3 w0.089: v6(183.5,174.5) 184.1,175.1 184.1,175.79 184.1,178.18 183.92,178.36 183.92,178.94 183.93,178.94 183.93,178.97
  L3 w0.102: 183.93,178.97 183.93,180.36 182.14,182.14 179.91,182.14 178.51,183.54 178.51,183.69 178.95,184.14 178.95,184.45 178.62,184.78 178.31,184.78 177.86,184.34 177.72,184.34 175.61,186.44 175.61,186.59 176.13,187.1 176.13,187.41 175.79,187.75 175.48,187.75 174.96,187.23 174.82,187.23 174.6,187.45 174.6,187.59 175.12,188.11 175.12,188.42 174.78,188.76 174.47,188.76 173.95,188.24 173.81,188.24 173.59,188.46 173.59,188.6 174.11,189.12 174.11,189.43 173.78,189.76 173.46,189.76 172.95,189.25 172.8,189.25 170.36,191.69 144.15,191.69 138.89,186.44 130.51,186.44 119.68,175.61 119.68,161.34 121.46,159.56 121.46,138.07 120.24,136.85 120.24,133.87 119.1,132.73 119.1,119.89 116.79,117.58 116.79,116.98 115.24,115.43 115.24,108.48 113.59,106.83 113.59,102.31 98.07,86.79 98.07,85.01 97.51,84.45 97.51,81.72 95.89,80.09 95.89,77.58 95.31,77 94.72,77 v1(94.36,77.36)
DDI1_DATA_CPU_P3: length 5.9
  TOP w0.102: DISPC1.29 84.66,73.25 84.81,73.1 85.74,73.1 86.99,74.35 87.63,74.35 ; C1131.1 88.39,74.35 87.63,74.35 ; 87.63,74.35 v3(87.63,74.75)
DDI1_DATA_CPU_P3_R: length 206.2
  TOP w0.102: v3(90.6,74.75) 90.6,74.33 ; 90.6,74.33 89.94,74.33 C1131.2 ; 90.6,74.33 92.04,74.33 v1(92.41,74.7) ; CPU1.E9 v6(185.5,174.5)
  L3 w0.089: v6(185.5,174.5) 185.1,174.9 185.1,179.06 184.85,179.31 184.85,179.8 184.85,179.81 184.85,179.83
  L3 w0.102: 184.85,179.83 184.85,180.75 182.27,183.34 181.21,183.34 177.57,186.98 177.57,187.12 178.35,187.9 178.35,188.21 178.02,188.55 177.7,188.55 176.92,187.77 176.78,187.77 172.14,192.41 143.86,192.41 143.78,192.33 133.99,192.33 118.95,177.29 118.95,161.06 120.75,159.26 120.75,138.53 119.48,137.26 119.48,134.11 118.39,133.02 118.39,120.2 114.53,116.34 114.53,108.79 112.7,106.96 112.7,102.54 97.36,87.2 97.36,85.33 96.8,84.77 96.8,82.18 94.08,79.46 94.08,78.79 93.31,78.02 93.31,74.55 93.09,74.33 92.78,74.33 v1(92.41,74.7)
DDI1_HDMI1_CLK_CPU: length 211.8
  TOP w0.102: CPU1.F11 v6(184.5,172.5) ; 87.76,71.6 90.68,71.6 90.96,71.32 91.95,71.32 92.13,71.51 RN3.2 92.13,72.19 92.25,72.31 92.64,72.31 92.93,72.61 93.66,72.61 v1(93.98,72.93) ; 87.76,71.6 84.89,71.6 84.75,71.75 DISPC1.26 ; 87.76,71.6 v3(87.76,71.98)
  L3 w0.089: 183.1,177 183.1,176.97 183.09,176.97 183.09,174.75 183.09,174.74 183.09,174.34 183.34,174.09 183.74,174.09 184.1,173.74 184.1,172.9 v6(184.5,172.5)
  L3 w0.101: 183.27,178.24 183.27,177.73 183.1,177.56 183.1,177
  L3 w0.102: v1(93.98,72.93) 94.28,72.63 94.56,72.63 94.89,72.96 94.89,74.86 98.35,78.32 98.35,84.12 105.72,91.49 105.72,93.15 114.45,101.89 114.45,105.97 117.96,109.47 117.96,117.66 119.81,119.52 119.81,129.55 121.01,130.74 121.01,136.2 122.17,137.37 122.17,159.87 120.55,161.49 120.55,167.27 120.93,167.65 120.93,174.85 131.8,185.72 139.88,185.72 145.14,190.98 169.39,190.98 174.14,186.23 174.14,185.7 177.22,182.62 177.22,182.31 176.54,181.63 176.54,181.48 176.74,181.29 176.88,181.29 177.56,181.97 177.87,181.97 178.54,181.31 180.82,181.31 182.04,180.09 182.78,180.09 183.27,179.6 183.27,178.24
DDI1_HDMI1_DATA_CPU: length 211.8
  TOP w0.102: 91.06,71.12 90.87,71.12 90.59,71.4 90.4,71.4 90.3,71.3 90,71.3 89.9,71.4 89.59,71.4 89.49,71.3 89.19,71.3 89.09,71.4 88.78,71.4 88.68,71.3 88.38,71.3 88.28,71.4 84.89,71.4 84.75,71.25 DISPC1.25 ; 91.06,71.12 v3(91.06,70.71) ; 91.06,71.12 92.46,71.12 92.78,71.45 RN3.1 92.78,72.17 93.02,72.41 93.59,72.41 v1(93.98,72.02) ; CPU1.G11 v6(183.5,172.5)
  L3 w0.089: v6(183.5,172.5) 183.9,172.9 183.9,173.66 183.66,173.9 183.26,173.9 182.9,174.26 182.9,174.67 182.9,176.97 182.89,176.97 182.89,177
  L3 w0.101: 182.89,177 182.89,177.65 183.07,177.82 183.07,178.15 183.06,178.15 183.06,178.24
  L3 w0.102: 183.06,178.24 183.06,179.51 182.69,179.88 181.96,179.88 180.74,181.1 178.45,181.1 177.79,181.76 177.65,181.76 176.96,181.08 176.65,181.08 176.33,181.4 176.33,181.71 177.02,182.39 177.02,182.54 173.94,185.62 173.94,186.15 169.31,190.78 145.22,190.78 139.96,185.52 131.89,185.52 121.13,174.77 121.13,167.56 120.75,167.18 120.75,161.58 122.38,159.95 122.38,137.29 121.21,136.12 121.21,130.66 120.02,129.46 120.02,119.43 118.16,117.58 118.16,109.39 114.66,105.88 114.66,101.8 105.92,93.07 105.92,91.41 98.55,84.04 98.55,78.23 95.1,74.78 95.1,72.88 94.64,72.43 94.39,72.43 v1(93.98,72.02)
DDI1_HDMI_HPD: length 257.8
  TOP w0.114: v1(192.23,174.47) 193.68,175.92 R26.2 ; DISPC1.24 86.65,70.75 v3(86.66,70.76) 86.68,70.75 88.23,70.75 v1(88.27,70.71) ; CPU1.D10 v6(186.5,173.5)
  L3 w0.114: v6(186.5,173.5) 186.98,173.02 189.69,173.02 189.79,173.13 191.64,173.13 191.87,173.36 191.87,174.12 v1(192.23,174.47) 194.49,174.47 197.94,177.93 197.94,191.76 197.94,192.11 190.67,199.38 156.55,199.38 156.53,199.36 129.61,199.36 128.27,198.02 128.27,196.34 127.54,195.61 127.54,193.55 113.7,179.71 113.7,168.26 112.76,167.33 112.76,156.38 110.65,154.26 110.65,152.77 112.1,151.32 112.1,143.96 111.53,143.39 111.53,138.46 106.55,133.48 106.55,123.06 107.21,122.41 107.21,110.83 102.13,105.75 98.27,105.75 91.54,99.03 91.54,96.11 90.24,94.81 90.24,82.8 88.27,80.82 v1(88.27,70.71)
DDR0_A_ALERT_N: length 50.3
  TOP w0.114: CPU1.N34 177.53,149.53 v6(177.54,149.53) ; DIMM1.116 186.62,107.71 187.85,108.94 v6(188.51,108.94)
  L3 w0.114: v6(188.51,108.94) 189.91,110.34 189.91,118.77 181.32,127.36 181.32,135.71 180.35,136.67 180.35,143.9 179.05,145.21 179.05,146.89 178.08,147.85 178.08,148.99 v6(177.54,149.53)
DDR0_A_PARITY: length 50.6
  TOP w0.178: v6(178.13,109.91) 179.87,111.65 DIMM1.143 ; v6(169.5,149.5) CPU1.Y33
  L3 w0.191: v6(169.5,149.5) 169.5,148.09 169.09,147.68 169.09,147.23 169.32,147 169.32,146.34 169.95,145.7 169.95,124.97 178.66,116.26 178.66,110.44 v6(178.13,109.91)
DDR1_B_ALERT_N: length 70.4
  TOP w0.114: v6(186.95,93.34) 186.62,93.02 DIMM2.116 ; v6(177.44,145.54) 177.44,145.56 CPU1.N37
  L6 w0.102: v6(186.95,93.34) 187.67,93.34 188.74,92.27 190.99,92.27 193.6,94.88 193.6,108.9 194.09,109.39 194.09,117.03 187.22,123.9 187.22,127.8 185.29,129.74 185.29,134.42 182.83,136.88 182.83,142.1 179.4,145.54 v6(177.44,145.54)
  BOTTOM w0.114: v2(186.64,92.58) 186.95,92.89 v6(186.95,93.34)
DDR1_B_PARITY: length 53.9
  TOP w0.102: CPU1.AB38 168.4,144.6 168.4,143.76 168.44,143.71 168.44,143 168.07,142.63 v6(168.07,142.61)
  TOP w0.178: v6(179.63,98.13) 179.87,98.38 DIMM2.143
  L6 w0.165: v6(168.07,142.61) 168.78,141.9 168.78,137.07 172.36,133.49 172.36,123.44 179.1,116.71 179.1,103.94 179.65,103.39 179.65,98.16 v6(179.63,98.13)
DEVSLP: length 5.3
  TOP w0.114: R437.1 104.93,90.32 v3(105.28,90.68) 106.5,91.89 SSDC1.38
DEVSLP_N: length 10.3
  TOP w0.114: Q34.S 106.5,90.87 105.79,90.17 105.79,89.33 105.24,88.79 R437.2 104.64,88.79 104.13,89.29 PR219.2 103.84,88.13 PR220.1 104.46,87.5 v3(105.28,87.5) 105.36,87.58 R436.1
DEVSLP_N_GATE: length 3.6
  TOP w0.114: Q34.G 108.55,87.54 v3(108.58,87.5) 109.07,87.5 109.22,87.66 C507.1 R438.1
DIMM_CA_VREF_A: length 10
  TOP w0.305: v6(174.75,104.9) 173.03,104.9 172.63,105.31 DIMM1.164
  BOTTOM w0.508: R107.2 178.94,105.22 R108.2 C164.1 C165.1 175.77,105.28 175.01,106.05 v2(174.75,106.05) 174.57,105.87 174.57,105.08 v6(174.75,104.9)
DIMM_CA_VREF_B: length 9.5
  TOP w0.305: DIMM2.164 172.63,90.45 172.98,90.1 172.98,89.67
  TOP w0.508: v3(177.1,86.17) 176.59,86.68 R117.2 C188.1 C187.1 R118.2 172.97,89.66 172.98,89.67
DMI_RX_CPU_N0: length 175.4
  TOP w0.102: C196.2 146.18,55.25 145.44,55.98 145.44,56.08 145.44,56.15 145.43,56.19 v1(145.77,56.57) ; CPU1.AD8 v6(165.5,175.5)
  L3 w0.102: v6(165.5,175.5) 165.91,175.91 165.91,180.67 164.53,182.04 162.74,182.04 161.67,183.1 161.67,184.44 161.33,184.78 154.97,184.78 154.08,183.9 151,183.9 145.41,178.31 145.41,177.19 141.35,173.13 136.19,173.13 129.97,166.9 129.97,134.7 128.35,133.07 128.35,116.93 127.43,116.02 127.43,110.52 126.44,109.52 126.44,100.31 129.08,97.67 129.08,94.13 129.3,93.92 129.44,93.92 129.65,93.7 129.65,93.56 129.87,93.35 130.01,93.35 130.23,93.13 130.23,92.99 130.44,92.77 130.58,92.77 130.8,92.56 130.8,92.42 132.94,90.27 132.94,88.05 133.04,87.96 133.04,87.65 132.94,87.55 132.94,87.25 133.04,87.15 133.04,86.84 132.94,86.74 132.94,86.44 133.04,86.34 133.04,86.04 132.94,85.94 132.94,85.63 135.75,82.82 135.89,82.82 136.11,82.61 136.11,82.47 136.32,82.25 136.46,82.25 136.68,82.04 136.68,81.9 136.89,81.68 137.03,81.68 137.25,81.47 137.25,81.33 138.18,80.4 138.18,80.09 138.28,80 138.28,79.69 138.18,79.59 138.18,79.29 138.28,79.19 138.28,78.88 138.18,78.78 138.18,78.48 138.28,78.38 138.28,78.08 138.18,77.98 138.18,75.34 138.39,75.12 138.53,75.12 138.75,74.91 138.75,74.77 138.96,74.55 139.1,74.55 139.32,74.33 139.32,74.19 139.53,73.98 139.67,73.98 139.89,73.76 139.89,73.62 141.55,71.96 141.55,68.54 145.44,64.65 145.44,64.35 145.51,64.27 145.51,63.97 145.44,63.89 145.44,56.9 v1(145.77,56.57)
