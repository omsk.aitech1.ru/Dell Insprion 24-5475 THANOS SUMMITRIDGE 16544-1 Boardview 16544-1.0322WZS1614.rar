# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TX_PCH_P1: length 13.3
  TOP w0.102: v6(169.8,45) PCH1.N24
  BOTTOM w0.102: v6(169.8,45) 170.1,44.7 170.1,44.4 170.43,44.07 171.65,44.07 ; 171.65,44.07 v2(171.65,43.71) ; 171.65,44.07 172.25,44.07 172.47,44.29 172.47,45.82 172.6,45.95 172.83,45.95 172.96,45.82 172.96,44.29 173.18,44.07 175.13,44.07 175.26,43.94 175.26,42.77 175.13,42.65 174.03,42.65 C205.1
PCIE_TX_SSDX4_N4: length 13.1
  TOP w0.102: C1150.2 124.24,91.32 124.24,91.82 124.12,91.95 122.12,91.95 121.87,92.2 121.87,92.77 122.12,93.01 124.82,93.01 124.89,93.09 124.89,93.52 124.82,93.6 122.06,93.6 121.81,93.85 121.81,94.13 ; v3(121.41,94.13) 121.81,94.13 ; 121.81,94.13 121.81,94.85 121.66,94.99 U26.16
PCIE_TX_SSDX4_N4_R: length 78.4
  TOP w0.102: 172.59,50.52 172.59,50.19 171.93,49.53 171.13,49.53 PCH1.H26 ; 172.59,50.52 172.59,50.78 172.42,50.96 v6(172.42,51.56) ; 172.59,50.52 v3(173,50.52) ; v1(124.05,85.19) 124.41,84.84 124.68,84.84 124.79,84.95 124.79,88.93 124.26,89.46 124.26,89.68 C1150.1
  L4 w0.102: v6(172.42,51.56) 172.1,51.56 172.1,51.58 171.91,51.77 171.91,53.96 172.01,54.06 172.01,54.37 171.91,54.46 171.91,55.04 172.01,55.14 172.01,55.44 171.91,55.54 171.91,55.85 172.01,55.95 172.01,56.25 171.91,56.35 171.91,57.36 172.01,57.46 172.01,57.76 171.91,57.86 171.91,58.17 172.01,58.26 172.01,58.57 171.91,58.67 171.91,59.83 164.3,67.44 140.98,67.44 125.43,82.99 125.43,84.26 124.85,84.84 124.41,84.84 v1(124.05,85.19)
PCIE_TX_SSDX4_N5: length 109.2
  TOP w0.102: v6(169.8,49) PCH1.J24 ; v3(111.3,106.98) 111.58,106.71 ; 111.58,106.71 111.88,107.01 118.87,107.01 126.52,99.36 126.52,90.07 127.08,89.51 127.08,87.83 126.52,87.27 126.52,84.24 126.71,84.05 127.04,84.05 v1(127.37,84.39) ; 111.58,106.71 110.99,106.12 110.71,106.12 C503.1
  L4 w0.102: v1(127.37,84.39) 127.73,84.03 127.93,84.03 128.32,83.64 128.32,81.26 141.33,68.25 164.64,68.25 173.81,59.08 173.81,51.46 171.93,49.58 169.6,49.58 169.49,49.47 169.49,49.31 v6(169.8,49)
PCIE_TX_SSDX4_N5_C: length 13.8
  TOP w0.102: v3(106.53,105.99) 106.53,105.61 ; 106.53,105.61 107.42,105.61 107.65,105.38 107.65,104.7 107.77,104.57 108.41,104.57 108.53,104.7 108.53,105.98 108.75,106.2 109.13,106.2 C503.2 ; 106.53,105.61 105.43,105.61 105.18,105.37 105.18,104.34 105.43,104.09 106.6,104.09 106.73,103.96 106.73,103.59 106.6,103.46 106.12,103.46 105.9,103.24 105.9,101.53 105.75,101.38 SSDC1.35
PCIE_TX_SSDX4_N6: length 117.1
  TOP w0.102: 173,47.57 171.23,47.57 PCH1.K26 ; 173,47.57 173.28,47.57 173.61,47.24 173.61,46.99 v6(173.99,46.61) ; 173,47.57 v3(173,47.98) ; C501.1 113.55,108.89 114,108.89 114.35,108.53 119.34,108.53 127.94,99.93 127.94,90.93 128.96,89.92 128.96,84.26 131.95,81.26 131.95,79.98 133.58,78.36 134.56,78.36 134.95,78.75 v1(134.95,79.17)
  L4 w0.102: v6(173.99,46.61) 173.63,46.97 173.63,47.17 173.86,47.4 176.28,47.4 177.88,49 177.88,61.65 168.35,71.17 166.61,71.17 164.78,73 142.7,73 136.47,79.22 135,79.22 v1(134.95,79.17)
PCIE_TX_SSDX4_N6_C: length 16.1
  TOP w0.102: SSDC1.23 102.75,101.43 102.9,101.58 102.9,104.52 ; 102.9,104.52 v3(102.51,104.52) ; 102.9,104.52 102.9,105.29 106.11,108.51 109.85,108.51 110.28,108.94 112,108.94 C501.2
PCIE_TX_SSDX4_N7: length 121.5
  TOP w0.102: v6(170.6,46.6) PCH1.L25 ; v1(133.73,83.37) 133.74,83.36 133.74,82.97 133.48,82.7 132.56,82.7 130.33,84.94 130.33,91.06 129.31,92.08 129.31,99.76 129.31,100.59 119.85,110.06 114.84,110.06 114.16,110.74 110,110.74 109.59,110.34 109.12,110.34 ; 109.12,110.34 107.92,110.34 107.91,110.34 C495.1 ; 109.12,110.34 v3(109.12,110.72)
  L4 w0.102: v6(170.6,46.6) 170.9,46.9 170.9,47.2 171.15,47.45 172.46,47.45 173.42,48.41 174.52,48.41 176.28,50.16 176.28,61.79 168.11,69.95 166.36,69.95 164.33,71.98 140.82,71.98 133.32,79.48 133.32,82.48 133.73,82.89 133.73,83.37 v1(133.73,83.37)
PCIE_TX_SSDX4_N7_C: length 13.4
  TOP w0.102: C495.2 106.34,110.41 106.02,110.41 105.33,109.73 ; 105.33,109.73 99.9,104.29 99.9,101.52 99.75,101.38 SSDC1.11 ; 105.33,109.73 v3(105.05,110.01)
PCIE_TX_SSDX4_P4: length 13.1
  TOP w0.102: 124.84,92.81 122.2,92.81 122.07,92.68 122.07,92.28 122.2,92.15 124.2,92.15 124.45,91.91 124.45,91.27 C1149.2 ; 124.84,92.81 v3(124.84,92.43) ; 124.84,92.81 124.9,92.81 125.09,93.01 125.09,93.61 124.9,93.8 122.15,93.8 122.01,93.94 122.01,94.85 122.16,94.99 U26.17
PCIE_TX_SSDX4_P4_R: length 78.4
  TOP w0.102: v6(171.91,51.03) 172.06,51.03 172.39,50.7 172.39,50.27 171.85,49.73 170.53,49.73 PCH1.H25 ; v1(124.05,84.28) 124.41,84.63 124.76,84.63 124.99,84.86 124.99,88.65 ; v3(125.37,88.65) 124.99,88.65 ; 124.99,88.65 124.99,89.01 124.46,89.54 124.46,89.75 C1149.1
  L4 w0.102: v6(171.91,51.03) 171.89,51.04 171.89,51.5 171.7,51.69 171.7,59.75 164.22,67.23 140.89,67.23 125.22,82.91 125.22,84.18 124.76,84.63 124.41,84.63 v1(124.05,84.28)
PCIE_TX_SSDX4_P5: length 109.4
  TOP w0.102: v1(127.37,83.47) 127,83.85 126.63,83.85 126.31,84.16 126.31,87.36 126.87,87.92 126.87,89.43 126.31,89.98 126.31,99.28 124.61,100.99 ; C504.1 110.63,105.92 111.07,105.92 111.96,106.81 118.79,106.81 124.61,100.99 ; v6(169,49) PCH1.H24 ; 124.61,100.99 v3(124.33,100.71)
  L4 w0.102: v1(127.37,83.47) 127.73,83.83 127.85,83.83 128.12,83.56 128.12,81.18 141.25,68.05 164.56,68.05 173.61,59 173.61,58.69 173.51,58.59 173.51,58.29 173.61,58.19 173.61,57.88 173.51,57.78 173.51,57.48 173.61,57.38 173.61,57.08 173.51,56.98 173.51,56.67 173.61,56.57 173.61,55.45 173.51,55.35 173.51,55.04 173.61,54.94 173.61,54.64 173.51,54.54 173.51,54.23 173.61,54.13 173.61,53.83 173.51,53.73 173.51,53.43 173.61,53.33 173.61,53.02 173.51,52.92 173.51,52.62 173.61,52.52 173.61,51.54 171.85,49.78 169.52,49.78 169.29,49.56 169.29,49.29 v6(169,49)
PCIE_TX_SSDX4_P5_C: length 13.1
  TOP w0.102: C504.2 109.05,105.99 108.84,105.99 108.74,105.89 108.74,104.61 108.49,104.37 107.69,104.37 107.44,104.61 107.44,105.3 107.33,105.41 105.51,105.41 105.38,105.28 105.38,104.42 105.51,104.29 106.69,104.29 106.93,104.05 106.93,103.5 106.69,103.26 106.2,103.26 106.1,103.16 106.1,101.54 106.25,101.4 SSDC1.37
PCIE_TX_SSDX4_P6: length 117.3
  TOP w0.102: v6(173.06,46.61) 173.41,46.95 173.41,47.16 173.19,47.37 170.63,47.37 PCH1.K25 ; 132.18,79.47 133.49,78.16 134.65,78.16 134.95,78.46 v1(135.56,78.46) ; 132.18,79.47 131.75,79.9 131.75,81.18 128.75,84.18 128.75,89.83 127.74,90.85 127.74,99.85 119.25,108.33 114.27,108.33 113.91,108.69 113.53,108.69 C502.1 ; 132.18,79.47 v3(131.9,79.2)
  L4 w0.102: v1(135.56,78.46) 135.56,78.94 135.64,79.02 136.39,79.02 142.61,72.8 164.69,72.8 166.52,70.97 168.27,70.97 177.67,61.56 177.67,49.08 176.19,47.6 173.77,47.6 173.42,47.25 173.42,46.97 v6(173.06,46.61)
PCIE_TX_SSDX4_P6_C: length 15.8
  TOP w0.102: SSDC1.25 103.25,101.42 103.1,101.57 103.1,105.21 106.2,108.31 109.93,108.31 110.36,108.74 110.97,108.74 ; 110.97,108.74 111.93,108.74 C502.2 ; 110.97,108.74 v3(110.97,108.36)
PCIE_TX_SSDX4_P7: length 121.8
  TOP w0.102: 133.07,82.5 133.56,82.5 133.78,82.72 v1(134.38,82.72) ; 133.07,82.5 v3(133.07,82.12) ; 133.07,82.5 132.48,82.5 130.12,84.85 130.12,90.97 129.11,91.99 129.11,99.85 129.11,100.51 119.76,109.86 114.76,109.86 114.07,110.54 110.08,110.54 109.68,110.13 107.84,110.13 C496.1 ; PCH1.L26 v6(171.4,46.6)
  L4 w0.102: v1(134.38,82.72) 133.85,82.72 133.53,82.4 133.53,79.56 140.9,72.19 164.41,72.19 166.45,70.15 168.2,70.15 176.48,61.87 176.48,61.57 176.58,61.47 176.58,61.17 176.48,61.07 176.48,60.76 176.58,60.66 176.58,60.36 176.48,60.26 176.48,59.95 176.58,59.86 176.58,59.55 176.48,59.45 176.48,50.08 174.61,48.21 173.51,48.21 172.54,47.24 171.23,47.24 171.1,47.12 171.1,46.9 v6(171.4,46.6)
PCIE_TX_SSDX4_P7_C: length 13.2
  TOP w0.102: SSDC1.13 100.25,101.38 100.1,101.52 100.1,104.21 100.49,104.59 ; 100.49,104.59 106.1,110.21 106.42,110.21 106.64,109.99 C496.2 ; 100.49,104.59 v3(100.76,104.32)
PCIE_WAKE#: length 235.9
  TOP w0.114: CPU1.AL5 v6(158.5,178.5) ; PCH1.V5 v6(154.6,41.8) ; RN6.3 139.83,147.25 140.08,147.5 140.08,148.46 140.46,148.84 v1(140.72,148.84)
  L4 w0.114: v6(154.6,41.8) 164.02,41.8 166.83,38.99 167.59,38.99 167.61,39.01 175.82,39.01 178.91,35.93 180.89,35.93 181.71,35.1 v1(181.74,35.1) ; v1(182.9,73.06) 179.74,76.21 178.24,76.21 173.08,81.38 161.09,81.38 158.93,83.54 156.44,83.54 154.23,85.75 149.63,85.75 146.34,89.05 142.71,89.05 141.58,90.18 141.58,95.35 143.45,97.22 143.45,114.68 143.85,115.08 143.85,126.25 143.15,126.95 143.15,142.7 139.83,146.02 139.83,147.96 v1(140.72,148.84) 142.29,150.42 142.29,154.33 142.47,154.51 142.47,158.72 146.15,162.41 146.15,165.25 146.3,165.4 146.3,168.68 146.63,169.01 147.36,169.01 147.63,169.28 147.63,170.59 149.51,172.47 150.4,172.47 150.88,172.94 150.88,174.22 152.95,176.29 152.95,176.53 153.38,176.96 154.74,176.96 155.45,177.67 157.67,177.67 v6(158.5,178.5)
  L6 w0.102: v1(181.74,35.1) 182.81,36.17 182.81,41.78 185.22,44.19 185.22,70.74 v1(182.9,73.06)
  BOTTOM w0.114: R162.2 147.46,37.01 v2(148.39,37.94) 149.84,39.4 154.68,39.4 155.23,39.94 155.23,40.68 155.02,40.89 155.02,41.35 154.6,41.77 v6(154.6,41.8)
PDB: length 34.2
  TOP w0.114: PR1.2 215.91,36.79 PD1.A PD2.A 216.21,34.7 218.57,32.33 v1(218.57,29.87) ; v1(216.15,29.62) 216.15,29.18 215.62,28.65 215.62,28.24 215.44,28.06 U7.15 ; U8.15 198.36,29.63 198.45,29.72 198.81,29.72 198.88,29.64 200.3,29.64 200.53,29.87 202.21,29.87 v1(202.36,29.72)
  L4 w0.114: v1(202.36,29.72) 202.44,29.64 205.77,29.64 206.71,28.7 215.23,28.7 v1(216.15,29.62)
  BOTTOM w0.114: v1(216.15,29.62) 216.15,28.98 v2(216.56,28.57) 216.91,28.57 218.21,29.87 v1(218.57,29.87)
PEDET_B: length 3.3
  TOP w0.114: R442.1 113.79,104.76 v3(114.34,105.31) 115.45,105.31 115.61,105.15 Q35.B
PEG_C_RXN0: length 56.9
  TOP w0.102: GPU1.AN43 88.35,169.45 88.35,169.35 88.45,169.25 90.09,169.25 91.41,167.92 95.32,167.92 95.48,168.08 95.48,168.2 v1(95.07,168.61) ; 121.92,190.99 v3(121.92,190.6) ; 121.92,190.99 121.48,190.99 119.85,189.36 117.45,189.36 110.95,182.85 103.72,182.85 97.59,176.72 97.59,172.36 97.43,172.21 97.43,169.02 98.02,168.43 98.48,168.43 98.7,168.2 98.7,167.77 v1(99.09,167.39) ; 121.92,190.99 123.01,190.99 C533.2
  L3 w0.102: v1(95.07,168.61) 95.07,168.42 96.79,166.7 98.4,166.7 v1(99.09,167.39)
PEG_C_RXN1: length 59.4
  TOP w0.102: 99.14,169.34 98.12,170.36 98.12,171.11 98.22,171.21 98.22,171.52 98.12,171.62 98.12,171.92 98.27,172.07 98.27,176.33 104.06,182.12 111.2,182.12 116.94,187.86 117.67,187.86 C537.2 ; 99.14,169.34 v3(99.42,169.62) ; 99.14,169.34 99.39,169.09 99.39,168.4 99.69,168.1 102.51,168.1 102.82,167.79 102.82,166.93 v1(103.17,166.57) ; v1(93.19,168.61) 92.76,169.04 92.76,169.24 92.46,169.54 90.71,169.54 89.75,170.5 87,170.5 86.9,170.6 GPU1.AM41
  L3 w0.102: v1(103.17,166.57) 102.74,167 102.74,167.22 102.47,167.49 101.5,167.49 101.29,167.28 100.75,167.28 99.56,166.09 94.59,166.09 92.86,167.82 92.86,168.27 v1(93.19,168.61)
PEG_C_RXN2: length 51.5
  TOP w0.102: C540.2 123.03,188.8 122.54,188.8 120.51,186.77 117.1,186.77 111.68,181.36 105.23,181.36 ; v3(105.23,180.97) 105.23,181.36 ; 105.23,181.36 104.58,181.36 98.98,175.76 98.98,172.64 98.98,172.21 99.92,171.27 99.92,171.22 100.46,170.69 v1(100.46,170.66) ; v1(94.92,170.64) 95.17,170.38 95.17,170.03 95,169.85 94.61,169.85 94.31,170.15 90.88,170.15 89.44,171.59 88.39,171.59 GPU1.AM42
  L3 w0.102: v1(100.46,170.66) 99.57,169.77 98.85,169.77 98.7,169.93 97.68,169.93 97.68,169.93 95.63,169.93 v1(94.92,170.64)
PEG_C_RXN3: length 48.1
  TOP w0.102: v1(101.75,168.61) 101.4,168.96 101.4,169.65 ; C544.2 117.68,185.56 117.01,185.56 111.63,180.19 104.66,180.19 99.67,175.2 99.67,172.52 99.95,172.24 100.74,172.24 101.14,171.83 101.14,170.48 101.4,170.23 101.4,169.65 ; 101.4,169.65 v3(101.8,169.65) ; GPU1.AK42 88.2,171.8 88.87,171.8 89.07,172 89.71,172 90.41,171.3 92.35,171.3 92.51,171.14 92.51,170.97 v1(92.18,170.64)
  L3 w0.102: v1(92.18,170.64) 92.18,170.63 93.72,169.09 98.12,169.09 99.25,167.95 99.31,167.89 101.04,167.89 v1(101.75,168.61)
PEG_C_RXN4: length 47.1
  TOP w0.102: v1(101,173.29) 100.7,173.59 100.7,173.9 101.02,174.21 101.02,175.56 104.94,179.48 111.97,179.48 112.35,179.86 112.49,179.86 112.71,180.07 112.71,180.21 112.92,180.43 113.06,180.43 113.28,180.64 113.28,180.78 113.49,181 113.63,181 113.85,181.21 113.85,181.35 116.95,184.46 119.44,184.46 119.77,184.79 120.68,184.79 122.37,186.49 123.08,186.49 C524.2 ; 94.59,171.35 95.14,171.35 95.48,171.69 95.48,172.26 v1(95.07,172.67) ; 94.59,171.35 93.58,171.35 92.77,172.16 90.63,172.16 89.94,172.85 88.45,172.85 88.35,172.95 88.35,173.05 GPU1.AJ43 ; 94.59,171.35 v3(94.59,171.73)
  L3 w0.102: v1(95.07,172.67) 95.78,171.96 100.41,171.96 100.86,172.41 100.86,173.15 v1(101,173.29)
PEG_C_RXN5: length 45.2
  TOP w0.102: C526.2 117.67,183.42 117.03,183.42 112.4,178.79 105.24,178.79 103.56,177.11 ; GPU1.AG41 86.9,174.2 87,174.1 89.69,174.1 90.31,173.48 92.61,173.48 92.89,173.2 92.89,172.97 v1(93.19,172.67) ; v3(103.84,176.83) 103.56,177.11 ; 103.56,177.11 101.7,175.25 101.7,173.63 102.49,172.85 102.49,172.16 103.08,171.57 103.08,171.07 v1(103.46,170.69)
  L3 w0.102: v1(93.19,172.67) 92.85,172.27 92.86,172.17 92.86,171.88 93.4,171.35 100.66,171.35 100.88,171.57 102.26,171.57 102.6,171.23 102.92,171.23 v1(103.46,170.69)
PEG_C_RXN6: length 44.1
  TOP w0.102: 106.5,178.08 105.98,178.08 104.67,176.78 104.67,175.59 104.17,175.08 103.64,175.08 103.35,174.8 v1(102.31,174.8) ; 106.5,178.08 v3(106.5,177.7) ; 106.5,178.08 112.69,178.08 116.97,182.36 120.39,182.36 122.37,184.35 123.06,184.35 C550.2 ; GPU1.AG42 88.21,175.01 89.92,175.01 90.74,174.19 94.55,174.19 94.78,173.96 95.29,173.96 95.48,174.15 95.48,174.29 v1(95.07,174.7)
  L3 w0.102: v1(95.07,174.7) 95.78,173.99 98.32,173.99 99.87,175.54 101.97,175.54 102.31,175.2 v1(102.31,174.8)
PEG_C_RXN7: length 38.4
  TOP w0.102: 107.01,176.86 108.75,176.86 109.28,177.4 112.98,177.4 116.78,181.2 117.73,181.2 C529.2 ; 107.01,176.86 v3(107.01,176.45) ; 107.01,176.86 105.93,176.86 105.36,176.29 105.36,174.85 104.6,174.09 104.24,174.09 104.21,174.06 103.1,174.06 v1(103.09,174.06) ; GPU1.AF42 88.28,176.28 88.85,176.28 88.87,176.26 89.66,176.26 90.4,175.51 92.38,175.51 v1(93.19,174.7)
  L3 w0.102: v1(103.09,174.06) 103.09,173.63 102.84,173.38 102.01,173.38 100.89,174.5 99.69,174.5 98.57,173.38 93.4,173.38 92.86,173.91 92.86,174.2 92.85,174.3 v1(93.19,174.7)
PEG_C_RXN8: length 43.9
  TOP w0.102: v1(106.35,174.24) 106.35,174.4 106.63,174.68 107.06,174.68 108.56,176.17 110.5,176.17 111.04,176.71 111.46,176.71 ; 111.46,176.71 113.29,176.71 116.72,180.14 120.21,180.14 122.24,182.17 123.16,182.17 123.46,181.88 C555.2 ; 111.46,176.71 v3(111.46,176.33) ; v1(95.07,176.73) 95.43,176.38 95.43,176.11 95.24,175.92 94.52,175.92 94.27,176.17 90.91,176.17 90.16,176.93 88.77,176.93 GPU1.AE43
  L3 w0.102: v1(106.35,174.24) 105.97,174.62 105.77,174.62 105.16,175.23 105.16,176.52 103.85,177.83 103.55,177.83 103.45,177.73 103.14,177.73 103.04,177.83 102.74,177.83 102.64,177.73 102.34,177.73 102.24,177.83 101.93,177.83 101.83,177.73 101.53,177.73 101.43,177.83 99.86,177.83 98.05,176.02 95.99,176.02 95.5,176.51 95.3,176.51 v1(95.07,176.73)
PEG_C_RXN9: length 41.6
  TOP w0.102: 117.07,178.93 117.75,178.93 C559.2 ; 117.07,178.93 v3(117.07,178.54) ; 117.07,178.93 116.59,178.93 112.76,175.11 108.49,175.11 106.79,173.41 105,173.41 104.8,173.2 104.8,172.62 v1(104.8,172.62) ; v1(93.19,176.73) 92.72,177.2 92.15,177.2 91.65,177.7 87,177.7 86.9,177.8 GPU1.AD41
  L3 w0.102: v1(104.8,172.62) 104.55,172.87 104.55,176.27 103.78,177.04 99.93,177.04 98.3,175.41 93.28,175.41 92.85,175.84 92.85,176.34 92.86,176.34 v1(93.19,176.73)
PEG_C_RXN10: length 45.3
  TOP w0.102: v3(110.72,174.04) 110.72,174.42 ; 110.72,174.42 113.45,174.42 116.49,177.47 117.58,177.47 117.84,177.73 120.5,177.73 122.58,179.81 123.1,179.81 C563.2 ; 110.72,174.42 110.24,174.42 109.05,173.24 108.56,173.24 108.56,173.23 107.83,173.23 v1(107.65,173.05) ; v1(95.07,178.77) 94.56,178.26 90.66,178.26 90.51,178.4 89.23,178.4 89.03,178.6 88.28,178.6 87.88,178.2 GPU1.AD42
  L3 w0.102: v1(107.65,173.05) 107.65,173.49 107.8,173.64 107.8,173.95 107.82,173.97 107.82,176.21 104.45,179.58 99.29,179.58 97.76,178.05 95.78,178.05 v1(95.07,178.77)
PEG_C_RXN11: length 45.7
  TOP w0.102: v1(92.33,178.77) 92.33,179.13 92.16,179.3 89.17,179.3 88.87,179 88.49,179 88.3,179.18 88.02,179.18 GPU1.AC42 ; 115.82,175.42 114.1,173.71 111.65,173.71 111.15,173.21 110.12,173.21 108,171.09 108,170.27 107.53,169.8 105.91,169.8 105.64,170.07 105.64,170.34 v1(105.29,170.69) ; 115.82,175.42 v3(116.1,175.13) ; 115.82,175.42 116.95,176.56 117.74,176.56 C567.2
  L3 w0.102: v1(105.29,170.69) 105.69,171.09 105.69,171.78 106.2,172.29 106.2,172.86 106.84,173.5 106.84,176.04 104.11,178.77 99.63,178.77 98.1,177.24 93.31,177.24 92.66,177.89 92.66,178.44 v1(92.33,178.77)
PEG_C_RXN12: length 48.1
  TOP w0.102: C571.2 122.97,177.18 122.49,177.18 120.77,175.46 117.54,175.46 115.11,173.02 113.84,173.02 ; 113.84,173.02 v3(113.84,172.64) ; 113.84,173.02 111.93,173.02 110.41,171.5 109.97,171.5 109.96,171.49 109.33,171.49 v1(109.14,171.3) ; v1(95.07,180.8) 95.07,180.59 94.53,180.05 88.45,180.05 88.35,180.15 88.35,180.25 GPU1.AA43
  L3 w0.102: v1(95.07,180.8) 95.78,180.09 97.49,180.09 98.6,181.2 105.35,181.2 109.96,176.59 109.96,173.46 109.14,172.64 v1(109.14,171.3)
PEG_C_RXN13: length 51.3
  TOP w0.102: C575.2 117.78,174.26 117.33,174.26 116.67,173.6 ; v3(116.94,173.33) 116.67,173.6 ; 116.67,173.6 114.8,171.73 111.69,171.73 110.42,170.46 109.5,170.46 108.16,169.11 106.55,169.11 106.44,169 106.44,168.78 v1(106.64,168.58) ; GPU1.Y41 87.34,181.36 91.1,181.36 91.18,181.43 92.56,181.43 v1(93.19,180.8)
  L3 w0.102: v1(106.64,168.58) 106.64,168.6 106.28,168.95 106.28,169.16 106.43,169.32 107.52,169.32 107.98,169.77 107.98,170.86 108.53,171.41 108.53,172.92 109.35,173.74 109.35,176.34 105.09,180.59 98.86,180.59 97.74,179.48 93.42,179.48 92.86,180.04 92.86,180.41 v1(93.19,180.8)
PEG_C_RXN14: length 51.2
  TOP w0.102: 121.63,173.39 122.45,174.22 122.45,174.7 122.56,174.8 122.97,174.8 C579.2 ; 121.63,173.39 v3(121.92,173.1) ; 121.63,173.39 121.36,173.13 117.89,173.13 117.25,172.49 116.61,172.49 113.89,169.77 111.8,169.77 111.69,169.89 110.65,169.89 v1(110.59,169.95) ; GPU1.Y42 88.15,182.15 88.15,182.33 88.37,182.55 89.59,182.55 89.9,182.25 94.82,182.25 95.07,182.5 v1(95.07,182.83)
  L3 w0.102: v1(95.07,182.83) 95.07,182.8 95.76,182.12 97.19,182.12 97.9,182.83 106.02,182.83 111.61,177.24 111.61,171.91 110.68,170.98 110.68,170.04 v1(110.59,169.95)
PEG_C_RXN15: length 48.4
  TOP w0.102: GPU1.W43 88.91,183.21 89.33,183.21 89.74,183.62 92.27,183.62 92.53,183.35 92.53,183.03 v1(92.33,182.83) ; v1(108.51,168.58) 108.89,168.2 108.89,168.05 109.09,167.84 112.93,167.84 114.01,168.92 ; v3(114.3,168.63) 114.01,168.92 ; 114.01,168.92 115.18,170.09 115.32,170.09 115.53,170.31 115.53,170.45 115.75,170.66 115.89,170.66 116.1,170.88 116.1,171.02 116.32,171.23 116.46,171.23 116.68,171.45 116.68,171.59 116.89,171.81 117.86,171.81 118.22,171.44 C583.2
  L3 w0.102: v1(108.51,168.58) 108.83,168.9 108.81,168.92 108.81,170.29 110.79,172.27 110.79,176.9 105.68,182.02 98.23,182.02 97.52,181.31 93.49,181.31 92.66,182.14 92.66,182.5 v1(92.33,182.83)
PEG_C_RXP0: length 56.5
  TOP w0.102: 97.23,169.6 97.23,172.29 97.38,172.44 97.38,176.81 97.68,177.11 97.68,177.25 97.9,177.46 98.04,177.46 98.25,177.68 98.25,177.82 98.47,178.03 98.61,178.03 98.82,178.25 98.82,178.39 99.04,178.6 99.18,178.6 102.77,182.2 102.77,182.34 102.99,182.55 103.13,182.55 103.63,183.06 110.86,183.06 117.37,189.56 119.76,189.56 121.39,191.19 123.01,191.19 C531.2 ; 97.23,169.6 97.23,168.93 97.94,168.22 98.39,168.22 98.5,168.11 98.5,167.72 v1(98.17,167.39) ; 97.23,169.6 v3(96.85,169.6) ; GPU1.AN42 88.15,169.45 88.15,169.27 88.37,169.05 90,169.05 91.33,167.72 95.4,167.72 95.68,168 95.68,168.28 v1(95.99,168.58)
  L3 w0.102: v1(98.17,167.39) 97.69,166.9 96.88,166.9 95.99,167.79 v1(95.99,168.58)
PEG_C_RXP1: length 59.1
  TOP w0.102: 101.83,167.89 99.61,167.89 99.19,168.32 99.19,169 97.92,170.27 97.92,172.01 98.07,172.16 98.07,176.41 103.98,182.32 111.12,182.32 116.86,188.06 117.69,188.06 C535.2 ; 101.83,167.89 102.43,167.89 102.62,167.71 102.62,166.93 v1(102.26,166.57) ; 101.83,167.89 v3(101.83,167.51) ; GPU1.AN41 86.9,170.2 87,170.3 89.67,170.3 90.63,169.34 92.37,169.34 92.56,169.16 92.56,168.83 v1(92.33,168.61)
  L3 w0.102: v1(102.26,166.57) 102.54,166.85 102.54,167.13 102.39,167.28 101.58,167.28 101.38,167.08 100.84,167.08 99.64,165.89 94.51,165.89 92.66,167.73 92.66,168.28 v1(92.33,168.61)
PEG_C_RXP2: length 50.6
  TOP w0.102: 93.65,169.95 94.23,169.95 94.53,169.65 95.08,169.65 95.38,169.94 95.38,170.15 v1(95.83,170.61) ; 93.65,169.95 90.8,169.95 89.36,171.39 89.09,171.39 GPU1.AM43 ; 93.65,169.95 v3(93.65,169.54) ; v1(99.54,170.63) 99.72,170.81 99.72,171.18 98.78,172.12 98.78,172.15 98.78,175.85 99,176.06 99,176.2 99.21,176.42 99.35,176.42 99.57,176.63 99.57,176.77 99.78,176.99 99.92,176.99 100.14,177.2 100.14,177.34 100.35,177.56 100.49,177.56 102.78,179.85 102.78,179.99 103,180.2 103.14,180.2 103.35,180.42 103.35,180.56 103.57,180.77 103.71,180.77 103.92,180.99 103.92,181.13 104.14,181.34 104.28,181.34 104.49,181.56 111.6,181.56 111.82,181.77 111.82,181.91 112.03,182.13 112.17,182.13 112.39,182.35 112.39,182.49 112.6,182.7 112.74,182.7 112.96,182.92 112.96,183.06 113.17,183.27 113.31,183.27 115.3,185.26 115.3,185.4 115.52,185.62 115.66,185.62 115.87,185.83 115.87,185.97 116.09,186.19 116.23,186.19 116.44,186.4 116.44,186.54 116.66,186.76 116.8,186.76 117.01,186.97 120.43,186.97 120.64,187.19 120.64,187.33 120.86,187.55 121,187.55 122.46,189.01 123.03,189.01 C521.2
  L3 w0.102: v1(95.83,170.61) 96.32,170.13 97.64,170.13 98.78,170.13 98.93,169.98 99.48,169.98 99.69,170.19 99.69,170.48 v1(99.54,170.63)
PEG_C_RXP3: length 47.4
  TOP w0.102: GPU1.AK43 89.79,172.2 90.49,171.5 92.43,171.5 92.71,171.22 92.71,170.97 v1(93.04,170.64) ; 107.26,180.39 v3(107.26,180.77) ; 107.26,180.39 109.12,180.39 109.22,180.49 109.53,180.49 109.63,180.39 109.93,180.39 110.03,180.49 110.34,180.49 110.43,180.39 110.74,180.39 110.84,180.49 111.14,180.49 111.24,180.39 111.55,180.39 115.21,184.05 115.21,184.19 115.43,184.41 115.57,184.41 115.78,184.63 115.78,184.77 116,184.98 116.14,184.98 116.35,185.2 116.35,185.34 116.57,185.55 116.71,185.55 116.92,185.77 117.68,185.77 C542.2 ; 107.26,180.39 104.57,180.39 104.36,180.18 104.22,180.18 104,179.96 104,179.82 103.79,179.6 103.65,179.6 103.43,179.39 103.43,179.25 103.22,179.03 103.08,179.03 102.86,178.82 102.86,178.68 101.2,177.02 101.06,177.02 100.85,176.8 100.85,176.66 100.63,176.45 100.49,176.45 100.27,176.23 100.27,176.09 100.06,175.87 99.92,175.87 99.7,175.66 99.7,175.52 99.47,175.28 99.47,172.44 99.87,172.03 100.65,172.03 100.94,171.75 100.94,170.4 101.19,170.15 101.19,168.96 v1(100.84,168.61)
  L3 w0.102: v1(93.04,170.64) 93.04,170.05 93.8,169.29 94.11,169.29 94.21,169.39 94.51,169.39 94.61,169.29 94.91,169.29 95.01,169.39 95.32,169.39 95.42,169.29 98.2,169.29 98.49,169.01 98.63,169.01 98.84,168.79 98.84,168.65 99.4,168.1 100.74,168.1 100.84,168.2 v1(100.84,168.61)
PEG_C_RXP4: length 46.7
  TOP w0.102: 100.81,175.08 100.81,175.64 104.85,179.68 111.89,179.68 116.87,184.66 119.35,184.66 119.69,185 120.59,185 122.29,186.69 123.08,186.69 C522.2 ; 100.81,175.08 100.81,174.29 v1(100.15,173.63) ; 100.81,175.08 v3(100.43,175.08) ; v1(95.99,172.64) 95.68,172.34 95.68,171.6 95.22,171.15 93.5,171.15 92.68,171.96 90.54,171.96 89.86,172.65 88.37,172.65 88.15,172.87 88.15,173.05 GPU1.AJ42
  L3 w0.102: v1(95.99,172.64) 95.99,172.47 96.29,172.16 100.32,172.16 100.65,172.49 100.65,172.91 100.15,173.41 v1(100.15,173.63)
PEG_C_RXP5: length 44.7
  TOP w0.102: GPU1.AJ41 86.9,173.8 87,173.9 89.6,173.9 90.22,173.28 92.52,173.28 92.68,173.12 92.68,173.02 v1(92.33,172.67) ; 102.42,171.94 102.88,171.48 102.88,171.02 v1(102.55,170.69) ; 102.42,171.94 102.29,172.08 102.29,172.76 101.5,173.55 101.5,175.34 105.15,178.99 112.32,178.99 116.95,183.62 117.67,183.62 C525.2 ; 102.42,171.94 v3(102.13,171.65)
  L3 w0.102: v1(92.33,172.67) 92.33,172.53 92.65,172.25 92.66,172.17 92.66,172.16 92.66,171.8 93.31,171.15 100.74,171.15 100.97,171.37 102.17,171.37 102.4,171.15 102.4,170.84 v1(102.55,170.69)
PEG_C_RXP6: length 42.7
  TOP w0.102: 93.68,173.99 90.65,173.99 89.84,174.8 88.9,174.8 GPU1.AG43 ; 93.68,173.99 v3(93.68,173.58) ; 93.68,173.99 94.46,173.99 94.69,173.76 95.38,173.76 95.68,174.07 95.68,174.37 v1(95.99,174.68) ; v1(102.95,175.45) 102.95,175.22 103.16,175 103.27,175 103.55,175.29 104.08,175.29 104.47,175.67 104.47,176.86 105.9,178.29 112.61,178.29 116.89,182.57 120.3,182.57 122.28,184.55 123.06,184.55 C527.2
  L3 w0.102: v1(102.95,175.45) 102.35,175.45 102.06,175.74 101.4,175.74 101.3,175.84 101,175.84 100.9,175.74 100.59,175.74 100.49,175.84 100.19,175.84 100.09,175.74 99.78,175.74 98.24,174.19 96.06,174.19 95.99,174.27 v1(95.99,174.68)
PEG_C_RXP7: length 37.7
  TOP w0.102: v1(103.84,174.6) 104.07,174.36 104.58,174.36 105.16,174.94 105.16,176.38 105.84,177.06 107.98,177.06 ; 107.98,177.06 108.66,177.06 109.2,177.6 112.9,177.6 116.7,181.4 117.73,181.4 C551.2 ; 107.98,177.06 v3(107.98,177.47) ; v1(92.33,174.7) 92.52,174.89 92.52,175.09 92.3,175.31 90.31,175.31 89.57,176.05 88.95,176.05 GPU1.AF43
  L3 w0.102: v1(92.33,174.7) 92.33,174.56 92.65,174.29 92.66,174.2 92.66,174.19 92.66,173.83 93.31,173.18 98.66,173.18 99.77,174.29 100.81,174.29 101.93,173.18 102.93,173.18 103.61,173.85 103.61,174.37 v1(103.84,174.6)
PEG_C_RXP8: length 43.9
  TOP w0.102: C530.2 123.1,182.38 122.15,182.38 120.12,180.34 116.63,180.34 113.2,176.92 110.95,176.92 110.41,176.38 109.73,176.38 ; 109.73,176.38 108.48,176.38 106.98,174.88 106.63,174.88 v1(106.35,175.16) ; 109.73,176.38 v3(109.73,176.76) ; GPU1.AE42 88.2,176.6 88.87,176.6 89,176.73 90.07,176.73 90.83,175.97 94.18,175.97 94.44,175.72 95.33,175.72 95.63,176.02 95.63,176.35 v1(95.99,176.71)
  L3 w0.102: v1(106.35,175.16) 106.02,174.83 105.85,174.83 105.36,175.32 105.36,176.61 103.94,178.03 99.77,178.03 97.97,176.23 96.29,176.23 95.99,176.53 v1(95.99,176.71)
PEG_C_RXP9: length 41.4
  TOP w0.102: C557.2 117.75,179.14 116.5,179.14 113.04,175.68 ; v3(112.75,175.97) 113.04,175.68 ; 113.04,175.68 112.67,175.31 108.41,175.31 106.71,173.61 104.92,173.61 103.96,172.65 v1(103.89,172.65) ; GPU1.AE41 86.9,177.4 87,177.5 91.56,177.5 v1(92.33,176.73)
  L3 w0.102: v1(92.33,176.73) 92.65,176.46 92.65,175.75 93.19,175.21 98.39,175.21 100.01,176.83 103.69,176.83 104.34,176.18 104.34,173.11 v1(103.89,172.65)
PEG_C_RXP10: length 43.7
  TOP w0.102: C561.2 123.1,180.01 122.5,180.01 120.42,177.93 117.75,177.93 117.49,177.67 116.41,177.67 116.21,177.47 116.2,177.47 115.64,176.91 115.5,176.91 115.29,176.69 115.29,176.55 115.07,176.34 114.93,176.34 114.72,176.12 114.72,175.98 114.5,175.77 114.36,175.77 114.15,175.55 114.15,175.41 113.93,175.2 113.79,175.2 113.58,174.98 113.58,174.84 113.36,174.62 110.15,174.62 108.97,173.44 108.56,173.44 v1(108.28,173.72) ; v3(94.59,177.65) 94.59,178.05 ; 94.59,178.05 95.3,178.05 v1(95.99,178.74) ; 94.59,178.05 90.58,178.05 90.43,178.2 GPU1.AD43
  L3 w0.102: v1(95.99,178.74) 95.99,178.56 96.29,178.26 97.68,178.26 99.2,179.78 104.54,179.78 108.03,176.29 108.03,173.97 v1(108.28,173.72)
PEG_C_RXP11: length 45
  TOP w0.102: 108.33,171.71 110.04,173.42 111.07,173.42 111.56,173.91 114.02,173.91 116.87,176.76 117.89,176.76 118.12,177 C565.2 ; 108.33,171.71 107.8,171.17 107.8,170.36 107.44,170 105.99,170 105.84,170.15 105.84,170.32 v1(106.21,170.69) ; 108.33,171.71 v3(108.05,171.98) ; GPU1.AC43 88.98,179.4 89.08,179.5 92.24,179.5 92.38,179.36 92.6,179.36 v1(93.19,178.77)
  L3 w0.102: v1(93.19,178.77) 92.86,178.43 92.86,177.98 93.4,177.44 98.02,177.44 99.54,178.97 104.2,178.97 107.04,176.13 107.04,173.41 106.4,172.77 106.4,172.21 105.89,171.7 105.89,171 v1(106.21,170.69)
PEG_C_RXP12: length 47.9
  TOP w0.102: 115.43,173.63 117.46,175.66 120.69,175.66 122.41,177.38 123.01,177.38 C569.2 ; 115.43,173.63 v3(115.14,173.91) ; 115.43,173.63 115.03,173.23 111.85,173.23 110.32,171.7 110.03,171.7 v1(109.76,171.97) ; v1(95.99,180.77) 95.53,180.31 95.08,180.31 94.61,179.84 88.37,179.84 88.15,180.07 88.15,180.25 GPU1.AA42
  L3 w0.102: v1(109.76,171.97) 109.51,171.97 109.34,172.14 109.34,172.56 110.16,173.37 110.16,176.68 105.43,181.41 98.52,181.41 97.4,180.29 96.16,180.29 95.99,180.47 v1(95.99,180.77)
PEG_C_RXP13: length 50.9
  TOP w0.102: 112.32,171.93 114.71,171.93 117.24,174.46 117.78,174.46 C573.2 ; 112.32,171.93 111.61,171.93 110.34,170.66 109.42,170.66 108.07,169.32 106.46,169.32 106.12,168.98 106.12,168.98 v1(105.72,168.58) ; 112.32,171.93 v3(112.32,172.34) ; v1(92.33,180.8) 91.9,181.23 91.26,181.23 91.18,181.15 87.45,181.15 GPU1.AA41
  L3 w0.102: v1(105.72,168.58) 106.08,168.94 106.08,169.25 106.35,169.52 107.43,169.52 107.77,169.86 107.77,170.94 108.33,171.5 108.33,173 109.14,173.82 109.14,176.26 105.01,180.39 98.94,180.39 97.82,179.27 93.34,179.27 92.66,179.95 92.66,180.36 92.65,180.38 92.33,180.66 v1(92.33,180.8)
PEG_C_RXP14: length 50.2
  TOP w0.102: C577.2 122.98,175.01 122.47,175.01 122.25,174.79 122.25,174.3 121.28,173.33 117.81,173.33 117.17,172.69 116.52,172.69 113.8,169.98 113.26,169.98 ; v3(113.26,170.36) 113.26,169.98 ; 113.26,169.98 111.89,169.98 v1(111.33,170.54) ; GPU1.Y43 88.35,182.15 88.35,182.25 88.45,182.35 89.5,182.35 89.81,182.04 95.22,182.04 v1(95.99,182.8)
  L3 w0.102: v1(95.99,182.8) 95.99,182.58 96.24,182.32 97.1,182.32 97.81,183.03 106.1,183.03 111.81,177.33 111.81,171.82 110.88,170.9 110.88,170.63 110.98,170.54 v1(111.33,170.54)
PEG_C_RXP15: length 49.2
  TOP w0.102: v1(93.19,182.83) 93.19,182.98 92.35,183.82 89.65,183.82 89.25,183.41 88.21,183.41 GPU1.W42 ; v1(109.42,168.59) 109.09,168.26 109.09,168.13 109.18,168.05 111.43,168.05 ; 111.43,168.05 112.84,168.05 116.81,172.01 117.83,172.01 118.22,172.39 C581.2 ; 111.43,168.05 v3(111.43,168.45)
  L3 w0.102: v1(93.19,182.83) 92.86,182.5 92.86,182.22 93.57,181.51 97.44,181.51 98.15,182.22 105.77,182.22 111,176.99 111,172.19 109.02,170.21 109.02,169 v1(109.42,168.59)
PEG_C_TXN0: length 38.3
  TOP w0.102: GPU1.AR39 v6(85.55,168)
  BOTTOM w0.102: 112.18,167.89 111.7,167.41 100.84,167.41 100.3,166.88 96.6,166.88 96.1,167.37 90.91,167.37 89.59,168.68 87.07,168.68 85.84,167.45 85.3,167.45 85.2,167.55 85.2,167.65 v6(85.55,168) ; 112.18,167.89 116.3,172.01 117.84,172.01 C534.1 ; 112.18,167.89 v2(111.94,168.12)
PEG_C_TXN1: length 45
  TOP w0.102: GPU1.AN37 v6(83.85,169.2)
  BOTTOM w0.102: 103.73,168.1 91.12,168.1 90,169.21 86.76,169.21 86.24,168.7 83.95,168.7 83.85,168.8 v6(83.85,169.2) ; 103.73,168.1 v2(103.73,168.45) ; 103.73,168.1 110.72,168.1 112.86,170.24 113.56,170.24 116.47,173.15 119.86,173.15 122.05,175.34 123.12,175.34 C538.1
PEG_C_TXN2: length 37.4
  TOP w0.102: GPU1.AN38 v6(84.65,169.2)
  BOTTOM w0.102: C541.1 117.78,174.46 116.04,174.46 113.04,171.46 ; v2(112.8,171.7) 113.04,171.46 ; 113.04,171.46 110.88,169.3 90.74,169.3 90.32,169.72 86.69,169.72 86.41,169.44 85.88,169.44 85.72,169.61 85.55,169.61 85.54,169.62 85.39,169.62 85.15,169.37 84.82,169.37 v6(84.65,169.2)
PEG_C_TXN3: length 43.9
  TOP w0.102: GPU1.AM38 v6(84.65,170.4)
  BOTTOM w0.102: v6(84.65,170.4) 85.07,170.81 85.8,170.81 86.18,170.43 90.58,170.43 91.16,169.85 92.17,169.85 92.37,170.05 108.79,170.05 114.27,175.54 115.34,175.54 ; 115.34,175.54 120.13,175.54 122.28,177.69 123.14,177.69 C545.1 ; 115.34,175.54 v2(115.34,175.9)
PEG_C_TXN4: length 36.4
  TOP w0.102: GPU1.AK39 v6(85.55,171.6)
  BOTTOM w0.102: v6(85.55,171.6) 85.85,171.6 86.28,171.17 90.12,171.17 90.42,171.48 92.28,171.48 92.38,171.37 107.98,171.37 113.36,176.76 114.22,176.76 ; 114.22,176.76 117.74,176.76 C546.1 ; 114.22,176.76 v2(114.22,177.11)
PEG_C_TXN5: length 45.1
  TOP w0.102: GPU1.AJ37 v6(83.85,172.8)
  BOTTOM w0.089: 87.63,172.62 87.6,172.62 87.6,172.62 86.94,172.62 86.52,172.19 84.5,172.19 84.4,172.3 83.94,172.3 83.85,172.38 v6(83.85,172.8)
  BOTTOM w0.102: v2(110.03,174.88) 110.27,174.64 ; 110.27,174.64 107.69,172.06 90.03,172.06 89.47,172.62 87.63,172.62 ; 110.27,174.64 113.53,177.9 119.94,177.9 122.05,180.01 123.1,180.01 C548.1
PEG_C_TXN6: length 38.1
  TOP w0.102: GPU1.AJ38 v6(84.65,172.8)
  BOTTOM w0.102: 100.2,174.32 101.07,174.32 101.98,173.41 106.52,173.41 112.25,179.14 117.75,179.14 C528.1 ; 100.2,174.32 99.34,174.32 98.42,173.41 86.36,173.41 86.18,173.23 85.08,173.23 v6(84.65,172.8) ; 100.2,174.32 v2(100.2,174.65)
PEG_C_TXN7: length 44.7
  TOP w0.102: GPU1.AG38 v6(84.65,174)
  BOTTOM w0.102: v2(104.83,176.05) 104.83,176.4 ; 104.83,176.4 108.43,176.4 108.76,176.73 108.9,176.73 109.11,176.94 109.11,177.08 109.33,177.3 109.47,177.3 109.68,177.51 109.68,177.65 109.9,177.87 110.04,177.87 110.25,178.08 110.25,178.22 112.09,180.06 112.39,180.06 112.49,179.96 112.8,179.96 112.9,180.06 113.2,180.06 113.3,179.96 113.61,179.96 113.71,180.06 114.01,180.06 114.11,179.96 114.41,179.96 114.51,180.06 115.63,180.06 115.72,179.96 116.03,179.96 116.13,180.06 116.43,180.06 116.53,179.96 116.84,179.96 116.94,180.06 120.23,180.06 120.63,180.46 120.77,180.46 120.98,180.68 120.98,180.82 121.2,181.03 121.34,181.03 121.55,181.25 121.55,181.39 121.77,181.6 121.91,181.6 122.12,181.82 122.12,181.96 122.34,182.17 123.1,182.17 C553.1 ; 104.83,176.4 100.74,176.4 98.32,173.99 86.59,173.99 86.16,173.56 85.09,173.56 v6(84.65,174)
PEG_C_TXN8: length 36.7
  TOP w0.102: GPU1.AF39 v6(85.55,175.2)
  BOTTOM w0.102: C556.1 117.74,181.39 111.82,181.39 107.71,177.29 100.27,177.29 99.78,176.8 ; v2(99.54,177.04) 99.78,176.8 ; 99.78,176.8 98.39,175.41 88.69,175.41 88.03,174.75 86.32,174.75 86,175.08 85.68,175.08 v6(85.55,175.2)
PEG_C_TXN9: length 45.5
  TOP w0.102: v6(83.87,176.37) 83.87,176.39 83.81,176.45 GPU1.AE37
  BOTTOM w0.089: 86.92,176.32 86.9,176.32 86.89,176.32 86.83,176.32 86.72,176.2 86.72,176.19 86.46,175.93 85.94,175.93 85.8,175.79 85.29,175.79 85.29,175.8 85.15,175.8 85.04,175.91 83.96,175.91 83.87,175.99 v6(83.87,176.37)
  BOTTOM w0.102: 117.09,182.5 116.33,182.5 116.23,182.6 115.93,182.6 115.83,182.5 115.52,182.5 115.42,182.6 115.12,182.6 115.02,182.5 114.72,182.5 114.62,182.6 114.31,182.6 114.21,182.5 111.85,182.5 107.33,177.98 99.31,177.98 97.43,176.1 88.32,176.1 88.1,176.32 86.92,176.32 ; 117.09,182.5 v2(117.09,182.83) ; 117.09,182.5 120.21,182.5 120.43,182.71 120.43,182.85 120.64,183.07 120.78,183.07 121,183.29 121,183.43 121.21,183.64 121.35,183.64 122.26,184.55 123.09,184.55 C560.1
PEG_C_TXN10: length 38.4
  TOP w0.102: GPU1.AE38 v6(84.65,176.4)
  BOTTOM w0.102: 112.7,183.42 v2(112.7,183.08) ; 112.7,183.42 112,183.42 107.09,178.51 99.16,178.51 97.92,177.27 91.08,177.27 90.63,176.81 90.32,176.81 90.22,176.71 89.92,176.71 89.82,176.81 89.51,176.81 89.42,176.71 89.11,176.71 89.01,176.81 88.71,176.81 88.61,176.71 88.3,176.71 88.2,176.81 86.75,176.81 86.2,176.26 85.98,176.26 85.72,175.99 85.38,175.99 85.15,176.23 84.82,176.23 v6(84.65,176.4) ; 112.7,183.42 113.3,183.42 113.4,183.32 113.7,183.32 113.8,183.42 114.1,183.42 114.2,183.32 114.51,183.32 114.61,183.42 114.91,183.42 115.01,183.32 115.32,183.32 115.42,183.42 117.69,183.42 C564.1
PEG_C_TXN11: length 44.9
  TOP w0.102: GPU1.AD38 v6(84.65,177.6)
  BOTTOM w0.102: v6(84.65,177.6) 85,177.25 85,177.07 85.22,176.84 85.86,176.84 86.44,177.42 88.21,177.42 88.77,177.98 89.08,177.98 89.18,177.88 89.48,177.88 89.58,177.98 89.89,177.98 89.98,177.88 90.29,177.88 90.39,177.98 97.66,177.98 98.88,179.2 106.78,179.2 111.73,184.15 113.18,184.15 113.56,184.53 114.15,184.53 ; 114.15,184.53 v2(114.15,184.18) ; 114.15,184.53 114.82,184.53 114.92,184.43 115.22,184.43 115.32,184.53 120.06,184.53 120.88,185.35 121.02,185.35 121.23,185.56 121.23,185.7 121.45,185.92 121.59,185.92 121.81,186.14 121.81,186.28 122.02,186.49 123.08,186.49 C568.1
PEG_C_TXN12: length 38.2
  TOP w0.102: v6(85.55,178.8) 85.55,178.95 GPU1.AC39
  BOTTOM w0.102: C572.1 117.7,185.77 117.07,185.77 116.97,185.87 116.67,185.87 116.57,185.77 116.26,185.77 116.17,185.87 115.86,185.87 115.76,185.77 115.46,185.77 115.36,185.87 115.05,185.87 114.95,185.77 113.21,185.77 ; 113.21,185.77 112.71,185.77 112.61,185.87 112.31,185.87 112.21,185.77 111.9,185.77 106.38,180.24 98.54,180.24 97.83,179.53 91.03,179.53 90.58,179.07 88.49,179.07 87.66,178.25 85.3,178.25 85.2,178.35 85.2,178.45 v6(85.55,178.8) ; 113.21,185.77 v2(113.21,186.11)
PEG_C_TXN13: length 45.3
  TOP w0.102: GPU1.AA37 83.85,180.15 v6(83.85,180)
  BOTTOM w0.089: v6(83.85,180) 83.85,179.58 83.94,179.5 85.2,179.5 85.3,179.4 86.97,179.4 87.33,179.76 88.26,179.76 88.27,179.76 88.29,179.76
  BOTTOM w0.102: C576.1 123.02,189.01 121.89,189.01 119.75,186.87 116.94,186.87 ; 116.94,186.87 111.93,186.87 105.99,180.92 98.09,180.92 97.4,180.24 90.81,180.24 90.33,179.76 88.29,179.76 ; 116.94,186.87 v2(116.94,187.2)
PEG_C_TXN14: length 38.9
  TOP w0.102: v6(84.65,180) 84.65,180.15 GPU1.AA38
  BOTTOM w0.102: v6(84.65,180) 85,180.35 85,180.53 85.22,180.75 86.39,180.75 86.5,180.64 89.74,180.64 90.73,181.63 105.29,181.63 108.22,184.56 108.22,184.56 ; 108.22,184.56 v2(107.98,184.81) ; 108.22,184.56 108.22,184.56 109.52,185.86 109.52,186.36 111.07,187.91 111.37,187.91 111.47,188.01 111.77,188.01 111.87,187.91 112.18,187.91 112.28,188.01 112.58,188.01 112.68,187.91 113.55,187.91 113.69,188.05 114.85,188.05 114.95,188.15 115.25,188.15 115.35,188.05 115.66,188.05 115.76,188.15 116.06,188.15 116.16,188.05 116.47,188.05 116.57,188.15 116.87,188.15 116.97,188.05 117.7,188.05 C580.1
PEG_C_TXN15: length 43.9
  TOP w0.102: GPU1.Y39 85.55,181.35 v6(85.55,181.2)
  BOTTOM w0.102: C584.1 123,190.99 121.58,190.99 121.48,190.89 121.18,190.89 121.08,190.99 120.77,190.99 118.89,189.11 114.02,189.11 113.92,189.01 113.62,189.01 113.52,189.11 113.21,189.11 113.12,189.01 112.81,189.01 112.71,189.11 112.41,189.11 112.31,189.01 112,189.01 111.9,189.11 111.51,189.11 108.67,186.27 ; 108.67,186.27 106.6,184.2 106.6,184.06 106.39,183.84 106.25,183.84 106.03,183.63 106.03,183.49 105.82,183.27 105.68,183.27 105.46,183.06 105.46,182.92 105.24,182.7 105.1,182.7 104.52,182.11 90.59,182.11 89.62,181.15 86.05,181.15 85.89,181.31 85.66,181.31 v6(85.55,181.2) ; 108.67,186.27 v2(108.92,186.03)
PEG_C_TXP0: length 39
  TOP w0.102: GPU1.AR38 v6(84.65,168)
  BOTTOM w0.102: 95.28,167.17 90.82,167.17 89.51,168.48 87.16,168.48 86.49,167.82 86.49,167.68 86.28,167.46 86.14,167.46 85.92,167.25 85.22,167.25 85,167.47 85,167.65 v6(84.65,168) ; 95.28,167.17 v2(95.28,166.83) ; 95.28,167.17 96.02,167.17 96.51,166.67 100.39,166.67 100.92,167.21 111.79,167.21 114.67,170.1 114.81,170.1 115.03,170.31 115.03,170.45 115.25,170.67 115.39,170.67 115.6,170.88 115.6,171.02 115.82,171.24 115.96,171.24 116.17,171.45 116.17,171.59 116.39,171.81 117.84,171.81 C532.1
PEG_C_TXP1: length 45
  TOP w0.102: GPU1.AR37 v6(83.85,168)
  BOTTOM w0.102: v6(83.85,168) 83.85,168.4 83.95,168.5 86.33,168.5 86.84,169.01 89.92,169.01 91.03,167.89 110.8,167.89 112.51,169.6 ; 112.51,169.6 v2(112.75,169.37) ; 112.51,169.6 112.95,170.04 113.64,170.04 116.56,172.95 119.94,172.95 122.13,175.14 123.13,175.14 C536.1
PEG_C_TXP2: length 36.6
  TOP w0.102: GPU1.AN39 v6(85.55,169.2)
  BOTTOM w0.102: v2(97.92,168.76) 97.92,169.1 ; 97.92,169.1 110.97,169.1 112.88,171.02 113.02,171.02 113.24,171.23 113.24,171.37 113.46,171.59 113.6,171.59 113.81,171.8 113.81,171.94 114.03,172.16 114.17,172.16 114.38,172.37 114.38,172.51 116.13,174.26 116.97,174.26 117.07,174.16 117.38,174.16 117.47,174.26 117.78,174.26 C539.1 ; 97.92,169.1 90.66,169.1 90.24,169.52 86.78,169.52 86.5,169.24 85.59,169.24 v6(85.55,169.2)
PEG_C_TXP3: length 43.2
  TOP w0.102: GPU1.AM39 v6(85.55,170.4)
  BOTTOM w0.102: C543.1 123.14,177.49 122.36,177.49 122.08,177.21 ; v2(122.35,176.96) 122.08,177.21 ; 122.08,177.21 120.21,175.34 117.76,175.34 117.66,175.24 117.36,175.24 117.26,175.34 116.96,175.34 116.86,175.24 116.55,175.24 116.45,175.34 116.15,175.34 116.05,175.24 115.74,175.24 115.65,175.34 114.36,175.34 110.99,171.97 110.99,171.83 110.78,171.61 110.64,171.61 110.42,171.4 110.42,171.26 110.2,171.04 110.06,171.04 109.85,170.83 109.85,170.69 109.63,170.47 109.49,170.47 108.87,169.85 92.46,169.85 92.26,169.65 91.08,169.65 90.49,170.23 86.08,170.23 85.91,170.4 v6(85.55,170.4)
PEG_C_TXP4: length 37.5
  TOP w0.102: GPU1.AK38 v6(84.65,171.6)
  BOTTOM w0.102: 111.24,174.35 112.31,175.42 112.45,175.42 112.66,175.63 112.66,175.77 112.88,175.99 113.02,175.99 113.23,176.2 113.23,176.34 113.45,176.56 117.74,176.56 C523.1 ; 111.24,174.35 v2(111.48,174.12) ; 111.24,174.35 108.06,171.17 92.3,171.17 92.2,171.27 90.51,171.27 90.2,170.97 86.2,170.97 85.97,171.19 85.38,171.19 85.15,171.43 84.82,171.43 v6(84.65,171.6)
PEG_C_TXP5: length 45.3
  TOP w0.102: GPU1.AK37 v6(83.85,171.6)
  BOTTOM w0.089: 87.63,172.42 87.6,172.42 87.6,172.43 87.02,172.43 86.6,172 84.42,172 84.37,172.06 84.32,172.1 83.94,172.1 83.85,172.02 v6(83.85,171.6)
  BOTTOM w0.102: 88.67,172.42 v2(88.67,172.09) ; 88.67,172.42 89.38,172.42 89.95,171.86 107.78,171.86 113.62,177.7 115.22,177.7 115.32,177.6 115.62,177.6 115.72,177.7 116.03,177.7 116.13,177.6 116.43,177.6 116.53,177.7 116.83,177.7 116.93,177.6 117.24,177.6 117.34,177.7 120.02,177.7 122.14,179.81 123.1,179.81 C547.1 ; 88.67,172.42 87.63,172.42
PEG_C_TXP6: length 37.8
  TOP w0.102: GPU1.AJ39 v6(85.55,172.8)
  BOTTOM w0.102: C549.1 117.75,178.94 117.45,178.94 117.35,178.84 117.04,178.84 116.95,178.94 116.64,178.94 116.54,178.84 116.24,178.84 116.14,178.94 115.83,178.94 115.73,178.84 115.43,178.84 115.33,178.94 112.33,178.94 110.48,177.08 110.48,176.94 110.26,176.72 110.12,176.72 109.91,176.51 109.91,176.37 109.69,176.15 109.55,176.15 109.34,175.94 109.34,175.8 109.12,175.58 108.98,175.58 107.17,173.77 107.17,173.63 106.96,173.42 106.82,173.42 106.6,173.2 101.9,173.2 100.99,174.12 99.42,174.12 98.51,173.2 98.2,173.2 98.1,173.1 97.8,173.1 97.7,173.2 90.4,173.2 ; v2(90.4,172.85) 90.4,173.2 ; 90.4,173.2 86.44,173.2 86.04,172.8 v6(85.55,172.8)
PEG_C_TXP7: length 42.6
  TOP w0.102: GPU1.AG39 v6(85.55,174)
  BOTTOM w0.102: 115.09,180.26 112.01,180.26 108.35,176.61 100.65,176.61 98.24,174.19 86.5,174.19 86.31,174 v6(85.55,174) ; 115.09,180.26 v2(115.09,180.59) ; 115.09,180.26 120.14,180.26 122.25,182.38 123.1,182.38 C552.1
PEG_C_TXP8: length 37.7
  TOP w0.102: GPU1.AF38 v6(84.7,175.2)
  BOTTOM w0.102: v2(112.32,180.85) 112.32,181.19 ; 112.32,181.19 111.9,181.19 107.8,177.09 100.36,177.09 98.48,175.21 88.77,175.21 88.11,174.55 86.24,174.55 86.09,174.7 85.99,174.79 85.11,174.79 v6(84.7,175.2) ; 112.32,181.19 117.74,181.19 C554.1
PEG_C_TXP9: length 45.1
  TOP w0.102: v6(83.87,175.25) 83.81,175.25 GPU1.AF37
  BOTTOM w0.089: v6(83.87,175.25) 83.87,175.63 83.96,175.71 84.97,175.71 85.07,175.61 85.21,175.61 85.21,175.6 85.88,175.6 86.02,175.74 86.54,175.74 86.92,176.12
  BOTTOM w0.102: v2(98.36,176.27) 98.12,176.5 ; 98.12,176.5 99.4,177.77 107.42,177.77 111.94,182.3 120.29,182.3 122.34,184.35 123.09,184.35 C558.1 ; 98.12,176.5 97.52,175.9 88.24,175.9 88.01,176.12 86.92,176.12
PEG_C_TXP10: length 36.7
  TOP w0.102: GPU1.AE39 v6(85.55,176.4)
  BOTTOM w0.102: 116.33,183.62 117.69,183.62 C562.1 ; 116.33,183.62 v2(116.33,183.97) ; 116.33,183.62 111.92,183.62 107.01,178.71 99.08,178.71 97.84,177.47 91,177.47 90.54,177.01 86.66,177.01 86.11,176.46 85.9,176.46 85.84,176.4 v6(85.55,176.4)
PEG_C_TXP11: length 44.1
  TOP w0.102: GPU1.AD39 v6(85.55,177.6)
  BOTTOM w0.102: v6(85.55,177.6) 85.2,177.25 85.2,177.15 85.3,177.05 85.78,177.05 86.35,177.62 88.13,177.62 88.69,178.18 97.58,178.18 98.8,179.4 106.7,179.4 111.65,184.35 113.1,184.35 113.48,184.73 119.97,184.73 121.93,186.69 122.45,186.69 ; C566.1 123.08,186.69 122.45,186.69 ; 122.45,186.69 v2(122.45,187.05)
PEG_C_TXP12: length 38.2
  TOP w0.102: v6(84.65,178.8) 84.65,178.95 GPU1.AC38
  BOTTOM w0.102: C570.1 117.7,185.56 111.99,185.56 111.66,185.24 ; 111.66,185.24 106.46,180.04 98.63,180.04 97.92,179.32 91.12,179.32 90.66,178.87 88.57,178.87 87.75,178.05 85.22,178.05 85,178.27 85,178.45 v6(84.65,178.8) ; 111.66,185.24 v2(111.91,184.99)
PEG_C_TXP13: length 45.3
  TOP w0.102: v6(83.85,178.8) 83.85,178.95 GPU1.AC37
  BOTTOM w0.089: 88.29,179.56 88.27,179.56 88.26,179.57 87.4,179.57 87.05,179.21 85.22,179.21 85.12,179.3 83.94,179.3 83.85,179.22 v6(83.85,178.8)
  BOTTOM w0.102: v2(122.43,188.44) 122.43,188.8 ; 122.43,188.8 123.02,188.8 C574.1 ; 122.43,188.8 121.98,188.8 119.84,186.66 112.01,186.66 106.07,180.72 98.17,180.72 97.49,180.04 90.89,180.04 90.41,179.56 88.29,179.56
PEG_C_TXP14: length 38.2
  TOP w0.102: GPU1.AA39 85.55,180.15 v6(85.55,180)
  BOTTOM w0.102: 114.3,187.85 113.77,187.85 113.63,187.71 111.15,187.71 109.72,186.28 109.72,185.77 105.38,181.43 90.81,181.43 89.82,180.44 86.41,180.44 86.3,180.55 85.3,180.55 85.2,180.45 85.2,180.35 v6(85.55,180) ; 114.3,187.85 v2(114.3,187.5) ; 114.3,187.85 117.71,187.85 C578.1
PEG_C_TXP15: length 44.4
  TOP w0.102: GPU1.Y38 84.65,181.35 v6(84.65,181.2)
  BOTTOM w0.102: 114.53,189.31 118.81,189.31 120.69,191.19 123,191.19 C582.1 ; 114.53,189.31 v2(114.53,189.66) ; 114.53,189.31 111.43,189.31 104.43,182.32 90.5,182.32 89.54,181.36 86.13,181.36 85.88,181.61 85.06,181.61 v6(84.65,181.2)
PEG_CLK0_WLAN_N: length 26.9
  TOP w0.102: R2645.2 178.47,36.88 178.93,36.88 v1(179.24,36.58) ; v1(180.34,54.46) 180.7,54.1 181.14,54.1 181.63,53.61 181.88,53.61 182.02,53.75 WLAN1.49
  L4 w0.102: v1(179.24,36.58) 179.6,36.93 180.09,36.93 180.36,37.2 180.36,43.51 183.01,46.16 183.01,53.64 182.62,54.03 180.77,54.03 v1(180.34,54.46)
  BOTTOM w0.102: v5(179.78,54.93) 180.25,54.46 v1(180.34,54.46)
PEG_CLK0_WLAN_N_R: length 7.8
  TOP w0.102: PCH1.AC25 170.21,37.39 170.54,37.39 170.94,36.98 172.92,36.98 173.05,36.86 173.33,36.86 ; 173.33,36.86 176.8,36.86 R2645.1 ; 173.33,36.86 v3(173.33,36.45)
PEG_CLK0_WLAN_P: length 27.4
  TOP w0.102: R2644.2 178.47,37.08 179.06,37.08 179.24,37.26 v1(179.24,37.49) ; v1(180.34,53.54) 180.7,53.9 181.05,53.9 181.54,53.41 181.87,53.41 182.03,53.25 WLAN1.47
  L4 w0.102: v1(179.24,37.49) 179.6,37.13 180,37.13 180.15,37.29 180.15,37.64 180.06,37.74 180.06,38.04 180.15,38.14 180.15,38.45 180.06,38.55 180.06,38.85 180.15,38.95 180.15,39.25 180.06,39.35 180.06,39.66 180.15,39.76 180.15,43.59 180.37,43.81 180.37,43.95 180.59,44.16 180.73,44.16 180.94,44.38 180.94,44.52 181.16,44.74 181.3,44.74 181.51,44.95 181.51,45.09 181.73,45.31 181.87,45.31 182.81,46.25 182.81,46.55 182.71,46.65 182.71,46.96 182.81,47.06 182.81,47.36 182.71,47.46 182.71,47.76 182.81,47.86 182.81,48.17 182.71,48.27 182.71,48.57 182.81,48.67 182.81,50.67 182.71,50.77 182.71,51.08 182.81,51.18 182.81,51.48 182.71,51.58 182.71,51.88 182.81,51.98 182.81,52.29 182.71,52.39 182.71,52.69 182.81,52.79 182.81,53.55 182.54,53.82 181.9,53.82 181.81,53.72 181.5,53.72 181.4,53.82 180.62,53.82 v1(180.34,53.54)
  BOTTOM w0.102: v1(179.24,37.49) 179.27,37.52 179.94,37.52 v5(179.95,37.53)
PEG_CLK0_WLAN_P_R: length 6.7
  TOP w0.102: R2644.1 176.75,37.06 176.44,37.06 176.34,37.16 176.04,37.16 175.94,37.06 173.13,37.06 173.01,37.19 172.83,37.19 172.73,37.28 172.43,37.28 172.33,37.19 172.02,37.19 171.92,37.28 171.62,37.28 171.52,37.19 171.21,37.19 PCH1.AC26
PEG_CLK1_LAN_N: length 108.2
  TOP w0.102: v3(113.89,10.95) 113.61,10.66 ; 113.61,10.66 112.96,11.3 110.41,11.3 108.4,9.3 108.4,7.89 108.25,7.75 TYPEC1.10 ; 113.61,10.66 116.07,8.19 116.07,6.81 116.13,6.76 116.13,6.71 117.34,5.5 117.34,2.43 v6(117.73,2.03) ; v1(178.84,40.72) 178.49,41.07 178.21,41.07 177.79,40.65 R2647.2
  L3 w0.102: v1(178.84,40.72) 178.87,40.72 179.15,41 179.64,41 179.77,40.87 179.77,39.27 179.49,38.99 177.13,38.99 170.64,32.49 170.64,32.34 169.26,30.96 167.99,30.96 162.41,25.38 162.41,16.85 155.96,10.4 155.96,7.19 150.7,1.93 119.41,1.93 119.23,1.75 118.01,1.75 v6(117.73,2.03)
PEG_CLK1_LAN_N_R: length 8.4
  TOP w0.102: 174.85,40.26 v3(175.13,39.98) ; 174.85,40.26 173.96,39.37 172.77,39.37 172.06,38.66 170.54,38.66 PCH1.AA25 ; 174.85,40.26 175.62,41.02 176.52,41.02 R2647.1
PEG_CLK1_LAN_P: length 109.2
  TOP w0.102: v6(116.84,2.03) 117.13,2.32 117.13,4.57 ; 117.13,4.57 117.13,5.42 115.92,6.62 115.92,6.67 115.87,6.73 115.87,8.11 113.46,10.52 112.88,11.1 110.49,11.1 108.6,9.21 108.6,7.89 108.75,7.75 TYPEC1.9 ; 117.13,4.57 v3(116.74,4.57) ; R2646.2 177.79,41.64 178.16,41.27 178.49,41.27 v1(178.84,41.63)
  L3 w0.102: v6(116.84,2.03) 117.32,1.55 119.31,1.55 119.49,1.73 150.78,1.73 156.16,7.1 156.16,10.31 162.61,16.76 162.61,25.3 168.07,30.76 169.34,30.76 170.84,32.26 170.84,32.41 177.22,38.79 179.57,38.79 179.97,39.19 179.97,40.95 179.72,41.2 179.25,41.2 178.84,41.61 v1(178.84,41.63)
PEG_CLK1_LAN_P_R: length 7.5
  TOP w0.102: v3(175.03,41.3) 175.32,41.01 ; 175.32,41.01 173.88,39.57 172.69,39.57 171.98,38.86 171.14,38.86 PCH1.AA26 ; 175.32,41.01 175.53,41.22 176.47,41.22 R2646.1
PEG_CLK4_M2SSD_N: length 128.9
  TOP w0.102: 176.07,38.13 177.52,38.13 178.21,38.81 179.21,38.81 179.9,38.13 180.62,38.13 v1(180.97,37.77) ; 176.07,38.13 v3(176.07,37.74) ; 176.07,38.13 175.4,38.13 R2649.2 ; SSDC1.53 110.25,100.04 110.39,99.9 110.39,99.44 110.85,98.98 115.28,98.98 115.47,98.8 115.47,98.33 v1(115.24,98.11)
  L4 w0.102: v1(180.97,37.77) 181.33,38.13 182.5,38.13 183.93,39.55 183.93,61.73 183.14,62.51 182.76,62.51 179.63,65.64 179.63,66.02 169.98,75.67 145.56,75.67 143,78.22 143,81.2 142.24,81.97 139.06,81.97 134.72,86.31 132.99,86.31 132.59,86.72 130.2,86.72 123.93,92.99 121.72,92.99 118.44,96.27 118.44,98 117,99.44 115.94,99.44 115.6,99.09 115.6,98.35 115.35,98.11 v1(115.24,98.11)
PEG_CLK4_M2SSD_N_R: length 4.3
  TOP w0.102: PCH1.AB25 170.56,37.84 172.24,37.84 172.5,38.1 173.72,38.1 R2649.1
PEG_CLK4_M2SSD_P: length 129.8
  TOP w0.102: v3(179.91,38.96) 179.63,38.68 ; 179.63,38.68 179.98,38.33 180.62,38.33 v1(180.97,38.68) ; 179.63,38.68 179.3,39.01 178.12,39.01 177.44,38.33 177.25,38.33 177.15,38.43 176.84,38.43 176.75,38.33 176.44,38.33 176.34,38.43 176.04,38.43 175.94,38.33 175.4,38.33 R2648.2 ; SSDC1.55 110.75,100.06 110.59,99.9 110.59,99.53 110.93,99.19 115.37,99.19 115.67,98.88 115.67,98.64 v1(116.16,98.15)
  L4 w0.102: v1(116.16,98.15) 116.07,98.15 115.8,98.42 115.8,99.01 116.03,99.24 116.92,99.24 118.24,97.92 118.24,96.19 121.64,92.79 123.84,92.79 130.12,86.51 132.5,86.51 132.91,86.11 134.64,86.11 138.98,81.76 142.16,81.76 142.8,81.12 142.8,78.14 143.76,77.18 143.76,77.04 143.97,76.82 144.11,76.82 144.33,76.61 144.33,76.47 144.54,76.25 144.68,76.25 144.9,76.03 144.9,75.89 145.12,75.68 145.26,75.68 145.47,75.46 169.9,75.46 170.12,75.25 170.12,75.11 170.33,74.89 170.47,74.89 170.69,74.68 170.69,74.54 170.9,74.32 171.04,74.32 171.26,74.11 171.26,73.97 171.47,73.75 171.61,73.75 175.21,70.16 175.21,70.02 175.42,69.8 175.56,69.8 175.78,69.59 175.78,69.45 175.99,69.23 176.13,69.23 176.35,69.02 176.35,68.88 176.56,68.66 176.7,68.66 179.43,65.94 179.43,65.56 182.68,62.31 183.06,62.31 183.72,61.64 183.72,61.34 183.62,61.24 183.62,60.93 183.72,60.83 183.72,60.53 183.62,60.43 183.62,60.12 183.72,60.03 183.72,59.72 183.62,59.62 183.62,59.32 183.72,59.22 183.72,56.46 183.62,56.36 183.62,56.05 183.72,55.95 183.72,55.65 183.62,55.55 183.62,55.25 183.72,55.15 183.72,54.84 183.62,54.74 183.62,54.44 183.72,54.34 183.72,45.45 183.62,45.35 183.62,45.04 183.72,44.94 183.72,44.64 183.62,44.54 183.62,44.23 183.72,44.14 183.72,43.83 183.62,43.73 183.62,43.43 183.72,43.33 183.72,42.06 183.62,41.96 183.62,41.66 183.72,41.56 183.72,41.25 183.62,41.15 183.62,40.85 183.72,40.75 183.72,40.44 183.62,40.35 183.62,40.04 183.72,39.94 183.72,39.64 182.41,38.33 181.33,38.33 v1(180.97,38.68)
