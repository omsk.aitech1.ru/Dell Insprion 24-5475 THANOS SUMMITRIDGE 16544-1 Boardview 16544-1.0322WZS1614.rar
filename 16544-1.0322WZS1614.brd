# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_PKG0: length 4.9
  TOP w0.114: PCH1.D9 v6(157,53)
  BOTTOM w0.114: R146.2 156.46,55.65 v5(156.31,55.5) 156.31,54.33 157,53.64 v6(157,53)
PM_PKG1: length 4.8
  TOP w0.114: PCH1.D8 v6(156.2,53)
  BOTTOM w0.114: R148.2 155.45,54.23 v2(155.83,53.85) 155.83,53.84 156.2,53.47 v6(156.2,53)
PM_PWGD: length 249.5
  TOP w0.114: PCH1.C25 170.37,53.4 170.73,53.76 171.82,53.76 172.26,53.31 173.23,53.31 173.6,52.94 174.07,52.94 C208.1 174.5,52.9 174.82,53.21 R163.2 R164.2 175.2,51.65 175.33,51.52 177.02,51.52 v1(177.06,51.56) ; PR94.1 222.4,216.87 223.43,215.84 224.8,215.84 v1(224.89,215.93) ; v1(214.2,68.68) 213.74,68.22 199.59,68.22 198.22,69.6 196.84,69.6 196.33,69.09 193.01,69.09 192.06,68.14 187.11,68.14 181.2,62.23 v1(181.2,61.82)
  L6 w0.102: v1(224.89,215.93) 225.45,215.37 225.45,212.09 219.1,205.74 218.16,205.74 217.17,204.75 215.85,204.75 212.98,201.88 209.91,201.88 208.08,200.05 208.08,199.01 206.88,197.82 206.88,195.76 205.99,194.87 205.99,191.9 207.16,190.73 207.16,187.45 205.97,186.26 205.97,179.5 206.81,178.66 206.81,168.63 208.16,167.28 208.19,167.28 209.42,166.04 216.39,166.04 224.06,158.37 v1(226.31,158.37)
  BOTTOM w0.114: v1(181.2,61.82) 179.93,61.82 v5(179.44,61.33) 177.9,59.79 177.9,52.4 v1(177.06,51.56) ; v1(214.2,68.68) 222.86,77.34 222.86,82.09 226.24,85.47 228.85,85.47 234.31,90.93 234.31,135.2 233.15,136.37 233.15,152.78 227.56,158.37 v1(226.31,158.37)
PM_PWRBTN_N: length 194.8
  TOP w0.114: RN6.4 139.28,149.06 139.95,149.73 v1(140.72,149.73) ; CPU1.AN5 v6(156.41,178.49) ; v1(113.56,63.63) 113.56,63.65 113.09,64.13 113.09,64.97 112.89,65.16 R2454.2
  L3 w0.114: v1(113.56,63.63) 113.56,62.82 117.2,59.18 122.03,59.18 v1(123.44,57.77)
  L4 w0.114: v1(159.41,82.37) 159.36,82.37 158.62,83.11 156.26,83.11 154.05,85.32 149.45,85.32 146.15,88.63 142.54,88.63 141.16,90 141.16,95.54 142.93,97.31 142.93,126.23 142.54,126.61 142.54,142.67 139.41,145.8 139.41,148.43 v1(140.72,149.73) 140.72,149.89 141.86,151.03 141.86,154.51 142.04,154.69 142.04,158.97 145.45,162.39 145.45,162.39 145.72,162.66 145.72,165.43 145.87,165.58 145.87,169.11 146.34,169.58 146.34,170.35 147.19,171.2 147.19,173.13 148.44,174.37 150.5,174.37 152.02,175.9 152.02,176.53 152.4,176.91 152.65,176.91 153.29,177.55 153.98,177.55 154.48,178.05 155.7,178.05 156.14,178.49 v6(156.41,178.49)
  BOTTOM w0.114: R2470.1 122.68,57.77 v1(123.44,57.77) 123.44,57.87 123.92,58.34 123.92,58.77 124.44,59.3 124.44,60.13 127.41,63.09 127.41,66.55 131.46,70.61 143.48,70.61 144.26,69.83 147.43,69.83 154.43,76.83 158.62,76.83 160.71,78.92 v5(160.71,81.08) v1(159.41,82.37)
PM_SPI_SCK: length 4.3
  TOP w0.114: PCH1.C5 v6(153.8,53.8)
  BOTTOM w0.114: R143.2 152.4,56.13 153.29,55.25 v5(153.29,55.16) 153.29,54.31 v6(153.8,53.8)
PM_SPI_SDI: length 8
  TOP w0.114: PCH1.B5 154.2,54.21 153.86,54.54 153.86,56.48 154.2,56.82 v3(154.2,57.51) 154.2,61.13 R141.2
PM_SPI_SDO: length 7.1
  TOP w0.114: PCH1.A4 153.54,55.14 v3(153.54,59.29) 153.54,60.64 R142.2
PM_TCK: length 1.5
  TOP w0.114: PCH1.B23 v6(168.2,54.6)
  BOTTOM w0.114: v6(168.2,54.6) 167.91,54.89 TP13.1
PM_TDI: length 1.5
  TOP w0.114: PCH1.C24 v6(169,53)
  BOTTOM w0.114: v6(169,53) 168.96,53.04 TP14.1
PM_TDO: length 1.4
  TOP w0.114: PCH1.A23 v6(168.2,55.4)
  BOTTOM w0.114: TP15.1 168.58,55.78 v6(168.2,55.4)
PM_TESTEN: length 4
  TOP w0.114: PCH1.AF26 171,34.77 v3(172.7,33.07) 173.77,33.07 R145.2
PM_TMS: length 2
  TOP w0.114: PCH1.D24 v6(169.8,53)
  BOTTOM w0.114: TP16.1 170.78,53.98 v6(169.8,53)
PM_UART_RX: length 1.5
  TOP w0.114: v6(156.21,51.38) 156.18,51.41 156.18,51.42 PCH1.E7
  BOTTOM w0.114: TP17.1 156.21,51.36 v6(156.21,51.38)
PM_UART_TX: length 6.3
  TOP w0.114: PCH1.D7 155.91,52.6 156.21,52.3 v6(156.21,52.22)
  BOTTOM w0.114: v6(156.21,52.22) 155.8,52.22 155.48,52.55 v2(155.48,52.58) 155.19,52.86 155.19,55.31 154.43,56.07 R140.2
PM_UREXT: length 3
  TOP w0.114: PCH1.AF10 v6(158.6,34.6)
  BOTTOM w0.114: 159.13,33.43 v5(159.13,33.4) ; 159.13,33.43 159.13,33.48 159.38,33.73 R169.2 ; 159.13,33.43 158.65,33.91 158.65,34.55 v6(158.6,34.6)
PM_XTAL_25M_IN: length 6.7
  TOP w0.114: X3.1 172.36,29.78 C209.1 R170.2 168.26,29.78 v3(168.22,29.74) 168.12,29.84 R2656.1
PM_XTAL_25M_IN_R: length 12.3
  TOP w0.114: PCH1.AE10 157.86,35.46 157.86,34.51 158.37,34.01 158.37,33.32 158.74,32.96 158.74,32.95 159.75,31.95 159.75,31.82 160.95,30.62 v3(161.04,30.62) 164.2,30.62 164.97,29.84 R2656.2
PM_XTAL_25M_OUT: length 5.2
  TOP w0.114: R2657.1 168.02,30.86 v3(168.28,31.11) 168.85,31.11 R170.1 170.05,30.67 C210.1 171.74,30.92 X3.3
PM_XTAL_25M_OUT_R: length 12.1
  TOP w0.114: R2657.2 165.63,30.86 165.2,31.29 v3(164.82,31.29) 164.8,31.27 161.22,31.27 160.39,32.09 160.39,32.21 159.38,33.22 159.38,35.89 159.08,36.2 158.6,36.2 PCH1.AD10
PMSCL: length 27.3
  TOP w0.114: PR245.2 114.27,140.41 TP105.1 114.2,140.34 114.2,139.93 114.2,139.93 v1(114.2,139.42) 114.15,139.37 PR225.2 ; PMBUS1.2 125.83,123.14 125.83,126.24 124.34,127.73 124.14,127.73 120.94,130.93 120.94,131.14 120.47,131.6 v1(120.47,131.85)
  L6 w0.102: v1(114.2,139.42) 114.2,139.47 114.68,139.95 115.6,139.95 116.33,139.22 116.33,138.35 119.53,135.15 119.53,132.79 v1(120.47,131.85)
PMSDA: length 23
  TOP w0.114: PMBUS1.3 125.42,124.72 125.42,126.17 124.2,127.39 124,127.39 v1(120.45,130.94) ; PR246.2 115.29,141.02 115.54,140.77 TP106.1 115.34,140.18 115.34,139.45 v1(115.37,139.42) 115.29,139.34 PR224.2
  L6 w0.102: v1(115.37,139.42) 115.37,137.97 118.3,135.04 118.3,133.09 v1(120.45,130.94)
PPON_0: length 4.6
  TOP w0.114: PCH1.AF6 155.1,34.9 155.1,34.01 155.83,33.27 155.83,32.86 156.11,32.58 156.11,31.11 TP18.1
PPON_1: length 4.4
  TOP w0.114: TP19.1 155.32,31.93 155.32,33.27 154.64,33.96 154.64,35.44 PCH1.AE6
PPON_2: length 3.7
  TOP w0.114: PCH1.AF7 155.79,34.99 155.79,34.41 156.51,33.68 156.51,33.14 157.18,32.48 TP20.1
PPON_3: length 6.7
  TOP w0.114: TP21.1 157.12,30.96 156.46,31.62 156.46,32.71 156.17,33 156.17,33.44 155.44,34.18 155.44,35.22 155.8,35.58 PCH1.AE7
PPON_4: length 1.7
  TOP w0.114: PCH1.AD7 v6(155.4,36.2)
  BOTTOM w0.114: v6(155.4,36.2) 155.19,35.99 TP22.1
PPON_5: length 3
  TOP w0.114: PCH1.AC7 v6(155.4,37)
  BOTTOM w0.114: TP23.1 153.9,35.5 v6(155.4,37)
PPON_6: length 3
  TOP w0.114: PCH1.AB7 v6(155.4,37.8)
  BOTTOM w0.114: TP24.1 154.14,37.4 155,37.4 v6(155.4,37.8)
PPON_7: length 1.4
  TOP w0.114: v6(155.4,38.56) 155.4,38.6 PCH1.AA7
  BOTTOM w0.114: TP25.1 155.4,39.2 v6(155.4,38.56)
PPON_8: length 2.3
  TOP w0.114: PCH1.AC9 v6(157.8,37)
  BOTTOM w0.114: TP26.1 158.94,37.34 158.9,37.38 158.18,37.38 v6(157.8,37)
PPON_9: length 2.1
  TOP w0.114: PCH1.AB9 v6(157.8,37.8)
  BOTTOM w0.114: v6(157.8,37.8) 157.05,38.55 TP27.1
PPON_10: length 1.5
  TOP w0.114: PCH1.AA9 157.4,39 157.68,39.28 v6(157.68,39.57)
  BOTTOM w0.114: v6(157.68,39.57) 157.48,39.78 TP28.1
PPON_11: length 3.9
  TOP w0.114: PCH1.AF9 157.4,33.23 158.78,31.85 TP29.1
PPON_12: length 6.5
  TOP w0.114: PCH1.AE9 157.04,35.44 157.04,33.1 158.31,31.83 158.31,31.64 159.3,30.66 TP30.1
PPON_13: length 4.9
  TOP w0.114: PCH1.AD9 v6(157.8,36.2)
  BOTTOM w0.114: v6(157.8,36.2) 157.8,36.16 157.84,36.08 157.84,32.66 TP31.1
PREXT: length 7.8
  TOP w0.114: PCH1.C9 157.41,53.4 157.76,53.75 157.76,54.38 157.99,54.61 158.37,54.61 158.62,54.86 158.62,55.4 160.71,57.48 v3(160.71,58.07) 161.54,58.9 R152.2
PROCHOT#_CPU_Q: length 54.3
  TOP w0.114: R1232.2 204.33,150.39 R2506.1 204.65,150.29 205.23,149.71 v3(206.94,149.71) 207.31,149.71 208.71,151.1 210.95,151.1 211.71,151.87 211.71,153.12 Q1.S 212.14,153.97 212.72,154.56 v1(212.72,154.81) ; CPU1.H15 182.1,168 v6(182.51,168.4)
  L3 w0.114: v1(212.72,154.81) 212.22,155.32 209.98,155.32 205.52,159.78 205.52,164.52 200.25,169.79 199.11,169.79 198.23,170.66 191.57,170.66 191.38,170.47 190.92,170.47 189.82,169.37 183.52,169.37 182.55,168.4 v6(182.51,168.4)
PSID_D: length 4.9
  TOP w0.114: Q21.D 91.43,64.34 R386.1 91.31,62.27 v3(91.31,61.34) 91.63,61.02 L24.2
PSID_D_1: length 10.6
  TOP w0.114: R386.2 92.32,61.23 92.71,60.83 93.54,60.83 R387.1 94.48,61.06 94.77,61.06 95.45,61.74 95.45,61.75 96,62.3 v3(96.21,62.3) 96.82,62.3 97.61,63.1 97.61,65.26 Q22.B
PSID_G: length 6.3
  TOP w0.114: Q22.C 96.98,63.79 Q21.G 93.76,62.99 94.02,62.74 R385.2 93.57,61.95 v3(93.09,61.47)
PSL_IN1#: length 11.4
  TOP w0.114: R2779.2 121.25,44.53 121.16,44.53 120.9,44.78 120.9,46.35 121.74,47.19 Q78.D 122.53,48.12 R239.1 121.59,48.64 120.42,49.81 119.84,49.81 v3(119.81,49.78) 119.71,49.89 119.38,49.89 119.12,50.14 KBC1.73
PSL_IN2#: length 5.4
  TOP w0.114: KBC1.93 116.96,58.14 116.84,58.27 116.84,59.33 117.58,60.07 v1(117.78,60.07)
  BOTTOM w0.114: R237.2 117.54,59.14 v2(117.66,59.27) 117.67,59.27 117.67,59.96 v1(117.78,60.07)
PSL_OUT#: length 33
  TOP w0.114: R193.1 101.14,70.99 v1(101.47,70.66) ; v1(114.83,51.38) 115.67,50.54 KBC1.74
  L4 w0.114: v1(114.83,51.38) 114.83,53.26 114.63,53.47 114.63,53.95 114.6,53.98 114.6,54.38 114.63,54.41 114.63,55.35 113.71,56.27 113.71,57.15 113.44,57.42 113.24,57.42 112.42,58.24 112.42,59.11 110.49,61.04 107.87,61.04 102.74,66.17 102.74,67.67 101.47,68.94 v1(101.47,70.66)
  BOTTOM w0.114: v5(100.46,70.62) 100.5,70.66 v1(101.47,70.66)
PSW_GPIO: length 160.7
  TOP w0.114: v6(148.82,164.06) 149.26,164.51 151.49,164.51 151.61,164.39 CPU1.AV19 ; R456.1 129.93,52.92 129.57,53.29 128.14,53.29 127.05,52.2 JMP1.3
  L3 w0.114: v1(144.48,87.27) 144.48,98.61 v1(145.51,99.64) ; v1(119.2,85.13) 119.04,84.98 119.04,75.91 119.51,75.44 122.83,75.44 126.54,71.73 126.54,63.38 128.37,61.55 128.91,61.55 129.18,61.28 129.18,58.95 127.65,57.42 127.65,53.78 JMP1.3
  L4 w0.114: v1(145.51,99.64) 145.51,119.6 146.18,120.27 146.18,154.69 147.83,156.34 147.83,158.32 148.92,159.41 148.92,159.66 149.41,160.15 149.41,163.32 148.82,163.91 v6(148.82,164.06)
  BOTTOM w0.114: TP103.1 148.63,163.88 v6(148.82,164.06) ; v1(144.48,87.27) 142.57,87.27 141.17,88.67 133.86,88.67 133.35,89.18 129.52,89.18 128.16,90.54 123.08,90.54 122.43,89.89 122.43,86.79 120.85,85.22 119.28,85.22 v1(119.2,85.13)
PURE_HW_SHUTDOWN#: length 231.7
  TOP w0.114: R1202.1 108.46,202.82 109.86,201.42 v1(110.79,201.42) ; v1(85.24,58.14) 85.24,58.14 85.22,58.12 85.22,55.25 86.84,53.62 87.86,53.62 88.27,54.03 93.17,54.03 93.38,54.24 93.99,54.24 v1(94.49,54.74) ; v1(111.61,125.2) 113.13,125.2 114.72,126.78 R2603.2
  L3 w0.114: v1(94.49,54.74) 95.35,54.74 96.84,56.23 98.49,56.23 99.53,55.19 102.48,55.19 102.56,55.12 102.78,54.9 107.38,54.9 v1(108.15,54.13)
  L4 w0.114: v1(85.24,58.14) 85.13,58.14 84.68,58.59 84.68,79.01 91.44,85.78 91.44,98.15 97.92,104.62 103.94,104.62 112.7,113.39 112.7,124.1 v1(111.61,125.2) 111.61,126.34 113.21,127.95 113.21,133.44 110.49,136.16 110.49,138.92 110.48,138.92 110.48,139.32 110.63,139.46 110.63,140.82 112.06,142.25 112.06,145.63 112.09,145.66 112.09,151.67 111.04,152.72 111.04,156.27 111.05,156.29 111.05,158.88 113.94,161.77 113.94,164.05 114.15,164.26 114.15,166.9 116.03,168.78 116.03,169.4 116.15,169.52 116.15,189.38 113.87,191.66 113.87,191.92 113.34,192.46 113.07,192.46 112.39,193.14 112.39,200.1 111.07,201.42 v1(110.79,201.42) ; v1(107.34,48.74) 107.34,49.56 108.74,50.95 108.74,53.54 v1(108.15,54.13)
  BOTTOM w0.114: v1(107.34,48.74) 107.34,47.72 Q14.D ; v1(108.15,54.13) 108.95,54.93 109.26,54.93 109.45,55.12 v2(109.58,55.12) 109.58,55.12 110.64,55.12 111.25,55.73 111.25,57.3 111.9,57.95 Q8.B 114.34,57.95 114.78,57.51 114.82,57.51 115.32,57.01 R182.1 116.4,57.89 R181.2 116.4,58.7 116.87,59.17 116.87,60.07 117.48,60.68 117.91,60.68 118.18,60.41 119.19,60.41 119.83,61.05 119.83,63.11 119.2,63.74 D3.K
PURE_HW_SHUTDOWN#_R: length 4.2
  TOP w0.114: R2603.1 116.26,128.45 116.8,128.99 v3(116.99,128.99) Q50.C
PWR_0D8V: length 3.7
  TOP w0.203: v4(115.32,193.45) 115.6,193.17 PG195.1 PG192.1 PG196.1 PG193.1
  BOTTOM w0.356: PG190.2 119.18,192.66
  vias: v4(116.08,194.21) v4(116.89,193.47) v4(117.73,194.21) v4(118.49,193.45) v5(116.08,195.58) v5(117.37,197.33)
PWR_0D8V_BOOT: length 4.3
  BOTTOM w0.254: PU47.1 113.35,205.3 111.76,203.71 PR318.1
  BOTTOM w0.508: PR318.1 111.58,203.3 111.1,203.3 v2(110.67,202.87)
PWR_0D8V_BOOT_A: length 2.7
  BOTTOM w0.508: PR318.2 111.76,201.7 112.47,200.99 v5(112.65,200.99) 112.83,201.17 PC373.1
PWR_0D8V_EN: length 6.9
  BOTTOM w0.254: PU47.11 117.05,207.1 117.27,207.31 117.27,208.65 117.8,209.18 v2(117.82,209.18) 117.7,209.3 117.5,209.3 117.02,209.78 117.02,209.91 116.82,210.11 PC499.1 117.85,210.33 PR321.1 118.03,210.32 PR320.2
PWR_0D8V_FB: length 5.4
  BOTTOM w0.254: PU47.14 117.41,205.75 117.75,206.1 PR319.2
  BOTTOM w0.508: PR322.1 119.41,208.05 119.3,208.15 v2(118.78,208.15) PC383.2 PR319.2
PWR_0D8V_FB_A: length 15.7
  L3 w0.508: v1(120.98,192.71) 120.95,192.74 120.95,194.18 121.16,194.39 121.16,204.62 120.14,205.64 120.14,206.38 v1(120.52,206.76)
  BOTTOM w0.406: v1(120.98,192.71) 120.93,192.66 PG190.1
  vias: v2(121.28,207.06)
PWR_0D8V_ILMT: length 9.5
  TOP w0.254: v1(120.51,209.93) 119.62,209.04 v3(119.38,209.04) 119.25,209.04 118.83,208.62 PR325.1
  BOTTOM w0.254: v1(120.51,209.93) 119.66,209.08 PR323.1 118.55,209.08 117.88,208.41 117.88,206.81 117.27,206.2 PU47.13
PWR_0D8V_PG: length 6.4
  BOTTOM w0.254: PU47.9 115.66,208.25 116.48,209.07 116.48,209.22 v2(116.54,209.27) 116.51,209.3 116.51,209.68 116.22,209.97 116.22,210.38 115.77,210.82 115.74,210.82 PR324.2 116.95,212.32 PR326.2
PWR_0D8V_PH: length 2.6
  BOTTOM w0.254: PU47.6 114.31,208.16 113.84,208.64 v1(113.79,208.64) ; PU47.19 114.76,203.47 114.81,203.43
  vias: v4(114.53,200.25) v4(114.58,202.36) v4(114.58,201.35) v4(115.93,200.13) v4(116.94,200.13) v4(118.03,200.08) v5(116.15,201.27) v5(117.78,202.41)
PWR_0D8V_VCC: length 1.8
  BOTTOM w0.254: PC372.1 118.75,204.09 119.25,203.58 v5(119.25,202.56)
PWR_0D9V_FB: length 6.4
  TOP w0.508: PU53.2 143.13,206.12 143.76,205.49 143.76,204.98 144.21,204.53 PC427.2 PR352.2 145.67,203.56 v3(145.57,203.45) 145.39,203.28 PR354.1
PWR_0D9V_PG: length 18.2
  TOP w0.254: PU53.7 135.33,206.12 133.53,207.92 133.53,210.62 135.94,213.03 v3(139.99,213.03) 141.69,213.03 142.24,213.58 PR355.1
PWR_0D9V_VIN: length 0.2
  TOP w0.254: PG215.1 137.54,211.96
  vias: v3(136.27,211.2)
PWR_0D775V: length 0.7
  TOP w0.305: 123.44,213.36 123.24,213.56 PG153.1
  vias: v3(123.7,212.47)
PWR_0D775V_EN: length 3.3
  TOP w0.254: PR218.1 123.89,216.09 v3(124.59,215.39) 124.61,215.37 124.74,215.37 125.73,214.38 PQ11.5
PWR_0D775V_EN_R: length 7.9
  TOP w0.254: v3(130.28,213.39) 129.9,213.77 129.9,214.02 129.54,214.38 PQ11.2 ; v3(130.28,213.39) 130.28,213.74 130.56,214.02 130.56,214.48 130.01,215.03 PQ11.3 ; v3(130.28,213.39) 130.43,213.39 130.45,213.36 PR216.2
PWR_0D775V_VIN: length 4.4
  TOP w0.508: PC271.1 PG154.1 128.12,211.56 128.27,211.71 v3(128.4,211.71)
  TOP w0.635: PC271.1 127.25,209.78 127,209.52 PU38.1
PWR_0D775V_VREF: length 7.7
  TOP w0.254: PU38.3 124.46,210.25 PR217.1 124.52,211.07 124.4,211.2 PR215.2 124.4,212 124.92,212.52 v3(124.92,213.1) 124.71,213.3 124.71,214.06 PC272.1 125.09,214.12 125.49,213.73 PQ11.6
PWR_1D2V: length 48.9
  TOP w0.203: 223.39,97.71 222.94,98.17 PG85.1 PG75.1 PG76.1 PG78.1 PG79.1 PG81.1 PG86.1 PG84.1 PG77.2
  TOP w0.254: 227.58,133.99 227.38,134.19 PG74.1 ; PG72.1 226.62,134.19 226.69,134.11
  L3 w1.524: v4(226.69,105.26) 226.8,105.16 232.41,105.16 233.43,106.17 233.43,131.14 232.49,132.08
  BOTTOM w0.203: PG65.1 PG84.1 PG86.1 PG81.1 PG79.1 PG78.1 PG76.1 PG75.1 PG85.1 222.94,98.17 223.37,97.74
  vias: v2(225.5,106.45) v2(226.41,99.67) v2(228.78,108.61) v3(227.91,103.71) v4(223.62,107.04) v4(223.67,108.48) v4(224.13,104.7) v4(224.31,100.48) v4(224.38,102.11) v4(224.71,109.86) v4(224.92,103.5) v4(225.4,104.65) v4(225.73,102.11) v4(225.73,100.56) v4(226.44,103.38) v4(226.72,109.93) v4(228.5,109.93) v4(229.97,133.88) v4(230,132.44) v4(230.07,109.58) v4(230.17,108.05)
PWR_1D5V: length 0.3
  TOP w0.305: PG152.1 140.64,132.03 ; PG151.1 139.88,131.95
  vias: v3(140.16,131.06)
PWR_1D05V: length 0.9
  TOP w0.254: 147.03,32.86 PG120.2 ; PG123.1 145.03,33.6 ; PG127.1 146.56,33.63 ; PG129.1 143.51,33.68 ; PG124.1 144.27,33.6 ; PG126.1 145.8,33.71
  vias: v2(146.3,32.77) v3(144.63,32.79) v4(145.54,32.13) v4(145.54,30.99)
PWR_1D05V_BOOT: length 2
  TOP w0.254: PU33.1 144.36,18.02 PR188.1
PWR_1D05V_BOOT_A: length 2.3
  TOP w0.508: PR188.2 141.99,18.87 v3(141.99,19.68) 142.94,19.68 PC223.1
PWR_1D5V_EN: length 5.4
  TOP w0.254: PR210.2 PC428.1 PR389.1 131.18,125.59 v3(131.44,125.86) 132.21,125.86 132.79,125.27 PU37.8
PWR_1D05V_EN: length 6.5
  TOP w0.254: PU33.11 v3(149.95,16.22) 150.75,16.22 PR192.1 150.96,15.67 PC431.1 149.99,14.69 PR363.2 151,13.65 PR337.2
PWR_1D5V_FB: length 6.8
  TOP w0.508: PU37.2 141.26,126.54 PR360.1 141.52,126.42 PR359.2 PC265.2 141.52,128.97 v3(142.27,129.72)
PWR_1D05V_FB: length 5.4
  TOP w0.254: PR190.1 150.04,18.06 v3(149.99,18.01) 149.55,17.57 PU33.14
  TOP w0.508: PR190.1 150.99,18.33 150.38,18.94 PC231.2 150.38,20.19 PR189.2
PWR_1D05V_FB_A: length 21.3
  TOP w0.508: PC231.1 151.26,19.13 151.26,20.19 151.41,20.35 PR189.1 151.36,20.41 151.36,22.78 v1(149.99,24.16) ; PG120.1 v1(148.81,32.86)
  L3 w0.508: v1(149.99,24.16) 150.27,23.88 151.03,23.88 152.58,25.43 152.58,26.39 151.79,27.18 151.79,31.98 150.91,32.86 v1(148.81,32.86)
  BOTTOM w0.508: v1(149.99,24.16) 150.47,23.67 v5(150.47,23.32)
PWR_1D05V_ILMT: length 5
  TOP w0.254: PU33.13 v1(149.83,17.12) 149.89,17.12 149.99,17.02 PR348.1
  BOTTOM w0.254: v1(149.83,17.12) 149.97,17.26 149.97,18.18 v5(149.98,18.18) 149.97,18.18 PR191.1
PWR_1D5V_PG: length 5.4
  TOP w0.254: PU37.7 132.28,126.54 131.78,127.05 PR212.2 130.16,126.11 v3(129.54,126.11) 129.49,126.16 PR214.2
PWR_1D05V_PG: length 5.5
  TOP w0.254: PU33.9 147.47,15.04 147.78,14.73 v1(147.78,14.61) 147.92,14.47 PR335.2
  BOTTOM w0.254: v1(147.78,14.61) 147.78,14.05 147.56,13.83 v2(147.54,13.83) 147.54,13.73 147.04,13.23 145.66,13.23 PR336.2
PWR_1D5V_PH: length 1.4
  TOP w0.254: v4(145.24,15.01) 145.82,15.01 146.12,15.31 PU33.6
  vias: v4(144.95,19.75) v4(145.99,19.75) v5(145.67,17.2)
PWR_1D05V_VCC: length 4.6
  TOP w0.254: 148.75,19.65 147.94,19.65 147.47,19.17 PU33.17
  TOP w0.508: 148.75,19.65 149.09,19.65 149.56,20.12 v3(149.56,20.17) 149.74,20.35 PC222.1
PWR_1D5V_VIN: length 0.3
  TOP w0.305: PG150.1 133.83,131.7
  vias: v3(132.49,130.94)
PWR_1D8V: length 6
  TOP w0.203: 131.88,122.05 132.41,122.58 PG137.1 PG134.1 PG135.1 PG138.1 PG141.1 PG142.1 137.13,122.58 137.26,122.45 PG132.2
  vias: v4(133.65,121.18) v4(134.57,121.18) v4(135.48,121.18) v5(133.86,120.02) v5(135.8,120.06)
PWR_1D8V_BOOT: length 3.6
  TOP w0.305: 132.33,109.5 132.33,109.45 132.73,109.05 PU34.1
  TOP w0.508: v3(130.3,110.74) 130.33,110.74 PR193.1 132.21,109.63 132.33,109.5
PWR_1D8V_BOOT_A: length 3.7
  TOP w0.508: PR193.2 129.16,110.39 v3(129.16,111.76) 129.16,111.8 129.54,112.18 PC233.1
PWR_1D8V_EN: length 6.6
  TOP w0.254: PU34.11 136.84,107.25 v1(137.29,106.81)
  BOTTOM w0.254: PR340.2 137.6,105.52 137.85,105.28 v5(138.61,105.28) 138.75,105.42 PR197.1 PC484.1 137.79,107.31 v1(137.29,106.81)
PWR_1D8V_FB: length 12.1
  TOP w0.254: 138.53,108.97 137.21,108.97 136.85,108.6 PU34.14
  TOP w0.508: PR194.2 138.82,113.72 140.69,113.72 141.5,112.9 v3(141.5,111.32) 141.5,109.8 140.98,109.28 PC242.2 PR195.1 138.85,109.28 138.53,108.97
PWR_1D8V_FB_A: length 22.7
  TOP w0.508: PG132.1 141.22,122.45 141.86,121.82 v3(141.86,120.11) 141.86,114.33 ; 141.86,114.33 142.6,113.59 142.6,109.04 141.94,108.38 140.35,108.38 PC242.1 ; 141.86,114.33 141.58,114.6 138.82,114.6 PR194.1
PWR_1D8V_ILMT: length 5.8
  TOP w0.254: PU34.13 136.98,108.15 137.85,107.29 PR349.1 138.72,106.03 v3(138.68,105.99) 138.49,105.8 PR196.1
PWR_1D8V_PG: length 4.1
  TOP w0.254: v3(137.41,105.16) 136.58,105.16 PR338.2 136.39,104.97 PR339.2 135.3,105.66 135.07,105.89 PU34.9
PWR_1D8V_PH: length 4.2
  TOP w0.254: v4(133.15,105.74) 133.72,106.31 PU34.6 ; 134.26,110.54 134.17,110.45 PU34.19
  TOP w0.508: 132.11,113.46 130.64,113.46 PC233.2
  vias: v4(132.84,110.62) v5(133.43,108.38)
PWR_1D8V_VCC: length 6.1
  TOP w0.254: PC234.1 v3(138.89,111.43) 138.89,111.33 138.23,110.67 135.53,110.67 135.07,110.2 PU34.17
PWR_1D8V_VGA: length 0.4
  TOP w0.254: PG223.1 95.57,156.66 ; PG222.1 95.6,155.77
  vias: v3(97.66,157.1)
PWR_1D8V_VGA_EN: length 6.8
  TOP w0.254: PU55.8 105.18,163.27 v1(105.61,163.7) 106.3,164.39 106.3,164.39 PC457.1 106.7,164.47 PR375.2
  BOTTOM w0.254: v1(105.61,163.7) 104.92,163.7 v2(104.8,163.58) PR390.1 104.71,162.5 PC501.1
PWR_1D8V_VGA_FB: length 7.3
  TOP w0.508: PR376.2 95.86,161.27 PC459.2 95.75,161.38 PR377.1 95.75,163.06 v3(96.27,163.57) 96.52,163.57 96.88,163.22 96.88,162.67 97.54,162 PU55.2
PWR_1D8V_VGA_PG: length 4.6
  TOP w0.254: PR378.1 106.57,162.21 107.21,161.57 PR374.2 106.27,161.46 v3(106.17,161.56) 105.73,162 PU55.7
PWR_1D8V_VGA_VIN: length 0.3
  TOP w0.254: PG221.1 108.04,157.16 ; PG220.1 108.12,158.17
  vias: v3(104.27,157.73) v6(100.61,161.29) v6(101.63,160.66) v6(101.65,162.81) v6(101.66,162.08) v6(101.66,161.37) v6(101.65,159.94) v6(102.64,161.32)
PWR_1D35V: length 4.8
  TOP w0.254: 36.56,216.87 PG240.1 ; 36.53,219.16 PG244.1 ; 35.04,212.73 PG237.2 ; 36.58,217.64 PG239.1 ; 36.86,213.83 PG245.1 ; 36.64,215.35 PG242.1 ; 36.64,218.4 PG238.1 ; 36.76,214.59 PG243.1 ; 36.62,216.11 PG241.1
  BOTTOM w0.254: 36.9,219.32 PG246.1 ; 36.82,217.03 PG207.1 ; 36.79,220.08 PG202.1 ; 36.87,218.56 PG206.1 ; 36.79,216.27 PG203.1 ; 36.85,217.79 PG205.1 ; 36.9,215.51 PG198.1 ; 36.87,214.75 PG199.1 ; 36.84,213.98 PG247.1
  vias: v2(32.89,216.15) v4(28.83,214.88) v4(28.83,213.74) v4(29.34,219.96) v4(29.97,214.88) v4(29.97,213.74) v4(30.48,219.96) v4(32.51,218.57) v4(33.66,218.57) v4(34.8,218.57) v4(34.8,217.42) v4(34.8,216.15) v4(35.69,218.95) v4(35.69,217.93) v4(35.69,216.79) v4(35.69,215.52)
PWR_1D35V_BOOT: length 4
  TOP w0.203: PU48.18 9.86,213.66 9.53,214
  TOP w0.508: v3(7.87,215.26) 8.94,215.26 PR421.1 8.99,214.53 9.53,214
PWR_1D35V_BOOT_A: length 3.4
  TOP w0.508: PR421.2 8.99,217.42 9.25,217.68 v3(9.91,217.68) 10.57,217.68 10.82,217.42 PC385.1
PWR_1D35V_CS: length 3
  TOP w0.203: v1(12.45,211.46) 12.19,211.2 PU48.13
  BOTTOM w0.254: v1(12.45,211.46) 12.45,210.9 12.65,210.69 v2(12.65,210.67) 12.67,210.64 PR425.1
PWR_1D35V_EN: length 6.2
  TOP w0.203: PU48.8 9.86,208.86 v1(9.65,208.66)
  TOP w0.254: PR392.2 9.52,206.73 PR393.1 9.52,208.53 v1(9.65,208.66)
  BOTTOM w0.254: PC500.1 9.52,206.72 PR391.1 9.52,208.53 v1(9.65,208.66) 9.91,208.91 v2(9.91,209.55)
PWR_1D35V_FB: length 5.4
  TOP w0.203: PU48.6 9.06,209.14 8.65,208.74
  TOP w0.508: 8.65,208.74 8.24,208.74 v3(7.62,208.11) PR330.1 6.55,208.19 PR328.2 PC397.2
PWR_1D35V_HG: length 24.1
  TOP w0.203: PU48.17 10.26,213.84 v4(10.41,214)
  TOP w0.762: PU57.4 v4(24.79,223.39)
  L3 w1.016: v4(24.79,223.39) 23.5,223.39 20.57,220.47 16,220.47 14.58,219.05 12.19,219.05 10.08,216.95 10.08,214.5 10.41,214.17 v4(10.41,214)
  BOTTOM w0.508: v4(10.41,214) 10.16,213.74 v2(10.16,213.11)
PWR_1D35V_LG: length 7
  TOP w0.203: PU48.15 12.28,212 12.62,212.34
  TOP w0.762: PU58.4 16.66,211.3 15.62,212.34 v3(13.46,212.34) 12.62,212.34
PWR_1D35V_PG: length 3.6
  TOP w0.203: PU48.10 10.85,209.65 11.18,209.32
  TOP w0.254: PR347.1 PR346.2 12.14,208.36 11.18,209.32
PWR_1D35V_PH: length 16.3
  TOP w0.203: 10.69,212.75 PU48.16
  L3 w1.016: v4(11.86,215.24) 11.86,216.21 12.92,217.27 15.32,217.27 16.74,218.69 21.46,218.69 23.47,220.7 v4(25.3,220.7)
  vias: v2(20.07,215.14) v2(23.11,210.69) v4(25.12,214.93) v4(25.15,213.84) v4(25.15,210.69) v4(25.2,212.78) v4(25.2,211.68) v4(25.3,221.97) v4(25.3,219.68) v4(26.54,222) v4(26.54,220.73) v4(26.54,219.71) v4(26.54,218.57) v4(26.54,217.55) v4(26.54,216.28) v4(26.54,215.26) v4(26.54,214.12) v4(26.54,213.11) v4(26.54,211.96) v4(26.54,210.95)
PWR_1D35V_SNUB: length 1.6
  TOP w0.508: PC509.1 20.43,217.35 PR422.2
PWR_1D35V_TON: length 3.6
  TOP w0.203: PU48.9 10.26,208.97 v1(10.59,208.64)
  BOTTOM w0.254: v1(10.59,208.64) 11.33,208.64 v2(11.56,208.41) 11.56,208.03 11.37,207.84 PR327.2
PWR_1D35V_VDD: length 4
  TOP w0.203: PU48.12 12.85,210.8 v3(13.08,210.57)
  TOP w0.508: PR423.1 14.11,209.52 PC384.1 14.01,210.57 v3(13.08,210.57)
PWR_1D35V_VDDQ: length 33.9
  TOP w0.203: PU48.5 8.3,210.11 v1(7.9,209.7)
  TOP w0.508: v1(7.9,209.7) 7.44,209.7 7.07,210.07 PR328.1 PC397.1 ; PG237.1 35.04,210.7 35.05,210.69 v1(35.05,210.55)
  L6 w0.508: v1(7.9,209.7) 12.42,209.7 13.21,208.91 33.41,208.91 v1(35.05,210.55)
  BOTTOM w0.508: v2(7.62,208.91) 7.62,209.42 v1(7.9,209.7)
PWR_1D35V_VID: length 4.3
  TOP w0.203: 11.41,209.99 PU48.11
  TOP w0.508: PR424.1 14.33,208.24 PC511.1 13.39,208.66 v3(12.83,209.22) 12.83,209.22 12.63,209.42 11.97,209.42 11.41,209.99
PWR_1D35V_VTTREF: length 2.9
  TOP w0.203: PU48.4 v1(7.29,210.8)
  BOTTOM w0.254: PC510.1 8.15,210.59 v2(8.1,210.54) 7.55,210.54 v1(7.29,210.8)
PWR_2D5V: length 0.3
  TOP w0.305: PG148.1 138.68,77.09 ; PG149.1 138.76,76.33
  vias: v3(137.85,76.71)
PWR_2D5V_EN: length 8.6
  TOP w0.254: PR209.2 145.11,65.25 v3(144.96,65.41) 144.85,65.29 PR387.1 143.01,65.29 PC432.1 142.98,65.58 143.39,65.99 143.39,66.63 141.82,68.2 141.22,68.2 140.84,67.82 PU51.8
PWR_2D5V_FB: length 4.9
  TOP w0.508: PU51.2 139.57,74.1 PC259.2 PR206.2 139.97,75.17 v3(140.61,75.17) 141.56,75.17 PR208.1
PWR_2D5V_PCH: length 1
  TOP w0.254: PG236.1 139.8,60.88 ; PG226.1 139.73,61.65 ; PG227.1 139.73,62.41
  vias: v3(138.91,61.44)
PWR_2D5V_PCH_EN: length 5.5
  TOP w0.254: PR396.2 v3(133.6,55.94) 133.35,56.2 PR388.1 PC487.1 131.57,57.26 PU56.8
PWR_2D5V_PCH_FB:
  vias: v3(138.71,58.39)
PWR_2D5V_PCH_PG: length 67
  TOP w0.254: v1(130.25,57.32) 129.81,57.32 128.79,58.33 PR395.2 129.45,59.44 PU56.7 ; v1(176.01,64.53) 176.9,63.64 v3(176.9,58.48) 176.9,58 177.52,57.38 177.52,56.36 176.91,55.75 176.91,54.41 177.79,53.53 PR400.2
  L6 w0.254: v1(176.01,64.53) 175.08,65.46 169.66,65.46 169.25,65.05 152.93,65.05 152.15,64.27 152.15,64.26 150.55,62.66 145.36,62.66 144.55,63.47 140.13,63.47 137.32,60.66 134.55,60.66 132.69,58.8 131.83,58.8 130.34,57.32 v1(130.25,57.32)
PWR_2D5V_PCH_VIN: length 2.8
  TOP w0.203: PC485.1 133.35,64.26 PG224.1 PG225.1 PG235.1
  vias: v3(130.2,63.45)
PWR_2D5V_PG: length 144.6
  TOP w0.254: PU51.7 139.57,66.55 140.08,66.04 141.63,66.04 v1(141.66,66.07) 141.66,65.84 141.16,65.34 PR207.2 ; v1(214.38,129.16) 213.68,129.86 PR399.2 ; v1(212.22,74.55) 212.06,74.4 212.06,74.37 209.32,71.63 v3(206.59,71.63) 185.72,71.63 181.98,67.89 180.89,67.89 180.26,67.26 v1(179.91,67.26)
  L4 w0.254: v1(214.38,129.16) 214.48,129.06 214.48,119.94 219.38,115.04 219.38,105.49 218.59,104.7 218.59,96.06 221.64,93.01 221.64,90.5 220.88,89.74 220.88,83.69 217,79.82 217,77.18 214.38,74.55 v1(212.22,74.55)
  L6 w0.254: v1(141.66,66.07) 141.66,66.37 142.7,67.41 148.04,67.41 148.78,68.15 167.97,68.15 168.63,68.81 177.24,68.81 178.41,67.64 179.02,67.64 179.4,67.26 v1(179.91,67.26)
PWR_2D5V_VIN: length 0.6
  TOP w0.356: PG212.1 134.85,68.05 ; PG147.1 134.85,68.81
  vias: v3(135.28,70.56)
PWR_3D3V: length 13.5
  TOP w0.203: 136.91,19.08 137.54,18.44 137.79,18.44 PG32.1 PG17.2 PG18.1 PG24.2 PG27.1 PG211.1 PG234.1 137.03,23.11
  BOTTOM w0.203: 129.49,17.32 129.64,17.17 PG33.2 ; 137.13,23.19 137.21,23.11 PG234.1 PG211.1 PG27.1 PG24.2 PG18.1 PG17.2 PG32.1 137.9,18.41 137.62,18.14
  vias: v4(125.35,18.87) v4(125.5,22.89) v4(125.68,17.65) v4(126.8,22.89) v4(127.13,17.65) v4(128.27,22.89) v4(128.73,17.73) v4(130.15,22.78) v4(130.18,21.13) v4(130.25,19.58) v4(130.28,18.26) v4(131.17,20.68) v4(131.34,19.51) v4(131.34,18.41) v4(134.95,19.25) v4(135.13,20.45) v4(136.04,21.01) v4(136.19,19.28) v5(126.11,21.13) v5(128.32,19.33) v5(133.3,20.29)
PWR_3D3V_5V_PG: length 3.8
  TOP w0.203: PU3.7 102.22,28.18
  TOP w0.254: 102.22,28.18 v3(101.75,27.71) 101.47,27.44 PR65.1
PWR_3D3V_BOOT2: length 4.6
  TOP w0.203: PU3.9 103.02,27.84 103.25,27.61
  TOP w0.508: PR53.2 104.98,27.1 v3(104.75,27.33) 103.53,27.33 103.25,27.61
PWR_3D3V_BOOT2_A: length 2.5
  TOP w0.508: PC104.1 PR53.1 105,24.66 v3(106.2,24.66)
PWR_3D3V_CS2: length 4.5
  TOP w0.203: PU3.5 100.65,29.96 100.41,29.72 100.41,28.63
  TOP w0.254: 100.41,28.63 v3(99.64,27.86) 98.62,26.84 PR57.1
PWR_3D3V_EN2: length 5
  TOP w0.203: PU3.6 101.82,28.66 101.22,28.07
  TOP w0.254: PR67.2 PC504.1 100.58,25.97 100.58,26.86 v3(100.59,26.87) 100.58,26.87 100.58,27.43 101.22,28.07
PWR_3D3V_FB2: length 6.5
  TOP w0.203: PU3.4 100.18,30.36 99.52,29.69
  TOP w0.508: PR59.2 96.88,27.22 97.16,27.5 PR61.1 97.65,27.74 98.2,27.74 99.47,29 99.47,29.4 v3(99.47,29.41) 99.47,29.64 99.52,29.69
PWR_3D3V_FB2_A: length 47.9
  TOP w0.508: PR59.1 96.29,25.7 v1(96.7,25.3)
  L4 w0.508: v1(129.06,16.56) 126.34,13.84 124.77,13.84 121.91,10.98 115.69,10.98 114.1,12.57 106.06,12.57 101.94,16.7 101.94,18.46 100.99,19.41 100.99,22.41 100.76,22.64 100.76,24.56 100.25,25.07 96.93,25.07 v1(96.7,25.3)
  BOTTOM w0.508: v1(129.06,16.56) PG33.1 ; v5(96.7,26.16) v1(96.7,25.3)
PWR_3D3V_HG2: length 29.2
  TOP w0.203: PU3.10 103.42,28.89 104.01,28.3 v4(104.01,28.12)
  L6 w1.016: v4(104.01,28.12) 104.62,27.51 104.62,26.39 106.2,24.82 108.03,24.82 112.12,20.73 112.12,18.92 117.35,13.69 120.32,13.69 v4(120.88,13.13)
  BOTTOM w0.508: v5(103.1,28.12) v4(104.01,28.12)
  BOTTOM w0.762: PU2.4 120.35,12.04 120.88,12.57 v4(120.88,13.13)
PWR_3D3V_LDO3: length 5.2
  TOP w0.203: PU3.3 v3(99.25,30.76) 99.2,30.81
  TOP w0.254: 99.2,30.81 PC112.1 96.93,30.81 96.7,31.04 PG36.2
PWR_3D3V_LG2: length 13.5
  TOP w0.203: PU3.11 104.56,29.96 105.41,29.11 v4(105.64,29.11)
  L6 w1.016: v4(105.64,29.11) 107.34,29.11 110.57,25.88 v4(113.64,25.88)
  BOTTOM w0.508: v4(105.64,29.11) 105.11,28.57 v5(105.11,28.3)
  BOTTOM w0.762: PU4.4 v4(113.64,25.88)
PWR_3D3V_PH2: length 34.5
  TOP w0.203: PU3.8 102.62,27.43 102.49,27.3 v4(102.49,27.13)
  TOP w0.635: PC104.2 103.15,26.16 102.49,26.82 v4(102.49,27.13)
  L6 w1.016: v4(122.56,13.94) 122.68,13.82 122.68,12.32 121.69,11.33 117.17,11.33 110.34,18.16 110.34,19.96 109.48,20.82 109.47,20.84 108.94,21.37 108.92,21.38 107.26,23.04 105.41,23.04 102.49,25.96 v4(102.49,27.13)
  vias: v3(119.66,14.22) v4(121.23,17.09) v4(121.28,20.57) v4(121.28,18.9) v4(121.41,24.87) v4(121.39,22.07) v4(121.46,23.62) v4(122.62,24.65) v4(122.63,23.09) v4(122.58,18.11) v4(122.56,16) v4(122.66,21.41) v4(122.66,19.71) v5(121.84,14.94)
PWR_3D3V_SNUB: length 2.9
  BOTTOM w0.508: PR55.2 v2(115.75,18.26) 115.72,18.29 PC108.1
PWR_5V: length 13.5
  TOP w0.203: 137.03,32.51 137.24,32.72 PG232.2 PG233.1 PG30.1 PG22.1 PG15.2 PG9.2 PG10.1
  BOTTOM w0.203: PG232.2 PG233.1 PG30.1 PG22.1 PG15.2 PG9.2 PG10.1 138.02,37.85 137.54,38.33 ; PG34.2 PG35.2 133.99,38.73 134.42,38.3
  vias: v3(132.21,38.48) v4(125.12,37.72) v4(125.12,35.74) v4(125.12,34.09) v4(126.16,36.73) v4(126.49,38.38) v4(127.79,37.85) v4(127.89,36.73) v4(128.98,38.4) v4(129.29,36.75) v4(130.05,35.81) v4(130.3,37.64) v4(130.86,34.77) v4(131.04,38.51) v4(131.7,37.13) v4(131.8,35.99) v4(131.98,34.67) v4(132.87,37.69) v4(134.16,37.74) v4(135.2,35.89) v4(135.25,34.62) v4(136.58,36.58) v4(136.6,35.13) v5(125.48,32.77) v5(128.14,35.05) v5(133.6,35.81) v5(136.02,38.1)
PWR_5V3V_EMN_R: length 10.2
  BOTTOM w0.114: D2.3 112.68,59.87 113.77,60.96 114.83,60.96 v2(115.01,61.14) 116,62.13 R175.1 R173.1 118.51,62.13 D3.A 119.1,61.37 117.24,61.37 116.95,61.07 R179.1
PWR_5V_BOOT1: length 4.9
  TOP w0.203: 103.38,33.53 103.02,33.17 PU3.17
  TOP w0.508: PR54.1 105.69,35.76 104.75,34.82 104.44,34.82 v3(104.14,34.52) 104.14,34.23 103.43,33.53 103.38,33.53
PWR_5V_BOOT1_A: length 3.4
  TOP w0.508: PR54.2 105.69,38.14 v3(105.11,38.72) 104.84,38.72 104.42,38.3 PC105.1
PWR_5V_BYP1: length 37.9
  TOP w0.203: PU3.14 105.37,31.16 v1(105.49,31.04)
  L4 w0.508: v1(105.49,31.04) 105.84,31.04 107.49,32.69 107.49,37.36 111.18,41.05 121.7,41.05 121.95,41.3 122.5,41.3 122.75,41.05 123.6,41.05 123.61,41.06 124.16,41.06 124.18,41.05 132.05,41.05 132.46,40.64 v1(132.56,40.64)
  BOTTOM w0.508: PG34.1 v1(132.56,40.64) ; v5(104.89,30.45) v1(105.49,31.04)
PWR_5V_CS1: length 5.4
  TOP w0.203: 100.41,31.73 100.58,31.56 PU3.1
  TOP w0.254: PR58.1 98.25,34.39 v3(98.55,34.09) 98.93,34.09 100.41,32.61 100.41,31.73
PWR_5V_EN1: length 4.9
  TOP w0.203: PU3.20 101.82,32.6 101.55,32.87
  TOP w0.254: PR66.2 100.26,35.09 PC503.1 100.26,34.42 v3(99.92,34.09) 101.14,32.87 101.55,32.87
PWR_5V_FB1: length 5.2
  TOP w0.203: PU3.2 99.93,31.16 99.31,31.78
  TOP w0.508: 99.31,31.78 v3(98.86,32.23) PR60.2 PR62.1
PWR_5V_FB1_A: length 47.9
  TOP w0.508: PR60.1 v1(95.61,32.23)
  L4 w0.508: v1(133.53,40.49) 133.53,41.01 130.7,43.83 126.26,43.83 124.74,42.32 111,42.32 107.72,39.04 107.72,39.03 106.48,37.78 106.48,36.65 102.06,32.23 v1(95.61,32.23)
  BOTTOM w0.508: v1(133.53,40.49) 133.58,40.44 PG35.1 ; v5(96.44,32.23) v1(95.61,32.23)
PWR_5V_HG1: length 20
  TOP w0.203: 103.5,32.72 103.42,32.63 PU3.16
  L6 w1.016: v4(121.03,36.32) 118.87,34.16 105.26,34.16 v4(104.98,33.88)
  BOTTOM w0.508: v5(104.06,33.88) v4(104.98,33.88)
  BOTTOM w0.762: PU1.4 120.83,36.25 120.9,36.32 v4(121.03,36.32)
PWR_5V_LDO5: length 4.6
  TOP w0.203: PU3.13 104.88,30.76 105.16,30.48
  TOP w0.254: 105.16,30.48 106.5,30.48 PC113.1 107.11,31.09 v3(108.38,31.09)
PWR_5V_LG1: length 10.3
  TOP w0.203: 104.8,31.72 104.64,31.56 PU3.15
  L6 w1.016: v4(105.28,32.13) 107.47,32.13 107.98,31.62 112.14,31.62 v4(112.27,31.5)
  BOTTOM w0.508: v4(105.28,32.13) 105.12,32.29 v5(104.38,32.29)
  BOTTOM w0.762: v4(112.27,31.5) 112.37,31.39 PU5.4
PWR_5V_PH1: length 24.8
  TOP w0.203: v4(102.62,33.91) PU3.18
  TOP w0.635: PC105.2 103.84,35.86 103.15,35.18 103.15,34.44 v4(102.62,33.91)
  L6 w1.016: v4(120.85,38.1) 120.02,38.1 117.86,35.94 104.27,35.94 102.62,34.29 v4(102.62,33.91)
  vias: v2(122.2,34.32) v2(122.2,28.7) v4(121.03,34.42) v4(120.95,32.13) v4(121.06,30.61) v4(121.08,28.85) v4(121.44,39.22) v4(122.17,33.27) v4(122.28,38.3) v4(122.28,36.93) v4(122.25,35.31) v4(122.28,31.52) v4(122.28,29.87)
PWR_5V_SNUB: length 3
  BOTTOM w0.508: PR56.2 116.2,33.83 116.18,33.81 v2(116.13,33.81) 116.05,33.81 115.85,34.01 PC109.1
PWR_12V: length 20.3
  L3 w0.508: v1(5.56,198.37) 5.56,198.35 4.32,197.1 4.32,186.89 6.17,185.04 v4(9.86,185.04)
  BOTTOM w0.508: PR203.1 PR202.1 5.83,198.11 v1(5.56,198.37)
  vias: v2(10.39,184.07) v4(11.02,185.04) v4(12.14,185.01)
PWR_12V_BOOT:
  vias: v2(14.2,197.79)
PWR_12V_BOOT_A: length 4.3
  TOP w0.508: v1(17.14,196.29) 16.94,196.49 PC246.1
  BOTTOM w0.508: v1(17.14,196.29) PR198.1 15.34,195.66 v2(15.34,194.77)
PWR_12V_EN: length 7.3
  TOP w0.254: v1(6.27,195) 7.11,195 v3(7.19,195.07) 7.19,195.2 7.21,195.22 PR201.2
  BOTTOM w0.254: PU35.5 9.92,195.62 9.73,195.43 8.07,195.43 PR386.1 6.61,195.89 PC505.1 6.27,195.58 v1(6.27,195)
PWR_12V_FB:
  vias: v2(8.28,200.81)
PWR_12V_FB_A: length 2.3
  BOTTOM w0.508: PR202.2 6.38,199.78 PC255.1 5.97,200.62 v2(5.97,200.96)
PWR_12V_LX:
  vias: v3(12.83,195.05) v4(12.95,193.8) v4(12.95,192.66) v4(14.1,193.8) v4(14.1,192.66)
PWR_12V_PG: length 3.9
  TOP w0.254: v1(8.73,196.32) 8.66,196.32 8.28,196.7 v3(8.28,197.15) 8.21,197.23 PR342.2 7.2,198.23 PR341.2
  BOTTOM w0.254: PU35.6 v1(8.73,196.32)
PWR_12V_SNB: length 2.6
  TOP w0.508: v3(13.08,199.01) 13.35,199.01 PC254.1 14.01,197.24 PR200.2
PWR_12V_SS: length 3.6
  TOP w0.254: PC245.2 10.3,201.69 v3(10.03,201.42) 9.61,201 v1(9.61,200.43)
  BOTTOM w0.254: v1(9.61,200.43) 9.63,200.43 9.92,200.14 PU35.8
PWR_12V_SVIN: length 4.5
  BOTTOM w0.305: PU35.10 10.92,201.52 PR199.2
  BOTTOM w0.508: PR199.2 10.92,202.79 PC253.1 11.15,203.02 v2(11.96,203.02)
PWR_12V_VCC: length 2.6
  BOTTOM w0.254: PC244.1 9.74,201.08 10.42,200.4 PU35.9
PWR_19V_DCBATOUT_RT6575: length 4.7
  TOP w0.203: PU3.12 104.77,30.36 105.16,29.97 105.56,29.97
  TOP w0.508: v1(108.31,29.87) 107.9,29.46 PC97.1 106.2,29.95 106.07,29.95 106.05,29.97 105.56,29.97
  vias: v5(108.19,31.12)
PWR_CHG_ACN: length 10.4
  TOP w0.254: v3(27.18,106.35) PR410.4 24.64,108.03 23.93,108.74 21.18,108.74 20.68,109.25 20.68,109.93 20.5,110.11 U24.5
PWR_CHG_ACP: length 8.5
  TOP w0.254: PR410.3 24.33,111.07 v3(23.85,111.55) 23.32,112.09 20.93,112.09 19.76,110.92 U24.4
PWR_DCBATOUT_0D8V: length 10
  TOP w0.508: PC380.1 112.14,206.07 112.57,206.5 v1(112.62,206.5) 113.64,207.52 115.82,207.52 118.24,209.93 v1(118.65,209.93)
  BOTTOM w0.254: PG191.2 113.94,215.7 ; PG194.2 114.71,215.75
  BOTTOM w0.508: v1(118.65,209.93) 118.87,209.93 118.91,209.97 PR323.2
  vias: v5(111.51,207.14) v5(114.05,211.46)
PWR_DCBATOUT_1D05V: length 13.4
  TOP w0.254: PG121.2 146.75,10.88 146.66,10.79 ; 146.57,10.12 PG122.2 ; 146.57,9.36 PG125.2
  BOTTOM w0.508: v1(143.46,13.31) 144.2,12.57 147.29,12.57 149.86,15.14 v5(149.86,16.13) 150.86,17.13 PR191.2
PWR_DCBATOUT_1D8V: length 25.5
  TOP w0.203: PG136.2 PG133.2 PG131.2 129.69,106.22 PC240.1
  TOP w0.254: PU34.2 132.1,108.6 132.08,108.58
  TOP w0.508: PR196.2 139.78,104.6 v1(140.21,105.03)
  BOTTOM w0.508: v1(140.21,105.03) 138.46,103.28 136.86,103.28 136.32,102.74 136.32,101.78 134.85,100.3 130.1,100.3 128.45,101.96 128.45,105.46 128.73,105.74 PC240.1
  vias: v4(131.78,108.05) v4(131.78,106.96) v5(130.12,107.47)
PWR_DCBATOUT_1D35V: length 15.7
  BOTTOM w0.254: 12.35,220.69 PG201.2 ; 12.35,221.58 PG197.2 ; 12.41,219.8 PG204.2
  BOTTOM w0.508: PR327.1 11.62,206.95 12.32,207.65 12.32,209.3 11.43,210.19 11.43,214.38 11.05,214.76 11.05,216.03 12.01,216.99 12.01,218.59 12.57,219.15
  vias: v2(16.38,220.73) v4(13.03,221.82) v4(13.06,220.7) v4(14.02,221.79) v4(14.05,220.68) v4(15.04,221.79) v4(16.08,221.82)
PWR_DCBATOUT_3D3V: length 3.1
  BOTTOM w0.203: 107.7,11.56 107.49,11.76 PG13.2 PG19.2 PG7.2 107.49,14.27 107.7,14.48
  vias: v3(109.73,13.03) v3(114.6,14.63) v4(110.82,15.37) v4(110.82,14.35) v4(111.96,14.73) v4(111.96,13.72) v5(110.36,13.39)
PWR_DCBATOUT_5V: length 0.7
  BOTTOM w0.305: PG14.2 107.39,38.38 ; PG20.2 107.49,39.9 ; PG8.2 107.44,37.62 ; PG28.2 107.34,36.86 ; PG23.2 107.39,39.14
  vias: v2(108.74,40.28) v2(108.99,37.59) v2(110.82,40.34) v3(108.74,38.1) v3(112.73,37.13) v4(110.54,38.68) v4(111.68,38.05) v4(111.76,39.47)
PWR_DCBATOUT_12V: length 0.4
  BOTTOM w0.254: 12.65,204.14 PG144.2 ; 12.52,204.9 PG143.2
  vias: v2(13.97,204.72) v4(13.21,203.33) v4(14.22,203.33)
PWR_DCBATOUT_VCOREA: length 4
  TOP w0.203: 192.1,227.46 191.72,227.84 PG38.2 PG39.2 PG40.2 188.82,227.84 188.42,227.43
  vias: v2(190.42,222.83) v2(191.19,220.34) v2(192.58,227.38) v2(192.58,224.26) v4(188.11,223.16) v4(188.16,224.28) v4(188.32,226.54) v4(188.32,225.48) v4(189.2,224.38) v4(189.38,226.54) v4(189.38,225.48) v4(190.45,226.54) v4(190.45,225.48)
PWR_DCBATOUT_VCOREB: length 0.6
  TOP w0.254: PG43.2 175.31,228.9 ; PG44.2 173.79,228.9 ; PG45.2 174.55,228.98
  vias: v4(172.19,228.85) v4(172.19,227.79) v4(174.4,220.9) v4(174.4,219.84) v4(175.46,220.9) v4(175.46,219.84) v5(172.72,225.17) v5(174.47,222.35) v5(174.96,228.47) v5(175.03,225.17) v5(177.11,225.4)
PWR_DCBATOUT_VCOREC: length 0.4
  TOP w0.254: PG50.2 158.93,228.8 ; PG48.2 159.69,228.8 ; PG49.2 160.45,228.8
  vias: v4(158.72,227.99) v4(158.72,226.92) v4(158.72,225.86) v4(159.79,227.99) v4(159.79,226.92) v4(159.79,225.86) v5(157.3,228.42) v5(158.14,222.78) v5(159.84,220.04) v5(160.6,224.66) v5(161.37,228.4)
PWR_DCBATOUT_VDDCA: length 0.5
  TOP w0.254: PG159.2 96.34,106.35 ; 97.1,106.3 PG157.2 ; 97.87,106.27 PG155.2
  vias: v2(99.77,114.96) v6(99.2,117.96) v6(99.17,116.87)
PWR_DCBATOUT_VDDCB: length 2
  TOP w0.254: 86.54,109.78 PG165.2 PG167.2 PG169.2
  vias: v2(88.9,114.07) v6(87.69,117.91) v6(87.69,116.64)
PWR_DCBATOUT_VDDCC: length 0.3
  TOP w0.254: PG178.2 71.68,109.88 ; PG176.2 70.15,109.86 ; PG180.2 70.92,109.83
  vias: v2(75.72,115.11) v6(76.59,117.96) v6(76.62,116.79)
PWR_DCBATOUT_VDDCD: length 0.4
  TOP w0.254: PG160.2 58.12,109.68 ; PG156.2 59.64,109.68 ; PG158.2 58.88,109.7
  vias: v2(61.86,115.27) v6(62.22,117.86) v6(62.22,116.84)
PWR_DCBATOUT_VDDCE: length 0.5
  TOP w0.254: PG170.2 51.61,110.62 ; PG166.2 52.37,110.67 ; PG168.2 50.85,110.8
  vias: v2(51.61,116.2) v6(51.09,117.98) v6(51.09,116.84)
PWR_DCBATOUT_VDDCF: length 1.9
  TOP w0.203: 39.34,110.69 PG179.2
  TOP w0.254: PG177.2 PG175.2 PG179.2
  vias: v2(39.73,116.08) v6(40.07,118.03) v6(40.07,116.81)
PWR_DCBATOUT_VDDCI: length 1.5
  TOP w0.305: 143.15,221.82 143.12,221.86 PU46.14
  BOTTOM w0.305: PG185.2 148.16,226.85 ; PG186.2 147.4,226.87 ; PG187.2 146.63,226.87
  vias: v4(143.79,221.18) v4(143.79,220.27) v4(143.79,219.35) v4(145.21,221.18) v4(145.21,220.27) v4(145.21,219.35) v4(148.29,223.65) v4(148.29,222.73) v4(148.34,221.23) v4(148.34,219.96) v5(146.74,222.15) v5(146.81,219.43) v5(147.96,225.55)
PWR_DCBATOUT_VDDNBA: length 2.8
  TOP w0.203: PG55.2 PG53.2 PG54.2
  TOP w0.254: PG54.2 219.07,198.02 ; PG55.2 216.97,198.53 216.81,198.37
  vias: v3(218.16,191.31) v3(218.69,197.13) v3(218.97,194.16) v4(217.63,195.61) v4(217.63,194.54) v4(217.63,193.5)
PWR_DCBATOUT_VDDNBB: length 1.8
  TOP w0.203: PG60.2 PG59.2 PG58.2
  TOP w0.254: PG58.2 226.62,201.19
  vias: v3(225.68,199.95) v3(227.36,197.79) v4(224.94,198.02) v4(225.96,198.02) v5(226.34,200.46) v5(226.92,198.5)
PWR_DCBATOUT_VDDP: length 0.5
  TOP w0.254: PG112.2 151.96,225.82 ; PG109.2 152.72,225.84 ; PG106.2 151.2,225.8
  vias: v4(150.5,219.71) v4(150.75,224.41) v4(150.75,223.27) v4(150.75,222.25) v4(150.75,220.73) v4(151.13,218.31) v5(150.85,225.81) v5(152.58,222.22) v6(150.52,216.13) v6(150.52,215.14) v6(150.52,214)
PWR_DCBATOUT_VDDQ: length 24.7
  TOP w0.203: 230.89,131.44 231.34,130.99 PG63.2 PG64.2 PG66.2 231.34,128.09 231.14,127.89
  TOP w0.508: PR168.1 220.54,144.74 v1(220.8,145.01)
  L6 w0.508: v1(220.8,145.01) 221.95,143.87 224.56,143.87 229.03,139.4 229.03,131.42 v4(229.97,130.48)
  vias: v2(230.89,131.09) v3(228.04,130.05) v4(228.47,128.4) v4(228.88,129.39) v4(229.62,128.4) v4(230.38,129.41) v4(230.76,128.4)
PWR_VCCDDC_SENSE_A: length 8.6
  TOP w0.254: PC289.1 117.22,155.96 v1(116.97,155.7) 116.95,155.68 116.26,155.68 116.04,155.47 PR253.2 116.04,155.11 116.36,154.79 PC287.1
  BOTTOM w0.254: PR252.1 117.73,155.7 117.73,155.7 v1(116.97,155.7) 116.64,156.03 116.64,157 115.75,157.89 v5(115.75,157.91) 115.75,158 PR251.2
PWR_VCCDDC_SENSE_B: length 3.9
  TOP w0.203: v3(115.74,154.35) 115.74,153.9 115.65,153.8 115.65,152.6 115.8,152.45 PU39.40
  TOP w0.254: PR253.1 115.15,154.94 v3(115.74,154.35)
PWR_VCCDDCI_SENSE_A: length 6.3
  TOP w0.254: PR261.2 117.45,139.04 v3(117.84,139.44) 118.5,140.09 119,140.09 PR260.2 119.01,140.08 PC296.1 119.99,140.62 PC295.1 118.63,141.27 PR262.2
PWR_VCCDDCI_SENSE_B: length 4
  TOP w0.203: PU39.23 116.6,145.02
  TOP w0.254: 116.6,145.02 117.35,144.27 v3(117.35,143.71) 117.35,143.45 PR262.1
PWR_VCORE_COMP: length 12.8
  TOP w0.254: PC131.1 207.18,211.15 PC134.1 207.18,213.21 207.14,213.25 207.14,213.36 206.77,213.73 PC133.1 206.77,214.26 207.14,214.63 v3(207.54,214.63) 207.85,214.93 211.48,214.93 212.71,216.17 PR108.1 212.98,215.26 v1(212.93,215.21)
  BOTTOM w0.203: PU6.22 213.1,215.52 212.93,215.34 v1(212.93,215.21)
PWR_VCORE_EN: length 5.5
  TOP w0.254: v1(220.27,217.81) 220.27,216.89 v3(220.24,216.87) 220.55,216.56 221.17,216.56 PR94.2
  BOTTOM w0.203: PU6.9 217.52,218.59 218.47,218.59 218.95,218.11 219.96,218.11 v1(220.27,217.81)
PWR_VCORE_FB: length 14.6
  TOP w0.508: v1(213,213.87) 212.55,213.41 PR103.1 212.5,212.81 PR107.2 211.07,212.81 210.73,212.47 PR105.2 210.38,213.12 v1(210.26,213.23) ; v1(206.25,212.9) 206.25,212.99 205.88,213.36 PC133.2
  L4 w0.508: v1(206.25,212.9) 206.35,212.8 208.58,212.8 209.02,213.23 v1(210.26,213.23)
  BOTTOM w0.203: v1(213,213.87) 213,214.2 213.46,214.66 213.46,215.86 213.5,215.9 PU6.21
  BOTTOM w0.508: v2(210.37,214.04) 210.26,213.93 v1(210.26,213.23) ; PR106.2 213.4,213.47 v1(213,213.87)
PWR_VCORE_FB2: length 16.6
  TOP w0.508: PC131.2 205.33,211.1 v1(205.23,211)
  L4 w0.508: v1(214.05,214.55) 213.84,214.35 213.84,213.77 212.85,212.78 212.39,212.78 210.85,211.23 209.55,211.23 209.17,210.85 209.17,210.82 208.76,210.41 208.76,209.85 208.25,209.35 206.74,209.35 205.23,210.85 v1(205.23,211)
  BOTTOM w0.203: v1(214.05,214.55) 213.79,214.81 213.79,215.7 213.89,215.8 213.89,216.6 PU6.20
  BOTTOM w0.508: v1(205.23,211) 205.23,211.2 v2(205.74,211.71)
PWR_VCORE_FB_A: length 2.8
  TOP w0.508: PR105.1 209.23,212.22 208.17,212.22 PC134.2 208.06,211.42 v3(208.41,211.07)
PWR_VCORE_FB_B: length 2.4
  TOP w0.508: v3(211.52,210.87) 211.52,211.92 PR107.1 211.07,211.92 210.68,211.53 PC138.1
PWR_VCORE_FB_C: length 3.3
  TOP w0.508: PR103.2 212.55,210.87 v1(212.6,210.82)
  BOTTOM w0.508: PC132.1 v2(212.22,211.61) 212.22,211.2 v1(212.6,210.82)
PWR_VCORE_IMON: length 4.5
  TOP w0.254: PC130.1 217.91,216.66 v1(218.49,217.25) 218.11,217.63 PR98.1
  BOTTOM w0.203: PU6.11 218.16,217.81 218.49,217.47 v1(218.49,217.25)
  BOTTOM w0.254: v1(218.49,217.25) 219.17,216.57 v2(219.17,216.27)
PWR_VCORE_ISEN1: length 24.5
  TOP w0.254: v1(207.01,206.93) 206.86,206.78 PR131.1 ; v1(206.35,203.73) 206.35,203.07 206.83,202.59 PR140.1 ; v1(210.85,210.34) 210.97,210.21 PR126.1
  L4 w0.254: v1(216.46,215.11) 216.23,215.34 215.65,215.34 215.62,215.37 215.16,215.37 214.86,215.06 214.86,213.53 212.88,211.56 212.45,211.56 211.23,210.34 v1(210.85,210.34) 208.05,207.54 207.62,207.54 v1(207.01,206.93)
  BOTTOM w0.203: v1(216.46,215.11) 216.43,215.14 216.43,215.31 215.97,215.77 215.97,215.94 215.9,216.01 PU6.15
  BOTTOM w0.254: v1(206.35,203.73) 206.63,204.01 206.63,204.19 207.01,204.57 v5(207.01,205.68) v1(207.01,206.93) ; v1(216.46,215.11) 216.48,215.11 217.78,213.82 PC137.2
PWR_VCORE_ISEN2: length 32.4
  TOP w0.254: PR104.1 218.06,214.45 v1(217.68,214.83) ; 208.08,202.54 208.08,203.17 207.42,203.84 v1(207.16,203.84) ; 208.08,202.54 208.1,202.56 209.83,202.56 210.95,203.68 PR135.1 ; 208.08,202.54 PR141.1 ; PR122.1 v1(207.87,210.24)
  L4 w0.254: v1(217.68,214.83) 216.64,215.87 212.83,215.87 211.61,214.65 211.61,213.82 209.9,212.12 209.18,212.12 207.87,210.81 v1(207.87,210.24)
  BOTTOM w0.203: v1(217.68,214.83) 217.63,214.88 217.42,214.88 216.3,216 PU6.14
  BOTTOM w0.254: v1(217.68,214.83) 218.97,213.54 PC506.2 ; v1(207.87,210.24) v5(207.87,209.12) 208.56,208.43 208.56,205.36 207.9,204.7 207.87,204.7 207.16,203.99 v1(207.16,203.84)
PWR_VCORE_ISEN3: length 34.6
  TOP w0.254: PR102.1 v1(217.73,215.6) ; v1(208.03,207.01) 207.87,206.86 PR132.1 ; v1(210.87,202.36) 210.85,202.36 210.19,201.7 PR144.1 ; v1(206.78,210.24) 206.81,210.21 PR123.1
  L3 w0.254: v1(210.69,207.82) 210.67,207.82 209.93,207.09 209.93,203.2 210.77,202.36 v1(210.87,202.36)
  L4 w0.254: v1(217.73,215.6) 218.21,215.11 218.21,214.61 212.74,209.14 211.25,209.14 210.54,208.43 210.54,207.98 v1(210.69,207.82)
  L6 w0.254: v1(210.69,207.82) 209.88,207.01 v1(208.03,207.01)
  BOTTOM w0.203: PU6.13 216.7,216.14 217.22,215.62 217.7,215.62 v1(217.73,215.6)
  BOTTOM w0.254: v1(208.03,207.01) 207.87,207.01 v2(206.98,207.9) 206.98,209.92 206.78,210.12 v1(206.78,210.24) ; v1(217.73,215.6) 218.57,214.76 v2(218.64,214.76) 218.87,214.53 219.79,214.53 220.14,214.17 PC135.2
PWR_VCORE_ISUMN: length 6.7
  TOP w0.254: v1(215.39,214.83) 215.39,214.77 214.91,214.29 214.91,213.63 PR116.1 215.23,213.08 214.78,213.08 v3(214.2,212.5) 214.2,212.01 214.52,211.7 PC144.1
  BOTTOM w0.203: v1(215.39,214.83) 215.39,214.86 215.29,214.96 215.29,215.69 215.1,215.88 PU6.17
PWR_VCORE_ISUMN_A: length 4.1
  TOP w0.254: PC144.2 216.03,210.68 v3(216.29,210.68) 217.22,211.61 217.57,211.61 218.44,212.47 PR117.1
PWR_VCORE_NTC: length 25.3
  TOP w0.254: v1(205.13,212.85) 205.02,212.97 PR99.2
  L6 w0.254: v1(221.31,214.17) 221.1,214.17 221.05,214.12 219.53,214.12 217.65,212.24 210.16,212.24 210.06,212.34 205.64,212.34 v1(205.13,212.85)
  BOTTOM w0.203: 217.75,216.79 217.5,217.04 PU6.12
  BOTTOM w0.254: 217.75,216.79 219.08,215.46 v2(220.44,215.46) 220.78,215.8 PR97.1 221.45,214.31 v1(221.31,214.17)
PWR_VCORE_NTC_A: length 23.2
  TOP w0.254: PR100.1 222.33,213.63 v1(222.33,214.25) ; v1(204.8,211.99) 204.71,212.08 PR99.1
  L6 w0.254: v1(222.33,214.25) 221.69,213.61 219.74,213.61 217.86,211.73 209.95,211.73 209.85,211.84 204.95,211.84 v1(204.8,211.99)
  BOTTOM w0.254: v5(204.09,212.7) v1(204.8,211.99) ; PR97.2 222.34,214.29 222.33,214.27 v1(222.33,214.25)
PWR_VCORE_PG: length 27.6
  TOP w0.254: R374.2 209.52,225.86 209.98,225.4 v3(210.49,225.4) 210.67,225.4 211.95,226.68 D7.1 214.11,226.68 214.15,226.64 v1(214.5,226.64) ; PR101.2 211.65,213.93 212.32,214.6 v1(212.39,214.6)
  L6 w0.254: v1(212.39,214.6) 212.29,214.71 212.29,215.75 212.83,216.28 215.9,216.28 218.01,218.39 218.01,221.59 216.79,222.81 216.79,224.89 216.03,225.65 215.27,225.65 214.5,226.42 v1(214.5,226.64)
  BOTTOM w0.203: PU6.23 212.7,215.75 212.39,215.44 v1(212.39,214.6)
PWR_VCORE_RTN: length 7.9
  TOP w0.254: 214.05,216.26 214.05,215.6 v1(214.3,215.34) 214.08,215.34 213.51,214.77 213.51,214.33 213.54,214.31 PR114.1 ; 214.05,216.26 v3(214.02,216.28) ; 214.05,216.26 214.07,216.28 214.38,216.28 214.67,215.99 PC141.1
  BOTTOM w0.203: PU6.19 214.3,215.42 214.3,215.42 v1(214.3,215.34)
PWR_VCORE_SVC: length 4.3
  BOTTOM w0.203: PR85.2 220.7,220.17 220.12,220.75 219.38,220.75 219.23,220.6 218.85,220.6 218.84,220.61 PU6.4
PWR_VCORE_SVD: length 4.3
  BOTTOM w0.203: 220.29,219.68 218.74,219.68 218.62,219.81 PU6.6
  BOTTOM w0.254: 220.29,219.68 v2(220.47,219.51) 220.85,219.13 PR87.2
PWR_VCORE_SVT: length 5.7
  TOP w0.254: PR91.2 221.06,217.96 v1(220.42,218.59)
  BOTTOM w0.203: PU6.8 218.45,219.01 218.52,218.93 218.59,218.93 218.94,218.59 v1(220.42,218.59)
  BOTTOM w0.254: v2(221.56,218.14) 220.88,218.14 v1(220.42,218.59)
PWR_VCORE_VDD: length 2.7
  BOTTOM w0.203: PU6.29 209.1,219.01 v1(208.91,218.82)
  vias: v3(207.39,216.08)
PWR_VCORE_VDDIO: length 5.2
  TOP w0.508: PR90.2 221.08,218.97 220.7,219.35 219.94,219.35 v1(219.71,219.13) 219.58,219.13 v3(219,218.54)
  BOTTOM w0.203: PU6.7 218.51,219.41 218.57,219.35 218.64,219.35 218.85,219.15 219.66,219.15 219.68,219.13 v1(219.71,219.13)
PWR_VCORE_VIN: length 1.9
  BOTTOM w0.203: PU6.35 210.87,221.41 210.69,221.59 210.69,222.5 v1(210.79,222.61)
  vias: v3(209.42,223.39)
PWR_VCORE_VRHOT: length 4.1
  TOP w0.254: v1(219.63,220.24) 219.66,220.24 219.71,220.19 v3(220.53,220.19) PR86.2
  BOTTOM w0.203: PU6.5 218.68,220.21 218.74,220.14 219.46,220.14 219.56,220.24 v1(219.63,220.24)
PWR_VCORE_VSEB: length 9.4
  TOP w0.254: PC142.1 215.93,215.99 215.93,214.55 v1(215.44,214.07)
  BOTTOM w0.203: v1(215.44,214.07) 215.19,214.33 215.18,214.33 214.88,214.62 214.88,215.63 214.7,215.81 PU6.18
  BOTTOM w0.254: PR112.1 214.34,210.73 PC132.2 214.29,211.66 PR106.1 214.29,213.68 v2(214.43,213.82) 215.19,213.82 v1(215.44,214.07)
