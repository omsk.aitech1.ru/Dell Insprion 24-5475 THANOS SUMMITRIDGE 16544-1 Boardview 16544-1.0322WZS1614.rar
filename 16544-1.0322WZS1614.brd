# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DN1: length 80.1
  TOP w0.127: v6(188.5,155.5) CPU1.B27 ; DIMM2.32 207.62,92.73 207.5,92.86 207.5,95.18 207.23,95.45 206.43,95.45 v6(206.32,95.57)
  L6 w0.127: v6(206.32,95.57) 206.43,95.45 207.66,95.45 207.9,95.69 207.9,102.59 208.86,103.55 208.86,103.93 208.75,104.05 208.75,104.43 208.86,104.54 208.86,104.93 208.75,105.04 208.75,105.42 208.86,105.53 208.86,105.92 208.75,106.03 208.75,106.41 208.86,106.53 208.86,106.91 208.75,107.02 208.75,107.4 208.86,107.52 208.86,113.46 208.75,113.58 208.75,113.96 208.86,114.07 208.86,114.45 208.75,114.57 208.75,114.95 208.86,115.06 208.86,115.45 208.75,115.56 208.75,115.94 208.86,116.05 208.86,116.44 208.75,116.55 208.75,116.93 208.86,117.05 208.86,117.43 202.37,123.92 202.37,131.37 198.9,134.84 198.9,147.81 191.52,155.19 190.46,155.19 189.15,156.5 188.32,156.5 188.17,156.35 188.17,155.83 v6(188.5,155.5)
M_B_DQS_DN2: length 70.9
  TOP w0.127: CPU1.C32 v6(187.5,150.5) ; DIMM2.53 202.38,98.87 202.25,98.74 202.25,97 201.8,96.56 200.93,96.56 v6(200.71,96.33)
  L6 w0.127: v6(200.71,96.33) 200.92,96.54 201.6,96.54 202.07,97.02 202.07,105.49 203.54,106.96 203.54,114.5 202.95,115.08 202.95,117.97 197.77,123.15 197.77,129.54 194.67,132.64 194.67,145.57 192.06,148.18 192.06,148.61 190.66,150.01 189.05,150.01 188.42,149.38 187.46,149.38 187.17,149.67 187.17,150.17 v6(187.5,150.5)
M_B_DQS_DN3: length 64.8
  TOP w0.127: v6(196.14,94.67) 196.39,94.42 196.65,94.42 197,94.08 197,92.86 197.12,92.73 DIMM2.74 ; v6(189.85,143.96) 189.56,143.66 189.18,143.66 188.7,144.15 188.7,145.7 CPU1.A37
  L6 w0.127: v6(189.85,143.96) 189.64,143.74 189.31,143.73 189.04,143.46 189.04,141.05 190.35,139.73 190.35,129.83 193.07,127.1 193.07,121.89 197.59,117.37 197.59,117.19 197.47,117.07 197.23,117.07 196.95,116.79 196.95,116.25 197.23,115.97 197.92,115.97 198.04,115.85 198.04,115.52 197.92,115.39 197.23,115.39 196.95,115.11 196.95,114.57 197.23,114.3 197.92,114.3 198.04,114.17 198.04,108.87 197.04,107.87 197.04,94.68 196.82,94.46 196.34,94.46 v6(196.14,94.67)
M_B_DQS_DN4: length 63.8
  TOP w0.127: v6(157.5,147.45) 157.55,147.45 CPU1.AM36 ; v6(167.99,95.63) 168.34,95.99 168.94,95.99 169.25,96.3 169.25,98.74 169.37,98.87 DIMM2.177
  L6 w0.089: 158.95,142.76 158.95,142.78 158.92,142.81 158.92,143.4 159.06,143.54 159.06,146.06 158.03,147.09 157.94,147.09 157.86,147.09 v6(157.5,147.45)
  L6 w0.127: v6(167.99,95.63) 168.29,95.93 168.72,95.93 169.15,96.36 169.15,115.33 160.77,123.7 160.77,130.24 159.84,131.17 159.84,138.39 158.6,139.62 158.6,141.7 158.95,142.05 158.95,142.76
M_B_DQS_DN5: length 61.5
  TOP w0.127: DIMM2.198 164.12,92.57 163.87,92.83 163.87,94.07 162.74,95.2 161.77,95.2 v6(161.57,95.4) ; CPU1.AT39 153.69,143.69 153.69,143.08 153.03,142.43 153.03,142.41 v6(152.6,141.98)
  L6 w0.127: v6(161.57,95.4) 161.81,95.16 162.41,95.16 162.78,95.52 162.78,95.9 162.66,96.02 162.66,96.4 162.78,96.51 162.78,96.89 162.66,97.01 162.66,97.39 162.78,97.5 162.78,97.88 162.66,98 162.66,98.38 162.78,98.49 162.78,98.87 162.66,98.99 162.66,99.37 162.78,99.48 162.78,103.99 162.66,104.1 162.66,104.48 162.78,104.6 162.78,104.98 162.66,105.09 162.66,105.47 162.78,105.59 162.78,105.97 162.66,106.08 162.66,106.46 162.78,106.58 162.78,106.96 162.66,107.07 162.66,107.45 162.78,107.57 162.78,114.64 155.02,122.39 155.02,134.8 153.08,136.74 153.08,142.14 152.95,142.27 152.72,142.27 152.6,142.14 v6(152.6,141.98)
M_B_DQS_DN6: length 70.2
  TOP w0.114: v6(151.56,149.48) 151.56,149.44 CPU1.AV34
  TOP w0.127: DIMM2.219 158.87,98.86 158.72,98.71 158.72,97.47 158.19,96.94 157.64,96.94 v6(157.41,96.71)
  L6 w0.127: v6(151.56,149.48) 151.85,149.48 151.94,149.39 151.94,149.19 151.75,149 147.64,149 146.37,147.72 146.37,137.28 149.74,133.91 149.74,131.51 150.68,130.58 150.68,130.2 150.55,130.07 150.01,130.07 149.73,129.79 149.73,129.25 150.01,128.98 150.55,128.98 150.68,128.85 150.68,128.52 150.55,128.39 150.02,128.39 149.75,128.12 149.75,127.58 150.02,127.3 150.55,127.3 150.68,127.17 150.68,120.69 156.31,115.05 156.31,97.36 156.71,96.95 157.17,96.95 v6(157.41,96.71)
M_B_DQS_DN7: length 79.5
  TOP w0.114: CPU1.AU29 v6(153.5,154.5)
  TOP w0.127: DIMM2.240 153.62,92.78 153.49,92.91 153.49,94.3 151.84,95.95 151.34,95.95 v6(151.02,96.27)
  L6 w0.127: v6(151.02,96.27) 151.33,95.96 151.47,95.96 151.59,96.08 151.59,98.72 150.74,99.57 150.74,113.67 150.23,114.17 149.75,114.17 145.56,118.36 145.56,129.16 142.25,132.47 142.25,149.63 147.63,155.01 150.71,155.01 151.24,155.53 152.77,155.53 153.14,155.17 153.11,154.71 153.29,154.51 v6(153.5,154.5)
M_B_DQS_DN8: length 5.8
  TOP w0.127: DIMM2.95 191.87,98.87 191.75,98.74 191.75,97.91 192.45,97.2 192.45,96.22 192.67,96 192.83,96 v6(193.14,96.3)
  BOTTOM w0.127: R119.2 193.03,96.41 v6(193.14,96.3)
M_B_DQS_DP0: length 92.7
  TOP w0.127: CPU1.B22 v6(188.5,161.5) ; DIMM2.13 212.37,99.03 212.5,98.9 212.5,97.63 213.88,96.25 v6(213.88,95.95)
  L6 w0.127: v6(213.88,95.95) 213.88,96.31 213.39,96.81 213.39,99.58 215.37,101.56 215.37,105.06 217.6,107.29 217.6,107.72 217.47,107.84 216.95,107.84 216.68,108.12 216.68,108.66 216.95,108.94 217.47,108.94 217.6,109.06 217.6,114.97 208.82,123.74 208.82,139.22 207.15,140.9 207.15,143.64 206.91,143.87 206.73,143.87 206.14,143.28 205.75,143.28 205.37,143.66 205.37,144.05 205.96,144.64 205.96,144.82 205.72,145.06 205.55,145.06 204.95,144.47 204.56,144.47 204.18,144.85 204.18,145.24 204.76,145.82 204.76,146.02 203.47,147.31 203.47,150.53 193.38,160.62 189.15,160.62 188.87,160.89 188.87,161.13 v6(188.5,161.5)
M_B_DQS_DP1: length 80
  TOP w0.127: v6(187.59,155.5) 187.59,155.64 187.23,156 CPU1.C27 ; DIMM2.34 207.12,92.73 207.25,92.86 207.25,95.08 207.13,95.21 206.93,95.21 206.62,94.9 v6(206.62,94.89)
  L6 w0.127: v6(206.62,94.89) 206.62,95.03 206.79,95.19 207.77,95.19 208.15,95.58 208.15,102.48 209.12,103.45 209.12,117.53 202.62,124.03 202.62,131.48 199.15,134.95 199.15,147.92 191.62,155.45 190.56,155.45 189.25,156.75 188.21,156.75 187.92,156.45 187.92,155.83 v6(187.59,155.5)
M_B_DQS_DP2: length 70.8
  TOP w0.127: DIMM2.55 201.87,98.87 202,98.74 202,97.1 201.7,96.8 200.92,96.8 v6(200.68,97.04) ; v6(186.5,150.5) 186.86,150.5 187,150.36 CPU1.C33
  L6 w0.127: v6(186.5,150.5) 186.92,150.08 186.92,149.56 187.35,149.13 188.53,149.13 189.15,149.75 190.56,149.75 191.8,148.51 191.8,148.08 194.41,145.47 194.41,144.55 194.3,144.44 194.3,144.06 194.41,143.95 194.41,143.56 194.3,143.45 194.3,143.07 194.41,142.95 194.41,142.57 194.3,142.46 194.3,142.08 194.41,141.96 194.41,141.58 194.3,141.47 194.3,141.09 194.41,140.97 194.41,132.54 197.52,129.43 197.52,123.04 202.7,117.86 202.7,114.98 203.28,114.39 203.28,107.06 201.82,105.6 201.82,97.12 201.49,96.8 200.93,96.8 v6(200.68,97.04)
M_B_DQS_DP3: length 64.8
  TOP w0.127: v6(189.86,143.32) 189.68,143.32 189.58,143.42 189.08,143.42 188.46,144.04 188.46,145.73 188.19,146 CPU1.B37 ; v6(196.17,93.96) 196.39,94.18 196.55,94.18 196.75,93.98 196.75,92.86 196.62,92.73 DIMM2.76
  L6 w0.127: v6(196.17,93.96) 196.42,94.21 196.93,94.21 197.3,94.58 197.3,107.76 198.3,108.76 198.3,114.28 198.02,114.55 197.34,114.55 197.21,114.68 197.21,115.01 197.34,115.14 198.02,115.14 198.3,115.41 198.3,115.95 198.02,116.23 197.34,116.23 197.21,116.36 197.21,116.69 197.34,116.81 197.57,116.81 197.85,117.09 197.85,117.48 193.33,122 193.33,127.21 190.61,129.93 190.61,139.83 189.29,141.15 189.29,143.35 189.42,143.48 189.7,143.48 v6(189.86,143.32)
M_B_DQS_DP4: length 63.5
  TOP w0.127: DIMM2.179 168.87,98.87 169,98.74 169,96.4 168.84,96.23 168.33,96.23 v6(168.05,96.51) ; CPU1.AM37 158,146.39 157.82,146.58 157.54,146.58 v6(157.5,146.54)
  L6 w0.089: 158.7,142.76 158.7,142.78 158.73,142.81 158.73,143.48 158.87,143.62 158.87,145.98 157.95,146.9 157.86,146.9 v6(157.5,146.54)
  L6 w0.127: 158.7,142.76 158.7,142.15 158.35,141.81 158.35,139.51 159.58,138.28 159.58,131.07 160.52,130.13 160.52,123.6 168.89,115.22 168.89,106.91 168.78,106.79 168.78,106.41 168.89,106.3 168.89,105.92 168.78,105.8 168.78,105.42 168.89,105.31 168.89,104.93 168.78,104.81 168.78,104.43 168.89,104.32 168.89,103.94 168.78,103.82 168.78,103.44 168.89,103.33 168.89,100.53 168.78,100.42 168.78,100.03 168.89,99.92 168.89,99.54 168.78,99.42 168.78,99.04 168.89,98.93 168.89,98.55 168.78,98.43 168.78,98.05 168.89,97.94 168.89,97.56 168.78,97.44 168.78,97.06 168.89,96.95 168.89,96.46 168.61,96.19 168.37,96.19 v6(168.05,96.51)
M_B_DQS_DP5: length 61.6
  TOP w0.127: v6(152.6,142.81) 153.07,142.81 153.44,143.18 153.44,144.44 CPU1.AT38 ; DIMM2.200 163.62,93.97 162.64,94.96 161.84,94.96 v6(161.57,94.69)
  L6 w0.127: v6(152.6,142.81) 152.6,142.65 152.72,142.52 153.06,142.52 153.33,142.25 153.33,136.85 155.28,134.9 155.28,122.5 163.03,114.75 163.03,95.41 162.52,94.9 161.79,94.9 v6(161.57,94.69)
M_B_DQS_DP6: length 70.2
  TOP w0.114: v6(152.51,149.56) 152.45,149.5 152.45,149.15 152.6,149 CPU1.AU34
  TOP w0.127: DIMM2.221 158.37,98.8 158.48,98.69 158.48,97.57 158.09,97.18 157.62,97.18 v6(157.37,97.42)
  L6 w0.127: v6(157.37,97.42) 157.16,97.21 156.82,97.21 156.56,97.46 156.56,98.01 156.68,98.13 156.68,98.51 156.56,98.62 156.56,99.01 156.68,99.12 156.68,99.5 156.56,99.61 156.56,112.19 156.68,112.3 156.68,112.68 156.56,112.8 156.56,113.18 156.68,113.29 156.68,113.67 156.56,113.79 156.56,114.17 156.68,114.28 156.68,114.66 156.56,114.78 156.56,115.16 150.93,120.79 150.93,127.28 150.65,127.56 150.13,127.56 150,127.68 150,128.01 150.13,128.14 150.65,128.14 150.93,128.42 150.93,128.96 150.65,129.23 150.11,129.23 149.99,129.36 149.99,129.69 150.11,129.82 150.65,129.82 150.93,130.09 150.93,130.68 150,131.61 150,134.01 146.62,137.39 146.62,147.62 147.75,148.74 151.85,148.74 152.19,149.08 152.19,149.41 152.34,149.56 v6(152.51,149.56)
M_B_DQS_DP7: length 79.4
  TOP w0.114: CPU1.AU28 152.55,154.55 v6(152.46,154.55)
  TOP w0.127: v6(151.02,95.44) 151.29,95.71 151.74,95.71 153.25,94.2 153.25,92.85 153.12,92.72 DIMM2.242
  L6 w0.127: v6(152.46,154.55) 152.66,154.54 152.86,154.73 152.88,155.07 152.67,155.28 151.34,155.28 150.82,154.75 147.73,154.75 142.5,149.52 142.5,132.58 145.81,129.27 145.81,118.47 149.85,114.43 150.33,114.43 150.99,113.77 150.99,113.39 151.1,113.28 151.1,112.9 150.99,112.78 150.99,112.4 151.1,112.29 151.1,111.91 150.99,111.79 150.99,111.41 151.1,111.3 151.1,110.92 150.99,110.8 150.99,110.42 151.1,110.31 151.1,109.92 150.99,109.81 150.99,103.64 151.1,103.52 151.1,103.14 150.99,103.03 150.99,102.65 151.1,102.53 151.1,102.15 150.99,102.04 150.99,101.66 151.1,101.54 151.1,101.16 150.99,101.05 150.99,100.67 151.1,100.55 151.1,100.17 150.99,100.06 150.99,99.67 151.84,98.82 151.84,95.97 151.58,95.71 151.29,95.71 v6(151.02,95.44)
M_B_DQS_DP8: length 6.2
  TOP w0.127: v6(193.14,95.45) 192.84,95.75 192.57,95.75 192.21,96.12 192.21,97.1 191.5,97.81 191.5,98.74 191.37,98.87 DIMM2.97
  BOTTOM w0.127: v6(193.14,95.45) 193.12,95.43 192.83,95.43 192.8,95.4 R120.2
M_B_EVENT#: length 151.9
  TOP w0.114: DIMM2.134 182.12,94.26 v6(182.45,94.59) ; CPU1.AA38 v6(169.5,144.5)
  L6 w0.102: v6(182.45,94.59) 182.47,94.57 182.47,93.65 176.83,88.01 153.8,88.01 145.99,95.82 145.99,100.51 144.98,101.52 144.98,112.32 143.56,113.74 143.56,127.29 140.06,130.79 140.06,144.2 138.99,145.27 138.99,152.55 140.54,154.1 141.6,154.1 144.48,156.97 145.49,156.97 147.02,158.5 151.64,158.5 154.05,156.08 156.84,156.08 157.86,155.07 157.86,154.8 157.92,154.74 157.92,154.5 158.58,153.84 159.3,153.84 159.31,153.85 159.65,153.85 159.96,153.54 162.18,153.54 163.09,152.63 163.09,147.96 166.55,144.5 v6(169.5,144.5)
  BOTTOM w0.114: v6(169.5,144.5) 170.06,145.06 v2(170.18,145.06) 171.78,146.66 RN2416.3
M_B_ODT0: length 56.3
  TOP w0.178: CPU1.AF39 164.06,143.94 164.06,140.66 164.25,140.46 v6(164.63,140.46) ; DIMM2.155 174.87,97.01 175.08,96.81 175.45,96.81 v6(175.87,97.23)
  L6 w0.165: v6(164.63,140.46) 165.13,140.46 165.45,140.14 165.45,136.25 169.26,132.44 169.26,122.16 174.8,116.62 174.8,106.4 175.87,105.32 v6(175.87,97.23)
M_B_ODT1: length 55.9
  TOP w0.102: CPU1.AH36 162.4,146.6 162.4,143.77 162.94,143.24 v6(162.94,142.63)
  TOP w0.178: DIMM2.161 173.37,98.18 v6(173.44,98.12)
  L6 w0.165: v6(162.94,142.63) 162.33,142.02 162.33,138.65 163.26,137.72 163.26,135.47 167.1,131.63 167.1,121.01 171.46,116.65 171.46,116.06 172.71,114.82 172.71,101.94 173.44,101.21 v6(173.44,98.12)
M_B_RAS#: length 62.1
  TOP w0.102: v6(164.67,141.72) 165.19,142.24 165.19,142.87 165.33,143.01 165.33,143.64 165.5,143.82 165.5,145.04 166.07,145.61 166.14,145.61 166.38,145.84 166.38,146.62 CPU1.AD36
  TOP w0.178: v6(177.25,94.91) 177.25,94.77 175.62,93.15 DIMM2.152
  L6 w0.165: v6(164.67,141.72) 165.87,140.52 165.87,136.42 169.68,132.61 169.68,122.44 175.23,116.88 175.23,106.56 176.36,105.43 176.36,96.04 177.25,95.15 v6(177.25,94.91)
M_B_WE#: length 59.4
  TOP w0.14: v6(164.62,139.82) 165.41,140.62 165.41,142.78 165.55,142.92 165.55,143.55 CPU1.AD39
  TOP w0.178: v6(175.95,95.76) 175.95,95.73 176.28,95.39 176.59,95.39 176.74,95.55 176.74,95.9 176.37,96.27 176.37,97.44 175.87,97.93 DIMM2.151
  L6 w0.165: v6(175.95,95.76) 175.67,95.76 175.35,96.08 175.35,105.25 174.38,106.22 174.38,115.51 173.19,116.71 173.19,117.58 168.78,121.99 168.78,132.33 165.02,136.09 165.02,139.42 v6(164.62,139.82)
MA_DM0: length 84.4
  TOP w0.114: v1(180.49,164.51) 180,164.02 CPU1.K19 ; DIMM1.12 212.62,108.61 v6(214.33,110.32)
  L3 w0.089: 187.24,163.09 187.05,163.28 184.05,163.28 183.87,163.1 181.27,163.1 181,163.38 181,164 v1(180.49,164.51)
  L3 w0.114: v6(214.33,110.32) 213.33,111.32 213.33,114.55 212.99,114.89 212.99,123.3 211.99,124.3 211.99,124.84 212.1,124.96 212.45,124.96 212.56,125.07 212.56,125.3 212.45,125.41 212.1,125.41 211.99,125.53 211.99,125.76 212.1,125.87 212.38,125.87 212.49,125.98 212.49,126.21 212.38,126.33 212.1,126.33 211.99,126.44 211.99,126.77 210.81,127.95 210.81,131.53 209.46,132.88 209.46,139.26 204.3,144.42 204.3,145.48 203.49,146.28 203.33,146.28 203.17,146.12 203.01,146.12 202.85,146.28 202.85,146.44 203.01,146.61 203.01,146.77 202.85,146.93 202.69,146.93 202.5,146.75 202.34,146.75 202.18,146.91 202.18,147.07 202.36,147.25 202.36,147.41 202.2,147.58 202.04,147.58 201.85,147.39 201.69,147.39 201.53,147.55 201.53,147.71 201.72,147.9 201.72,148.06 201.25,148.52 201.25,153.85 197.15,157.96 197.15,160.01 194.36,162.79 187.54,162.79 187.24,163.09
MA_DM1: length 75.5
  TOP w0.114: v6(181.46,159.54) 181.46,159.54 CPU1.J23 ; v6(206.2,110.8) 206.38,110.8 207.37,111.79 DIMM1.33
  L3 w0.089: v6(181.46,159.54) 181.48,159.54 182.02,159 182.36,159 182.45,158.91 182.45,158.6 182.55,158.49 182.7,158.49 182.8,158.6 182.8,158.91 182.89,159 184.71,159 184.83,159.12 186.18,159.12
  L3 w0.114: v6(206.2,110.8) 206.45,111.05 206.45,111.05 206.72,111.32 206.72,112.77 206.3,113.19 206.3,129.34 199.9,135.73 199.9,138.79 199.79,138.91 199.56,138.91 199.45,138.79 199.45,137.02 199.33,136.91 199.1,136.91 198.99,137.02 198.99,143.41 196.84,145.56 196.84,151.89 193.05,155.68 193.05,157.09 192.18,157.95 187.35,157.95 186.18,159.12
MA_DM2: length 65.6
  TOP w0.114: v6(201.46,109.99) 202.13,109.33 DIMM1.54 ; CPU1.G26 v6(183.5,156.5)
  L3 w0.114: v6(183.5,156.5) 183.91,156.91 185.42,156.91 186.96,155.37 186.96,155.23 187.44,154.75 189.02,154.75 193.57,150.21 193.57,140.29 196.06,137.8 196.06,133.96 202.82,127.2 202.82,126.03 202.71,125.91 202.27,125.91 202.15,125.8 202.15,125.57 202.27,125.45 202.71,125.45 202.82,125.34 202.82,111.35 202.7,111.23 202.7,111.07 202.89,110.88 202.89,110.72 202.73,110.56 202.56,110.56 202.42,110.71 202.26,110.71 202.1,110.54 202.1,110.38 202.78,109.7 202.78,109.54 202.62,109.38 202.45,109.38 201.84,109.99 v6(201.46,109.99)
MA_DM3: length 59.1
  TOP w0.114: CPU1.H30 v6(181.5,152.5) ; DIMM1.75 196.87,114.29 196.87,114.29 197.14,114.03 197.61,114.03 197.88,113.76 197.88,112.65 197.38,112.15 v6(197.09,112.15)
  L3 w0.114: v6(181.5,152.5) 181.5,152.16 181.7,151.96 182.34,151.96 183.3,152.92 184.7,152.92 184.95,152.67 184.95,151.98 184.83,151.87 184.65,151.87 184.54,151.75 184.54,151.52 184.65,151.41 184.83,151.41 184.95,151.3 184.95,149.85 185.36,149.43 185.36,146.69 187.28,144.78 187.28,140.98 187.28,140.98 187.28,140.58 187.96,139.9 187.96,137.81 188.16,137.6 188.16,137.44 187.97,137.25 187.97,137.09 188.14,136.93 188.3,136.93 188.49,137.12 188.65,137.12 188.81,136.95 188.81,136.79 188.62,136.6 188.62,136.44 188.78,136.28 188.94,136.28 189.14,136.47 189.3,136.47 191.1,134.67 191.1,130.16 191.3,129.95 191.3,129.79 191.11,129.6 191.11,129.41 191.25,129.28 191.44,129.28 191.63,129.47 191.79,129.47 191.95,129.31 191.95,129.15 191.64,128.84 191.64,128.65 191.78,128.51 191.97,128.51 192.27,128.82 192.44,128.82 192.6,128.66 192.6,128.5 192.49,128.39 192.49,128.21 192.63,128.07 192.82,128.07 192.92,128.18 193.08,128.18 194.05,127.2 194.05,123.36 196.8,120.61 196.8,112.45 v6(197.09,112.15)
MA_DM4: length 52
  TOP w0.114: v6(160.5,152.46) 160.95,152 CPU1.AJ31 ; v6(170.18,110.01) 169.12,108.95 DIMM1.178
  L3 w0.089: 161.49,148.6 161.96,149.07 161.96,149.77 160.95,150.78 160.95,152 v6(160.5,152.46)
  L3 w0.114: v6(170.18,110.01) 169.6,110.6 169.6,115.24 161.04,123.8 161.04,129.83 161.47,130.27 161.47,136.85 160.77,137.55 160.77,143.58 160.99,143.8 160.99,148.1 161.49,148.6
MA_DM5: length 51.5
  TOP w0.114: DIMM1.199 163.87,113.71 v6(162.26,112.1) ; CPU1.AM31 v6(158.5,152.5)
  L3 w0.089: 154.02,145.69 154.02,146.66 154.47,147.11 154.47,147.65 156.11,149.29 156.11,150.58 156.41,150.88 157.53,150.88 158.05,151.4 158.05,151.65 158.5,152.09 v6(158.5,152.5)
  L3 w0.114: 154.02,145.69 154.02,143.26 153.71,142.95 153.71,140.2 153.44,139.93 153.44,132.83 154.96,131.31 154.96,122.06 162.65,114.38 162.65,112.48 v6(162.26,112.1)
MA_DM6: length 62.3
  TOP w0.114: v6(158.12,109.05) 158.15,109.05 158.53,108.66 158.62,108.57 158.62,107.06 DIMM1.220 ; v6(159.5,154.5) CPU1.AL29
  L3 w0.089: 152.31,149.96 152.76,150.41 152.76,151.22 153.36,151.82 154.33,151.82 155.63,153.12 156.59,153.12 156.9,153.43 156.9,153.46 157.6,154.17 158.74,154.17 159.07,154.5 v6(159.5,154.5)
  L3 w0.114: 152.31,149.96 152,149.64 152,148.83 151.71,148.54 151.71,146.47 149.15,143.91 149.15,135.25 150.15,134.25 150.15,128.5 151.79,126.86 151.79,121.33 158.97,114.15 158.97,108.58 158.26,107.87 157.88,107.87 157.6,108.14 157.6,108.53 v6(158.12,109.05)
MA_DM7: length 72.1
  TOP w0.114: v1(159.5,157.5) CPU1.AL26 ; v6(150.25,110.5) 152.35,112.6 152.35,113.27 153.37,114.29 153.37,114.91 153.38,114.91 DIMM1.241
  L3 w0.114: v6(150.25,110.5) 149.67,111.07 149.67,111.67 147.26,114.08 146.83,114.08 143.1,117.81 143.1,126.3 142.69,126.71 142.69,152.27 148.93,158.51 152.59,158.51 153.18,159.1 157.41,159.1 158.01,158.5 158.01,158.39 158.53,157.87 159.13,157.87 v1(159.5,157.5)
MA_ZV: length 3.7
  TOP w0.114: CPU1.Y34 170.46,149.46 v6(170.46,149.55)
  BOTTOM w0.114: v6(170.46,149.55) 169.6,148.68 v2(169.6,148.54) 169.6,148.18 168.97,147.56 R10.2
MA_ZVSS: length 19.3
  TOP w0.114: R12.2 161.33,129.56 161.42,129.65 v3(161.42,129.74) 161.42,130.15 159.53,132.04 159.53,139.7 159.94,140.11 159.94,140.11 160.53,140.71 160.54,140.71 161.44,141.61 161.44,145.36 161,145.81 CPU1.AJ37
MAA0_0: length 30.7
  TOP w0.13: VRAMA1.H4 v6(102.9,196.4) ; GPU1.U32 79.85,185.85 v6(79.85,186)
  BOTTOM w0.089: 88.79,187.25 88.14,186.6 80.45,186.6 v6(79.85,186)
  BOTTOM w0.13: 88.79,187.25 90.94,189.4 90.94,191.47 93.86,194.39 94.17,194.39 94.26,194.3 101.92,194.3 102.52,194.9 102.52,195.31 102.53,195.31 102.53,195.65 102.52,195.65 102.52,196.02 v6(102.9,196.4)
MAA0_1: length 30.2
  TOP w0.13: v6(81.45,186) 81.45,185.85 GPU1.U34 ; v6(102.95,195.48) 103.3,195.83 VRAMA1.H5
  BOTTOM w0.089: v6(81.45,186) 81.85,186.4 88.52,186.4 88.74,186.62
  BOTTOM w0.13: v6(102.95,195.48) 102.9,195.43 102.9,194.78 102.72,194.6 102.72,194.34 103.02,194.05 103.02,193.87 102.82,193.67 102.64,193.67 102.35,193.97 102.09,193.97 101.92,193.8 94.08,193.8 91.44,191.16 91.44,188.76 91.23,188.56 90.86,188.56 90.66,188.36 90.66,187.98 90.49,187.81 90.11,187.81 89.91,187.61 89.91,187.26 89.7,187.05 89.17,187.05 88.74,186.62
MAA0_2: length 30.5
  TOP w0.13: GPU1.V31 78.6,184.35 v6(79.05,184.8) ; v6(102.91,191.62) 102.91,191.59 VRAMA1.H11
  BOTTOM w0.089: 86.51,185.65 86.26,185.4 79.65,185.4 v6(79.05,184.8)
  BOTTOM w0.13: 86.51,185.65 89.85,185.65 92.44,188.24 92.44,189.9 94.63,192.08 94.63,192.2 95.35,192.92 101.48,192.92 101.68,192.72 101.68,192.17 102.25,191.6 102.89,191.6 v6(102.91,191.62)
MAA0_3: length 29.9
  TOP w0.13: v6(102.9,192.45) 102.9,192.4 VRAMA1.H10 ; GPU1.U35 82.25,185.85 v6(82.25,186)
  BOTTOM w0.089: v6(82.25,186) 82.65,185.6 85.84,185.6 85.85,185.61
  BOTTOM w0.1: 86.26,186.02 85.85,185.61
  BOTTOM w0.13: v6(102.9,192.45) 103.05,192.6 103.05,192.92 102.8,193.17 101.98,193.17 101.85,193.3 95.1,193.3 94.7,192.91 94.56,192.91 94.46,193.01 94.46,193.19 94.36,193.3 94.18,193.3 93.86,192.98 93.86,192.77 94.12,192.51 94.12,192.3 93.96,192.14 93.74,192.14 93.52,192.36 93.34,192.36 93.16,192.17 93.16,191.97 93.35,191.78 93.35,191.59 93.19,191.43 92.95,191.43 92.72,191.66 92.54,191.66 92.36,191.48 92.36,190.75 91.94,190.33 91.94,188.54 89.42,186.02 86.26,186.02
MAA0_4: length 29.5
  TOP w0.13: GPU1.V36 82.6,184.35 v6(83.05,184.8) ; VRAMA1.K11 v6(101.3,191.6)
  BOTTOM w0.13: v6(101.3,191.6) 100.82,192.08 96.39,192.08 96.33,192.02 96.33,192.02 96.08,191.77 96.08,191.77 96.08,191.76 96.08,191.16 95.86,190.94 95.04,190.94 94.82,190.72 94.82,190.1 95.12,189.8 95.12,188.49 94.97,188.35 94.52,188.35 94.36,188.19 94.36,187.22 94.14,186.99 93.98,186.99 93.59,187.38 93.4,187.38 93.21,187.19 93.21,187.01 93.58,186.64 93.58,186.46 93.39,186.27 93.2,186.27 92.69,186.78 92.5,186.78 92.32,186.6 92.32,186.4 92.83,185.89 92.83,185.71 92.64,185.52 92.45,185.52 92.09,185.88 91.9,185.88 91.71,185.69 91.71,185.51 91.83,185.39 91.83,185.25 91.71,185.13 90.6,185.13 90.43,184.95 88.19,184.95 87.62,184.38 87.18,184.38 87.17,184.38 84.02,184.38 84.02,184.38 83.47,184.38 v6(83.05,184.8)
MAA0_5: length 30
  TOP w0.13: v6(80.65,184.8) 80.2,184.35 GPU1.V33 ; v6(101.25,192.44) 101.69,192 VRAMA1.K10
  BOTTOM w0.089: 87.58,185.2 81.05,185.2 v6(80.65,184.8)
  BOTTOM w0.13: v6(101.25,192.44) 95.47,192.44 94.93,191.9 94.93,191.68 93.12,189.87 93.12,189.71 93.22,189.61 94.09,189.61 94.32,189.38 94.32,189.21 94.19,189.08 93.1,189.08 92.97,188.95 92.97,188.68 93.1,188.55 93.73,188.55 93.86,188.42 93.86,188.15 93.73,188.02 93.07,188.02 92.79,187.73 92.74,187.73 90.26,185.25 87.63,185.25 87.58,185.2
MAA0_6: length 29.8
  TOP w0.13: v6(80.65,187.2) 80.2,186.75 GPU1.R33 ; VRAMA1.K5 101.24,195.54 v6(101.22,195.54)
  BOTTOM w0.089: v6(80.65,187.2) 80.65,187.57 80.88,187.8 87.28,187.8 87.54,188.07
  BOTTOM w0.13: 87.54,188.07 87.81,188.34 87.81,188.91 88.88,189.97 88.88,191.44 89.33,191.89 89.33,192.27 90.84,193.78 90.84,194.14 92.22,195.52 92.75,195.52 92.88,195.65 92.88,196.15 94.19,197.46 94.4,197.46 94.56,197.3 94.56,196.36 95.46,195.46 101.14,195.46 v6(101.22,195.54)
MAA0_7: length 29.8
  TOP w0.13: VRAMA1.K4 v6(102.1,196.4) ; GPU1.R35 82.25,187.05 v6(82.25,187.2)
  BOTTOM w0.089: 87.58,187.66 87.53,187.61 86.76,187.61 86.76,187.61 86.44,187.61 86.44,187.61 82.66,187.61 v6(82.25,187.2)
  BOTTOM w0.13: 87.58,187.66 89.94,190.02 89.94,192 91.34,193.4 91.34,193.91 91.63,194.2 92.2,194.2 92.33,194.33 92.33,194.88 92.46,195.01 92.64,195.01 92.75,194.9 92.96,194.9 93.51,195.45 93.51,195.66 93.38,195.79 93.38,196.18 93.5,196.29 94.08,196.29 94.18,196.19 94.18,196.06 95.15,195.1 101.42,195.1 101.65,195.33 101.65,195.82 101.5,195.97 101.5,196.6 101.63,196.73 101.78,196.73 v6(102.1,196.4)
MAA0_8: length 30.3
  TOP w0.13: VRAMA1.J5 v6(102.1,195.6) ; GPU1.U31 78.6,185.55 78.98,185.93 79.06,185.93 v6(79.07,185.94)
  BOTTOM w0.089: 87.87,187.13 87.55,186.8 79.93,186.8 79.07,185.94
  BOTTOM w0.1: 79.07,185.94 v6(79.07,185.94)
  BOTTOM w0.13: v6(102.1,195.6) 102.1,195.06 101.76,194.72 94.88,194.72 94.58,195.02 93.78,195.02 92.4,193.64 92.12,193.64 91.98,193.5 91.98,193.22 90.36,191.6 90.36,189.61 87.87,187.13
MAA1_0: length 38.3
  TOP w0.13: v6(80.8,193.05) 80.35,192.6 GPU1.H33 ; v6(90.91,220.91) 91.3,221.3 VRAMA2.K4
  BOTTOM w0.089: v6(80.8,193.05) 81.2,193.45 81.2,196.62 81.14,196.68 81.14,198.36 81.2,198.42
  BOTTOM w0.13: v6(90.91,220.91) 90.91,220.9 90.9,220.9 90.58,220.58 89.58,220.58 88.62,219.62 88.62,210.61 85.92,207.91 85.92,207.68 86.28,207.32 86.28,207.13 86.05,206.91 85.87,206.91 85.48,207.3 85.3,207.3 85.11,207.11 85.11,206.92 85.5,206.53 85.5,206.35 85.31,206.16 85.12,206.16 84.94,206.34 84.76,206.34 84.58,206.16 84.58,205.95 84.89,205.65 84.89,205.46 84.7,205.27 84.51,205.27 83.98,205.8 83.8,205.8 83.61,205.61 83.61,205.42 84.28,204.75 84.28,204.4 81.2,201.32 81.2,198.42
MAA1_1: length 38
  TOP w0.13: VRAMA2.K5 90.24,221.04 v6(90,221.04) ; GPU1.M32 v6(79.7,189.7)
  BOTTOM w0.089: v6(79.7,189.7) 80.15,190.15 80.15,191.5 80.39,191.74 80.39,196.75
  BOTTOM w0.1: 80.39,196.75 80.7,197.06
  BOTTOM w0.13: v6(90,221.04) 90,221.04 89.77,220.81 89.04,220.81 88.26,220.03 88.26,212.66 88.12,212.52 88.12,210.83 84.14,206.85 84.14,206.56 83.9,206.32 83.62,206.32 82.96,205.67 82.96,205.36 83.54,204.78 83.54,204.28 80.7,201.44 80.7,197.06
MAA1_2: length 38.1
  TOP w0.13: v6(79.6,192.25) 79.45,192.25 GPU1.J32 ; VRAMA2.K11 86.1,220.9 v6(86.11,220.9)
  BOTTOM w0.089: 79.7,198.6 79.7,197.39 80,197.09 80,195.72 80,194.82 80,194.02 80,193.22 80,192.65 v6(79.6,192.25)
  BOTTOM w0.13: v6(86.11,220.9) 86.11,220.85 86.1,220.84 86.1,220.26 86.65,219.71 87.32,219.71 87.46,219.57 87.46,213.3 86.77,212.61 86.77,212.47 87.12,212.12 87.12,211.68 86.99,211.55 86.81,211.55 86.04,212.32 85.83,212.32 85.65,212.14 85.65,211.91 86.6,210.96 86.6,210.72 80.35,204.47 80.35,204 80.64,203.71 80.87,203.48 80.88,203.48 80.88,203.07 79.49,201.67 79.49,201.22 79.7,201.01 79.7,200.6 79.49,200.39 79.49,198.81 79.7,198.6
MAA1_3: length 38.3
  TOP w0.13: v6(87,220.93) 86.87,220.93 VRAMA2.K10 ; v6(79.6,191.45) 79.45,191.45 GPU1.K32
  BOTTOM w0.089: v6(79.6,191.45) 80.2,192.05 80.2,196.66 80.19,196.67 80.19,196.83 80.2,196.84 80.2,197.38
  BOTTOM w0.13: 80.2,197.38 80.2,198.49 79.79,198.9 79.79,199.22 79.78,199.23 79.78,199.57 79.79,199.58 79.79,199.85 80.2,200.27 80.2,201.68 82,203.48 82,203.7 81.24,204.46 81.24,204.66 81.43,204.84 81.61,204.84 82.41,204.04 82.59,204.04 82.84,204.29 82.84,204.58 82.22,205.2 82.22,205.63 87.23,210.64 87.23,210.83 87.5,211.1 87.62,211.22 87.62,212.67 87.84,212.89 87.84,220.58 87.49,220.93 v6(87,220.93)
MAA1_4: length 38.2
  TOP w0.13: v6(78.4,191.45) 78.25,191.45 GPU1.K30 ; VRAMA2.H11 v6(86.1,219.3)
  BOTTOM w0.089: v6(78.4,191.45) 79,192.05 79,198 78.49,198.51
  BOTTOM w0.13: v6(86.1,219.3) 86.68,218.72 86.68,214.35 86.38,214.05 85.88,214.05 85.72,213.9 85.49,213.9 85.35,214.04 85.16,214.04 84.97,213.85 84.97,213.66 85.11,213.52 85.11,213.29 84.93,213.1 83.41,213.1 83.31,213 83.31,212.76 83.56,212.52 84.34,212.52 84.5,212.36 84.5,210.04 83.16,208.7 82.98,208.7 82.7,208.98 82.5,208.98 82.35,208.83 82.35,208.58 82.6,208.33 82.6,208.14 82.41,207.95 82.23,207.95 82,208.18 81.81,208.18 78.49,204.85 78.49,198.51
MAA1_5: length 38.3
  TOP w0.13: v6(78.4,190.65) 78.25,190.65 GPU1.L30 ; v6(87.01,219.17) 87.01,219.19 VRAMA2.H10
  BOTTOM w0.089: v6(78.4,190.65) 79.2,191.45 79.2,198.38
  BOTTOM w0.13: v6(87.01,219.17) 87.06,219.12 87.06,213.61 86.33,212.87 85.66,212.87 85.05,212.27 85.05,211.37 85.56,210.86 85.56,210.39 82.39,207.22 82.21,207.22 81.97,207.45 81.79,207.45 81.6,207.26 81.6,207.08 81.83,206.84 81.83,206.66 81.64,206.47 81.46,206.47 81.22,206.7 81.04,206.7 80.85,206.51 80.85,206.33 81.08,206.09 81.08,205.91 80.89,205.72 80.71,205.72 80.48,205.95 80.29,205.95 80.1,205.76 80.1,205.58 80.33,205.34 80.33,205.16 80.14,204.97 79.96,204.97 79.73,205.2 79.54,205.2 79.35,205.01 79.35,203.87 79.84,203.38 79.84,202.84 78.99,201.99 78.99,198.59 79.2,198.38
MAA1_6: length 37.8
  TOP w0.13: GPU1.H35 81.55,192.6 v6(82,193.05) ; v6(90,219.24) 90.46,219.7 VRAMA2.H5
  BOTTOM w0.089: v6(82,193.05) 82,193.24 82.42,193.65 82.42,196.27
  BOTTOM w0.13: 82.42,196.27 82.78,196.64 82.78,200.7 88.58,206.5 88.58,207.32 91.18,209.91 91.18,210.09 90.67,210.6 90.67,210.81 90.85,210.99 91.03,210.99 91.51,210.5 91.7,210.5 91.88,210.69 91.88,210.89 91.37,211.4 91.37,211.59 91.56,211.78 91.74,211.78 92.28,211.24 92.51,211.24 92.92,211.65 92.92,211.98 92.28,212.62 92.08,212.83 90.36,212.83 89.98,213.2 89.98,219.22 v6(90,219.24)
MAA1_7: length 39.3
  TOP w0.13: v6(90.91,220.1) 91.3,219.71 VRAMA2.H4 ; v6(80.7,190.7) GPU1.L33
  BOTTOM w0.089: 81.88,198.08 81.53,197.73 81.53,196.84 81.59,196.78 81.59,191.09 81.2,190.7 v6(80.7,190.7)
  BOTTOM w0.13: 81.88,198.08 82.28,198.48 82.28,200.9 87.91,206.53 87.91,207.35 90.17,209.61 90.17,210.03 90.04,210.16 89.81,210.16 89.68,210.29 89.68,210.56 89.81,210.69 90.04,210.69 90.17,210.82 90.17,211.14 90.04,211.27 89.81,211.27 89.7,211.38 89.7,211.68 89.83,211.81 90.84,211.81 91.03,212.01 91.03,212.24 90.93,212.34 89.83,212.34 89.7,212.47 89.7,212.76 89.56,212.9 89.56,219.44 89.8,219.68 90.5,219.68 90.91,220.09 90.91,220.09 v6(90.91,220.1)
MAA1_8: length 37.6
  TOP w0.13: VRAMA2.J5 90.14,220.14 v6(90,220.14) ; v6(80.8,192.25) 80.35,191.8 GPU1.J33
  BOTTOM w0.1: v6(80.8,192.25) 81.4,192.85 81.4,196.7 81.33,196.76 81.33,198.13 81.78,198.58
  BOTTOM w0.13: v6(90,220.14) 89.66,220.14 89.06,219.54 89.06,212.62 89.18,212.5 89.18,210.05 89.45,209.78 89.45,209.6 89.08,209.22 88.89,209.22 88.51,209.61 88.33,209.61 88.13,209.41 88.13,209.23 88.52,208.85 88.52,208.66 88.33,208.47 88.14,208.47 87.76,208.86 87.58,208.86 87.38,208.66 87.38,208.48 87.77,208.1 87.77,207.91 87.58,207.72 87.39,207.72 87.01,208.11 86.83,208.11 86.64,207.92 86.64,207.73 87.02,207.35 87.02,207.17 85.98,206.12 85.98,205.7 85.14,204.86 85.14,204.47 81.78,201.11 81.78,198.58
MAB0_0: length 35.8
  TOP w0.13: v6(71.2,193.05) 71.05,193.05 GPU1.H23 ; VRAMB1.H4 67.2,221.3 v6(67.6,220.9)
  BOTTOM w0.089: v6(71.2,193.05) 70.75,193.5 70.75,205.09
  BOTTOM w0.13: v6(67.6,220.9) 67.75,220.75 68.08,220.75 68.29,220.55 69.07,220.55 69.7,219.92 69.7,211.53 69.83,211.4 69.97,211.4 70.1,211.27 70.1,211 69.97,210.87 69.57,210.87 69.44,210.74 69.44,210.47 69.57,210.34 69.97,210.34 70.1,210.21 70.1,209.94 69.97,209.81 69.57,209.81 69.44,209.68 69.44,209.41 69.57,209.28 69.97,209.28 70.1,209.15 70.1,208.88 69.97,208.75 69.57,208.75 69.44,208.62 69.44,208.35 69.57,208.22 69.97,208.22 70.1,208.09 70.1,207.82 69.98,207.7 69.28,207.7 69.03,207.45 69.03,206.82 70.75,205.09
MAB0_1: length 35.4
  TOP w0.13: v6(68.46,220.97) 68.36,220.97 VRAMB1.H5 ; GPU1.N24 72.25,189.05 v6(72.4,189.05)
  BOTTOM w0.089: v6(72.4,189.05) 71.6,189.85 71.6,197.64 71.25,197.99
  BOTTOM w0.13: 71.25,197.99 71.25,205.38 70.69,205.94 70.69,205.95 70.59,206.06 70.59,211.73 70.06,212.26 70.06,220.07 69.16,220.97 v6(68.46,220.97)
MAB0_2: length 36.7
  TOP w0.13: GPU1.K24 72.25,191.45 v6(72.4,191.45) ; v6(72.4,220.9) 72.4,220.93 VRAMB1.H11
  BOTTOM w0.089: 72.15,195.57 72.15,195.17 72,195.03 72,191.85 v6(72.4,191.45)
  BOTTOM w0.13: 72.15,195.57 72.15,195.57 72.15,199.62 72.29,199.76 72.29,208.64 72.24,208.69 72.24,209.3 72.14,209.4 71.72,209.4 71.62,209.5 71.62,209.8 71.72,209.91 72.2,209.91 72.3,210.01 72.3,210.3 72.17,210.43 71.73,210.43 71.6,210.56 71.6,210.83 71.73,210.96 72.25,210.96 72.38,211.09 72.38,211.43 72.27,211.53 71.66,211.53 71.55,211.63 71.55,211.99 71.66,212.09 72.07,212.09 72.17,212.19 72.17,212.5 72.07,212.6 71.6,212.6 70.74,213.46 70.74,219.26 71.17,219.69 72.17,219.69 72.4,219.92 v6(72.4,220.9)
MAB0_3: length 36
  TOP w0.13: GPU1.M24 72.25,189.85 v6(72.4,189.85) ; v6(71.56,220.97) 71.64,220.97 VRAMB1.H10
  BOTTOM w0.089: 71.8,198.02 71.8,190.45 v6(72.4,189.85)
  BOTTOM w0.13: v6(71.56,220.97) 70.43,219.84 70.43,212.87 71.1,212.2 71.1,210.2 71.15,210.16 71.15,208.89 71.8,208.23 71.8,207.85 71.7,207.75 71.25,207.75 71.12,207.62 71.12,207.34 71.25,207.21 71.7,207.21 71.8,207.11 71.8,206.76 71.7,206.65 71.22,206.65 71.1,206.53 71.1,206.24 71.22,206.12 71.7,206.12 71.8,206.02 71.8,198.02
MAB0_4: length 35.6
  TOP w0.13: v6(73.6,190.65) 73.45,190.65 GPU1.L25 ; VRAMB1.K11 72.4,219.33 v6(72.4,219.3)
  BOTTOM w0.089: v6(73.6,190.65) 73,191.25 73,197.16
  BOTTOM w0.13: 73,197.16 73,198.62 73.5,199.12 73.5,199.66 73.3,199.86 73.3,208.59 74.68,209.97 74.68,210.71 74.55,210.84 74.25,210.84 74.12,210.97 74.12,211.24 74.25,211.37 74.55,211.37 74.68,211.5 74.68,211.77 74.55,211.9 74.25,211.9 74.12,212.03 74.12,212.3 74.25,212.43 74.58,212.43 74.93,212.78 74.93,212.95 74.76,213.13 73.72,213.13 73.43,213.41 73.43,213.87 73.23,214.07 72.2,214.07 71.83,214.45 71.83,218.72 v6(72.4,219.3)
MAB0_5: length 36.2
  TOP w0.13: v6(71.56,219.25) 71.56,219.29 VRAMB1.K10 ; GPU1.M25 73.45,189.85 v6(73.6,189.85)
  BOTTOM w0.089: 72.67,195.95 72.8,195.82 72.8,190.65 v6(73.6,189.85)
  BOTTOM w0.13: 72.67,195.95 72.46,196.16 72.46,199.6 72.8,199.94 72.8,209.7 72.9,209.8 73.52,209.8 73.62,209.91 73.62,210.35 73.49,210.48 72.99,210.48 72.86,210.61 72.86,210.84 73.03,211.01 73.49,211.01 73.62,211.14 73.62,211.41 73.49,211.54 72.99,211.54 72.86,211.67 72.86,211.9 73.03,212.07 73.49,212.07 73.62,212.2 73.62,212.48 73.38,212.72 72.33,212.72 71.3,213.75 71.3,218.99 v6(71.56,219.25)
MAB0_6: length 35.6
  TOP w0.13: GPU1.N23 71.05,189.05 v6(71.2,189.05) ; VRAMB1.K5 68.1,219.63 68.1,219.63 68.46,219.27 v6(68.46,219.22)
  BOTTOM w0.13: v6(68.46,219.22) 68.46,213.29 67.87,212.7 67.34,212.7 66.88,212.24 66.88,211.58 67.16,211.3 67.16,210.83 66.75,210.42 66.75,206.84 68.92,204.67 68.92,203.94 68.92,203.94 68.92,198.09 69.25,197.75 69.25,191.77 69.46,191.56 69.46,191.38 69.26,191.18 69.26,190.94 69.4,190.8 69.63,190.8 69.83,191 70.02,191 70.75,190.27 70.75,189.5 v6(71.2,189.05)
MAB0_7: length 35.5
  TOP w0.13: v6(71.2,190.65) 71.05,190.65 GPU1.L23 ; v6(67.6,220.1) 67.57,220.1 VRAMB1.K4
  BOTTOM w0.13: v6(67.6,220.1) 68.02,219.68 68.64,219.68 68.9,219.42 68.9,213.41 68.7,213.21 68.7,212.79 67.9,211.99 67.9,210.13 67.77,210 67.51,210 67.38,209.87 67.38,209.58 67.51,209.45 67.77,209.45 67.9,209.32 67.9,209.05 67.77,208.92 67.51,208.92 67.38,208.79 67.38,208.34 67.9,207.82 67.9,207.56 67.77,207.43 67.53,207.43 67.4,207.3 67.4,207.03 67.53,206.9 67.77,206.9 67.9,206.77 67.9,206.39 69.54,204.75 69.54,198.22 69.75,198.01 69.75,192.1 v6(71.2,190.65)
MAB0_8: length 34.6
  TOP w0.13: v6(68.46,220.12) 68.41,220.12 VRAMB1.J5 ; GPU1.K23 71.05,191.45 v6(71.2,191.45)
  BOTTOM w0.13: v6(68.46,220.12) 68.93,220.12 69.31,219.74 69.31,212.52 68.4,211.61 68.4,211.02 68.53,210.89 68.81,210.89 68.94,210.76 68.94,210.49 68.81,210.36 68.53,210.36 68.4,210.23 68.4,209.96 68.53,209.83 68.81,209.83 68.94,209.7 68.94,209.43 68.81,209.3 68.53,209.3 68.4,209.17 68.4,208.9 68.53,208.77 68.81,208.77 68.94,208.64 68.94,208.37 68.81,208.24 68.53,208.24 68.4,208.11 68.4,206.6 70.25,204.75 70.25,192.4 71.2,191.45 v6(71.2,191.45)
MAB1_0: length 41.5
  TOP w0.13: VRAMB2.K4 v6(53.9,220.9) ; GPU1.N18 v6(65.2,189.05)
  BOTTOM w0.089: 64.04,199.78 64.04,195.24 64.4,194.87 64.4,191.03 64.86,189.39 v6(65.2,189.05)
  BOTTOM w0.13: 64.04,199.78 58.3,205.52 58.3,208.02 56.8,209.52 54.68,209.52 54.21,209.99 54.17,209.99 51.62,212.54 51.62,219.62 52.58,220.58 53.58,220.58 v6(53.9,220.9)
MAB1_1: length 38.6
  TOP w0.13: VRAMB2.K5 53.26,221.3 v6(53,221.04) ; v6(64,191.45) 64.15,191.45 GPU1.K17
  BOTTOM w0.089: v6(64,191.45) 63.6,191.85 63.6,198.62 62.96,199.26
  BOTTOM w0.13: 62.96,199.26 62.96,200.15 57.8,205.31 57.8,207.61 56.39,209.02 54.34,209.02 51.12,212.24 51.12,213.23 51.26,213.37 51.26,219.82 52.48,221.04 v6(53,221.04)
MAB1_2: length 41
  TOP w0.13: v6(49.13,220.9) 49.1,220.9 VRAMB2.K11 ; v6(64,189.05) 64.15,189.05 GPU1.N17
  BOTTOM w0.089: 62.94,196.16 63.2,195.9 63.2,189.85 v6(64,189.05)
  BOTTOM w0.13: v6(49.13,220.9) 49.1,220.87 49.1,220.3 49.7,219.7 50.2,219.7 50.46,219.44 50.46,213.89 50.12,213.55 50.12,211.67 53.97,207.82 55.68,207.82 56.44,207.06 56.63,206.87 56.63,205.07 61.94,199.76 61.94,199.32 62.94,198.32 62.94,196.16
MAB1_3: length 39.7
  TOP w0.13: GPU1.M17 64.15,189.85 v6(64,189.85) ; v6(49.96,220.87) 49.95,220.88 49.95,220.89 49.54,221.3 VRAMB2.K10
  BOTTOM w0.089: v6(64,189.85) 63.4,190.45 63.4,198.36 63.09,198.67
  BOTTOM w0.13: v6(49.96,220.87) 49.98,220.84 50,220.84 50.42,220.42 50.42,219.95 50.84,219.53 50.84,213.65 50.62,213.43 50.62,211.88 54.04,208.46 56.24,208.46 57.3,207.4 57.3,205.1 62.46,199.94 62.46,199.3 63.09,198.67
MAB1_4: length 38.4
  TOP w0.13: v6(62.8,190.65) 62.95,190.65 GPU1.L15 ; VRAMB2.H11 v6(49.1,219.3)
  BOTTOM w0.089: 62.02,198.28 62.2,198.1 62.2,191.25 v6(62.8,190.65)
  BOTTOM w0.13: v6(49.1,219.3) 49.68,218.72 49.68,214.39 49.36,214.08 48.38,214.08 48.03,213.72 48.03,213.46 48.16,213.33 48.4,213.33 48.53,213.2 48.53,212.93 48.4,212.8 48.16,212.8 48.03,212.67 48.03,212.17 49.63,210.57 49.63,210.56 59.6,200.59 59.71,200.59 62.02,198.28
MAB1_5: length 37.4
  TOP w0.13: VRAMB2.H10 v6(49.94,219.26) ; GPU1.J15 62.95,192.25 v6(62.8,192.25)
  BOTTOM w0.089: 62.4,198.23 62.4,192.65 v6(62.8,192.25)
  BOTTOM w0.13: v6(49.94,219.26) 49.98,219.22 49.98,214.01 49.7,213.73 49.7,213.33 49.43,213.06 49.43,211.63 53.74,207.32 55.38,207.32 55.52,207.18 55.52,207 54.88,206.35 54.88,206.11 55.1,205.89 55.28,205.89 55.81,206.42 56,206.42 56.13,206.3 56.13,205.99 55.66,205.52 55.66,205.33 61.57,199.42 61.57,199.21 62.4,198.38 62.4,198.23
MAB1_6: length 40.1
  TOP w0.13: VRAMB2.H5 53.46,219.7 v6(53,219.24) ; v6(66.32,188.21) 66.34,188.19 66.61,188.19 GPU1.P19
  BOTTOM w0.089: 65.26,198.02 65.61,197.67 65.61,189.04 65.66,188.99 65.66,188.72 66.17,188.21 v6(66.32,188.21)
  BOTTOM w0.13: v6(53,219.24) 52.98,219.22 52.98,213.25 54.53,211.7 56.93,211.7 57.71,211.7 59.8,209.61 59.8,206.14 65.26,200.68 65.26,198.02
MAB1_7: length 39.4
  TOP w0.13: VRAMB2.H4 v6(53.9,220.1) ; v6(65.2,191.45) 65.35,191.45 GPU1.K18
  BOTTOM w0.089: v6(65.2,191.45) 64.8,191.85 64.8,197.64
  BOTTOM w0.13: 64.8,197.64 64.8,200.43 59.3,205.93 59.3,209.3 59.14,209.46 58.96,209.46 58.83,209.33 58.65,209.33 58.45,209.52 58.45,209.7 58.63,209.88 58.63,210.07 58.44,210.26 58.26,210.26 58.08,210.08 57.9,210.08 57.7,210.27 57.7,210.45 57.88,210.63 57.88,210.85 57.73,211 54.59,211 52.56,213.03 52.56,219.44 52.8,219.68 53.48,219.68 v6(53.9,220.1)
MAB1_8: length 38.3
  TOP w0.13: v6(53,220.14) 53.36,220.5 VRAMB2.J5 ; GPU1.L18 65.35,190.65 v6(65.2,190.65)
  BOTTOM w0.089: 64.38,195.47 64.6,195.25 64.6,191.25 v6(65.2,190.65)
  BOTTOM w0.13: v6(53,220.14) 52.66,220.14 52.08,219.56 52.08,212.8 54.68,210.2 57.02,210.2 58.8,208.42 58.8,205.72 64.38,200.14 64.38,195.47
MAC0_0: length 41.6
  TOP w0.13: GPU1.V13 60.95,184.65 v6(60.95,184.8) ; VRAMC1.H4 v6(29.1,196.1)
  BOTTOM w0.089: v6(60.95,184.8) 60.15,185.6 54.04,185.6 53.91,185.73
  BOTTOM w0.13: 53.91,185.73 53.68,185.96 50.22,185.96 44.48,191.7 41.98,191.7 41.06,192.62 40.18,193.51 40.18,195.67 37.46,198.38 30.38,198.38 29.42,197.42 29.42,196.42 v6(29.1,196.1)
MAC0_1: length 38.7
  TOP w0.13: v6(58.55,186) 58.55,185.85 GPU1.U10 ; VRAMC1.H5 28.7,196.74 v6(28.96,197)
  BOTTOM w0.089: 54.15,186.23 54.32,186.4 58.15,186.4 v6(58.55,186)
  BOTTOM w0.13: v6(28.96,197) 28.96,197.52 30.18,198.74 36.63,198.74 36.77,198.88 37.76,198.88 40.75,195.89 40.75,193.84 42.39,192.2 44.69,192.2 49.74,187.15 50.65,187.15 50.65,187.15 51.57,186.23 54.15,186.23
MAC0_2: length 41.3
  TOP w0.13: GPU1.U13 60.95,185.85 v6(60.95,186) ; v6(29.09,200.9) 29.09,200.91 VRAMC1.H11
  BOTTOM w0.089: 53.22,186.88 53.3,186.8 60.15,186.8 v6(60.95,186) ; 30.4,199.54 30.3,199.63 30.3,200.46 29.86,200.9 v6(29.09,200.9)
  BOTTOM w0.13: 53.22,186.88 53.04,187.06 51.65,187.06 50.81,187.89 50.41,187.89 45,193.31 42.87,193.31 42.14,194.04 41.98,194.2 41.98,195.1 41.85,195.22 41.85,196.36 38.33,199.88 36.45,199.88 36.11,199.54 30.4,199.54
MAC0_3: length 39.8
  TOP w0.13: v6(29.1,200.03) 29.1,200.1 VRAMC1.H10 ; GPU1.U12 60.15,185.85 v6(60.15,186)
  BOTTOM w0.089: v6(60.15,186) 59.55,186.6 53.02,186.6
  BOTTOM w0.13: 53.02,186.6 53.02,186.6 51.61,186.6 50.67,187.54 50.06,187.54 44.9,192.7 42.6,192.7 41.34,193.96 41.34,196.16 38.12,199.38 36.57,199.38 36.35,199.16 30.3,199.16 29.9,199.57 29.56,199.57 v6(29.1,200.03)
MAC0_4: length 38.8
  TOP w0.13: v6(30.7,200.9) VRAMC1.K11 ; GPU1.R11 59.35,187.05 v6(59.35,187.2)
  BOTTOM w0.089: v6(59.35,187.2) 58.75,187.8 51.9,187.8 51.72,187.98
  BOTTOM w0.13: 51.72,187.98 49.66,190.04 49.66,190.15 39.49,200.32 39.48,200.32 37.78,202.02 37.57,202.02 37.41,201.86 37.41,201.4 37.28,201.27 37.11,201.27 36.88,201.51 36.88,201.87 36.73,202.02 36.3,202.02 35.93,201.65 35.93,200.64 35.62,200.33 31.27,200.33 v6(30.7,200.9)
MAC0_5: length 38.3
  TOP w0.13: v6(57.75,187.2) 58.2,186.75 GPU1.R9 ; v6(30.74,200.06) VRAMC1.K10
  BOTTOM w0.089: 51.49,187.73 51.62,187.6 57.4,187.6 57.75,187.25 v6(57.75,187.2)
  BOTTOM w0.13: v6(30.74,200.06) 30.81,200 35.96,200 36.29,200.32 37.41,200.32 37.59,200.51 38.43,200.51 42.35,196.59 42.35,195.67 42.5,195.53 42.68,195.53 42.99,195.84 43.17,195.84 43.38,195.64 43.38,195.38 42.72,194.73 42.72,194.55 42.91,194.36 43.1,194.36 43.71,194.97 44.04,194.97 44.23,194.78 44.23,194.62 43.84,194.23 43.84,194.09 44.05,193.88 44.23,193.88 44.6,194.24 44.77,194.24 50.58,188.43 50.79,188.43 51.49,187.73
MAC0_6: length 40
  TOP w0.13: v6(61.73,183.6) 61.73,183.47 GPU1.W14 ; VRAMC1.K5 30.76,196.96 v6(30.76,197)
  BOTTOM w0.089: 51.98,184.74 52.32,184.4 61.47,184.4 61.73,184.15 v6(61.73,183.6)
  BOTTOM w0.13: v6(30.76,197) 30.93,197.17 31.86,197.17 32.01,197.02 36.69,197.02 38.3,195.41 38.3,192.8 40.9,190.2 43.86,190.2 49.32,184.74 51.98,184.74
MAC0_7: length 38.6
  TOP w0.13: GPU1.V10 59,184.35 v6(58.55,184.8) ; v6(29.9,196.1) VRAMC1.K4
  BOTTOM w0.089: v6(58.55,184.8) 58.15,185.2 53.12,185.2
  BOTTOM w0.13: 53.12,185.2 49.57,185.2 44.07,190.7 41.3,190.7 39,193 39,195.41 36.97,197.44 30.56,197.44 30.32,197.2 30.32,196.73 30.58,196.47 30.58,195.9 30.43,195.75 30.25,195.75 v6(29.9,196.1)
MAC0_8: length 38.3
  TOP w0.13: VRAMC1.J5 29.86,196.86 v6(29.86,197) ; GPU1.V11 59.8,184.35 v6(59.35,184.8)
  BOTTOM w0.089: v6(59.35,184.8) 58.75,185.4 53.76,185.4 53.69,185.47
  BOTTOM w0.13: v6(29.86,197) 29.86,197.34 30.44,197.92 37.2,197.92 39.6,195.52 39.6,193.18 41.58,191.2 44.28,191.2 49.78,185.69 49.78,185.69 49.97,185.51 53.65,185.51 53.69,185.47
MAC1_0: length 35.8
  TOP w0.13: GPU1.AC8 56.95,178.95 v6(56.95,178.8) ; VRAMC2.K4 v6(29.1,182.4)
  BOTTOM w0.13: v6(29.1,182.4) 29.1,182.4 29.45,182.05 29.45,180.63 29.78,180.3 38.47,180.3 38.6,180.17 38.6,180.03 38.73,179.9 39,179.9 39.13,180.03 39.13,180.43 39.26,180.56 39.53,180.56 39.66,180.43 39.66,180.03 39.79,179.9 40.06,179.9 40.19,180.03 40.19,180.43 40.32,180.56 40.59,180.56 40.72,180.43 40.72,180.03 40.85,179.9 41.12,179.9 41.25,180.03 41.25,180.43 41.38,180.56 41.65,180.56 41.78,180.43 41.78,180.03 41.91,179.9 42.18,179.9 42.69,180.41 42.89,180.41 43.02,180.28 43.02,180.03 43.15,179.9 43.42,179.9 43.55,180.03 43.55,180.28 43.68,180.41 43.88,180.41 45.04,179.25 56.5,179.25 v6(56.95,178.8)
MAC1_1: length 35.5
  TOP w0.13: v6(60.95,177.6) 60.95,177.75 GPU1.AD13 ; v6(29.03,181.54) 28.7,181.87 VRAMC2.K5
  BOTTOM w0.089: v6(60.95,177.6) 60.15,178.4 52.48,178.4 52.24,178.65
  BOTTOM w0.13: 52.24,178.65 44.94,178.65 44.18,179.4 38.08,179.4 37.8,179.68 37.54,179.94 29.63,179.94 29.03,180.54 v6(29.03,181.54)
MAC1_2: length 34.9
  TOP w0.13: VRAMC2.K11 29.1,177.6 v6(29.1,177.61) ; GPU1.AD10 59,178.05 v6(58.55,177.6)
  BOTTOM w0.089: 50.4,178 58.15,178 v6(58.55,177.6)
  BOTTOM w0.1: 50.39,177.99 50.4,178
  BOTTOM w0.13: 50.39,177.99 50.1,177.7 40.91,177.7 40.78,177.83 40.78,178.25 40.65,178.38 40.38,178.38 40.25,178.25 40.25,177.83 40.12,177.7 39.7,177.7 39.57,177.83 39.57,178.27 39.44,178.4 39.17,178.4 39.04,178.27 39.04,177.76 38.91,177.62 38.71,177.62 38.26,178.08 38.26,178.08 37.6,178.08 37.05,178.62 37.05,178.62 36.67,179 30.57,179 30.31,178.74 30.31,177.99 29.92,177.6 29.11,177.6 v6(29.1,177.61)
MAC1_3: length 35.8
  TOP w0.13: VRAMC2.K10 28.7,178.2 v6(29.08,178.59) ; v6(60.15,177.6) 60.6,178.05 GPU1.AD12
  BOTTOM w0.089: v6(60.15,177.6) 59.55,178.2 50.22,178.2
  BOTTOM w0.13: v6(29.08,178.59) 29.18,178.59 30.07,179.48 36.92,179.48 37.28,179.12 37.5,178.9 41.08,178.9 41.2,178.78 41.7,178.27 41.78,178.2 42.17,178.2 42.3,178.33 42.3,178.75 42.43,178.88 42.7,178.88 42.83,178.75 42.83,178.33 42.96,178.2 43.32,178.2 43.45,178.33 43.45,178.74 43.58,178.87 43.85,178.87 43.98,178.74 43.98,178.33 44.11,178.2 50.22,178.2
MAC1_4: length 35.8
  TOP w0.13: VRAMC2.H11 v6(30.7,177.6) ; GPU1.AE11 59.35,176.55 v6(59.35,176.4)
  BOTTOM w0.089: 51.19,176.94 51.24,176.99 58.76,176.99 v6(59.35,176.4)
  BOTTOM w0.13: v6(30.7,177.6) 31.28,178.17 35.55,178.17 35.93,177.8 35.93,177.4 36.11,177.21 36.11,177.03 35.97,176.89 35.97,176.7 36.16,176.51 36.35,176.51 36.49,176.65 36.67,176.65 36.88,176.44 36.88,175.25 37.01,175.12 37.24,175.12 37.57,175.45 37.57,175.75 37.7,175.88 37.97,175.88 38.1,175.75 38.1,175.45 38.23,175.32 38.5,175.32 38.63,175.45 38.63,175.75 38.76,175.88 39.03,175.88 39.16,175.75 39.16,175.45 39.29,175.32 39.9,175.32 40.13,175.55 40.26,175.55 41.35,176.65 50.19,176.65 50.26,176.58 50.83,176.58 51.19,176.94
MAC1_5: length 36
  TOP w0.13: VRAMC2.H10 30.31,178 v6(30.75,178.44) ; v6(60.15,176.4) 60.15,176.55 GPU1.AE12
  BOTTOM w0.089: v6(60.15,176.4) 59.37,177.18 54.2,177.18 53.84,177.54
  BOTTOM w0.13: v6(30.75,178.44) 30.89,178.58 36,178.58 36.37,178.58 37.28,177.67 37.28,176.62 37.52,176.38 37.8,176.38 37.93,176.51 37.93,176.97 38.1,177.14 38.33,177.14 38.46,177.01 38.46,176.51 38.59,176.38 38.86,176.38 38.99,176.51 38.99,176.97 39.16,177.14 39.39,177.14 39.52,177.01 39.52,176.51 39.65,176.38 40.38,176.38 40.54,176.54 40.54,176.94 40.8,177.2 50.06,177.2 50.4,177.54 53.84,177.54
MAC1_6: length 36
  TOP w0.13: GPU1.AC13 60.95,178.95 v6(60.95,178.8) ; v6(30.78,181.54) 30.32,182 VRAMC2.H5
  BOTTOM w0.13: v6(60.95,178.8) 60.5,179.25 59.28,179.25 57.91,180.62 51.75,180.62 51.29,181.09 45.33,181.09 43.29,183.12 39.7,183.12 39.57,182.99 39.57,182.75 39.44,182.62 39.17,182.62 39.04,182.75 39.04,182.99 38.91,183.12 38.58,183.12 38.45,182.99 38.45,182.73 38.32,182.6 38.05,182.6 37.92,182.73 37.92,182.99 37.79,183.12 37.55,183.12 37.33,182.9 37.33,182.03 36.84,181.54 31.91,181.54 31.91,181.54 30.78,181.54 v6(30.78,181.54)
MAC1_7: length 35.5
  TOP w0.13: v6(59.34,178.82) 59.35,178.83 59.35,178.95 GPU1.AC11 ; v6(29.9,182.4) VRAMC2.H4
  BOTTOM w0.13: v6(29.9,182.4) 30.32,181.98 30.32,181.36 30.58,181.1 36.59,181.1 36.59,181.1 37.21,181.1 38.25,182.14 39.62,182.14 39.8,182.33 39.8,182.52 39.9,182.62 40.23,182.62 40.34,182.52 40.34,182.2 40.44,182.1 40.77,182.1 40.87,182.2 40.87,182.52 40.97,182.62 41.3,182.62 41.4,182.52 41.4,182.19 41.5,182.09 41.83,182.09 41.94,182.19 41.94,182.45 42.04,182.55 43.16,182.55 45.14,180.57 49.49,180.57 49.81,180.25 57.9,180.25 59.33,178.82 v6(59.34,178.82)
MAC1_8: length 35.3
  TOP w0.13: VRAMC2.J5 29.5,181.92 v6(29.88,181.54) ; GPU1.AC10 58.55,178.95 v6(58.55,178.8)
  BOTTOM w0.13: v6(58.55,178.8) 57.5,179.85 45.15,179.85 43.92,181.08 43.61,181.08 43.48,181.2 43.48,181.44 43.35,181.57 43.08,181.57 42.95,181.44 42.95,181.2 42.82,181.08 42.55,181.08 42.42,181.2 42.42,181.44 42.29,181.57 42.02,181.57 41.89,181.44 41.89,181.2 41.76,181.08 41.34,181.08 41.23,181.19 41.23,181.47 41.1,181.6 40.83,181.6 40.7,181.47 40.7,181.19 40.57,181.06 40.3,181.06 40.17,181.19 40.17,181.47 40.04,181.6 39.77,181.6 39.64,181.47 39.64,181.19 39.51,181.06 39.24,181.06 39.11,181.19 39.11,181.48 39.01,181.58 38.53,181.58 37.67,180.72 30.24,180.72 29.88,181.08 v6(29.88,181.54)
MAD0_0: length 38.5
  TOP w0.13: VRAMD1.H4 v6(29.1,159.1) ; v6(56.95,169.2) 56.95,169.35 GPU1.AN8
  BOTTOM w0.089: 51.28,168.8 56.55,168.8 v6(56.95,169.2)
  BOTTOM w0.13: v6(29.1,159.1) 29.46,159.46 29.46,159.8 29.44,159.83 29.44,160.17 29.46,160.2 29.46,160.89 29.96,161.38 39.39,161.38 42.09,164.08 42.32,164.08 42.68,163.72 42.87,163.72 43.09,163.95 43.09,164.13 42.7,164.52 42.7,164.7 42.89,164.89 43.08,164.89 43.47,164.5 43.65,164.5 43.84,164.7 43.84,164.88 43.66,165.06 43.66,165.24 43.84,165.42 44.05,165.42 44.36,165.11 44.54,165.11 44.73,165.3 44.73,165.49 44.2,166.02 44.2,166.2 44.39,166.39 44.58,166.39 45.25,165.72 45.53,165.72 46.1,166.29 46.26,166.29 48.76,168.8 51.28,168.8
MAD0_1: length 38.5
  TOP w0.13: VRAMD1.H5 29.01,159.81 v6(29.01,160) ; v6(60.4,170.25) 60.8,170.65 GPU1.AM12
  BOTTOM w0.089: 53.26,169.62 58.27,169.62 58.5,169.85 60,169.85 v6(60.4,170.25)
  BOTTOM w0.13: 53.26,169.62 52.94,169.3 48.56,169.3 46.49,167.23 44.55,167.23 43.57,166.26 43.57,165.99 43.44,165.86 43.15,165.86 39.17,161.88 37.29,161.88 37.15,161.74 29.57,161.74 29.39,161.93 29.2,161.93 29.01,161.74 29.01,161.55 29.2,161.36 29.2,161.18 29.01,160.99 v6(29.01,160)
MAD0_2: length 38.2
  TOP w0.13: GPU1.AM9 57.75,170.55 v6(57.75,170.4) ; VRAMD1.H11 v6(29.1,163.9)
  BOTTOM w0.089: v6(57.75,170.4) 57.35,170 54.28,170 54.21,170.08 53.98,170.3 53.8,170.3
  BOTTOM w0.13: v6(29.1,163.9) 30.05,163.9 30.25,163.7 30.25,163.21 30.29,163.17 30.29,162.72 30.47,162.54 36.59,162.54 37.33,163.28 37.75,163.28 38.29,162.74 38.43,162.74 38.57,162.88 38.57,162.88 38.7,163.01 38.7,163.19 37.73,164.16 37.73,164.32 37.97,164.56 38.13,164.56 39.14,163.55 39.43,163.55 44.99,169.11 46.93,169.11 48.27,170.45 51.25,170.45 51.4,170.3 53.8,170.3
MAD0_3: length 37.7
  TOP w0.13: VRAMD1.H10 29.07,163.13 v6(29.07,163) ; v6(58.55,170.4) 58.55,170.55 GPU1.AM10
  BOTTOM w0.089: 53.75,169.9 54.11,169.9 54.13,169.89 54.21,169.81 57.96,169.81 v6(58.55,170.4)
  BOTTOM w0.13: v6(29.07,163) 29.07,162.45 29.31,162.2 29.86,162.2 29.91,162.16 37.06,162.16 37.16,162.26 37.16,162.64 37.26,162.74 37.62,162.74 37.74,162.61 37.74,162.48 37.84,162.38 38.97,162.38 44.51,167.92 44.93,167.92 45.4,168.39 46.13,168.39 46.23,168.29 46.23,167.92 46.33,167.82 46.74,167.82 46.91,167.99 46.91,168.39 48.74,170.22 49.23,170.22 49.36,170.09 49.36,169.79 49.47,169.67 49.89,169.67 50.01,169.79 50.01,170.09 50.14,170.22 50.99,170.22 51.31,169.9 53.75,169.9
MAD0_4: length 38.2
  TOP w0.13: GPU1.AK10 58.55,171.75 v6(58.55,171.6) ; VRAMD1.K11 v6(30.7,163.9)
  BOTTOM w0.089: v6(58.55,171.6) 57.96,171.01 51.99,171.01 51.76,171.24
  BOTTOM w0.13: v6(30.7,163.9) 30.7,163.65 31.03,163.33 35.65,163.33 35.95,163.62 35.95,164.12 36.11,164.28 36.11,164.49 35.94,164.66 35.94,164.84 36.13,165.03 36.31,165.03 36.48,164.86 36.69,164.86 36.9,165.07 36.9,166.37 37.03,166.5 37.33,166.5 37.48,166.35 37.48,165.66 37.69,165.45 38.9,165.45 39.25,165.1 39.56,165.1 41.3,166.84 41.3,167.02 41.02,167.3 41.02,167.5 41.17,167.65 41.42,167.65 41.67,167.4 41.86,167.4 42.05,167.59 42.05,167.77 41.82,168 41.82,168.19 44.85,171.22 51.74,171.22 51.76,171.24
