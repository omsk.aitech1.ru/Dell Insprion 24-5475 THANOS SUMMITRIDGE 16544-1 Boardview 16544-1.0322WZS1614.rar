# Allegro board 16544-1.0322WZS1614.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
19V_DCBATOUT on BOTTOM: 217.2,199.72 216.81,200.1 216.81,201.88 218.59,203.66 219.53,203.66 219.79,203.4 219.79,203.15 219.48,202.84 219.48,201.78 219.86,201.4 219.86,200 219.58,199.72
19V_DCBATOUT on BOTTOM: outline of 168 points within 2.34,10.79 221.49,234.29 ; 5 cut-outs
19V_DCBATOUT on L3: 232.61,234.42 234.21,232.82 234.21,201.93 233.6,201.32 232.82,201.32 231.66,202.48 229.3,202.48 227.8,203.97 227.8,213.91 227.2,214.5 227.2,219.46 227.46,219.71 227.46,222.63 220.52,229.57 211.25,229.57 209.25,231.57 176.5,231.57 174.37,229.44 161.29,229.44 160.53,228.68 117.75,228.68 117.58,228.5 117.58,225.93 113.28,221.64 106.15,221.64 101.22,226.57 100.58,226.57 96.44,230.71 42.65,230.71 38.25,226.31 26.82,226.31 25.91,227.23 15.13,227.23 13.11,225.21 12.48,225.21 6.44,219.16 6.44,217.69 5.41,216.66 2.74,216.66 2.44,216.97 2.44,223.16 6.55,227.28 11.66,227.28 12.98,228.6 12.98,234.06 13.34,234.42
19V_DCBATOUT on L4: outline of 112 points within 2.41,2.26 234.18,234.31 ; 1 cut-out
19V_DCBATOUT on L6: 150.65,2.41 145.16,2.41 145.03,2.29 89.53,2.29 88.27,3.56 88.27,5.08 82.42,10.92 82.42,25.15 81.28,26.29 80.77,26.29 80.26,26.8 80.26,34.29 80.52,34.54 82.93,34.54 85.09,32.38 85.09,29.97 85.47,29.59 85.47,13.08 93.98,4.57 113.69,4.57 115.65,6.53 123.9,6.53 124.97,5.46 139.57,5.46 140.34,4.7 150.88,4.7 151.21,4.37 151.21,2.97
19V_DCBATOUT on L6: 181.86,13.31 181.86,9.65 182.12,9.4 183.39,9.4 185.17,7.62 190.25,7.62 190.63,7.24 190.63,6.86 189.87,6.1 189.87,5.46 191.52,5.46 192.79,6.73 192.79,9.53 191.9,10.41 191.9,11.94 191.39,12.45 184.07,12.45 182.91,13.61 182.17,13.61
19V_DCBATOUT on L6: outline of 81 points within 2.1,60.07 234.44,234.34
19V_DCBATOUT_CAM on TOP: 221.59,51.84 219.07,54.36 219.07,56.9 219.25,57.07 225.63,57.07 226.77,55.93 229.03,55.93 229.18,55.78 229.18,52.68 229.13,52.63 227.25,52.63 226.47,51.84 ; 4 cut-outs
AGND on TOP: 201.33,55.21 200.79,55.75 200.79,58.17 200.53,58.42 200.53,59.08 200.61,59.16 203.3,59.16 203.71,58.75 203.71,55.37 203.54,55.21 ; 4 cut-outs
AGND on TOP: 136.96,6.22 136.7,6.48 136.7,7.8 137.29,8.38 140.03,8.38 140.06,8.36 140.36,8.36 140.84,7.87 140.84,6.6 140.46,6.22
AGND on TOP: 208.91,47.75 208.79,47.88 208.79,49.78 208.53,50.04 206.25,50.04 205.87,49.66 205.87,48.9 205.56,48.59 205.21,48.59 205.03,48.77 205.03,50.09 205.49,50.55 205.49,51.18 205.99,51.69 206.63,51.69 207.01,52.07 209.04,52.07 210.31,50.8 210.31,48.39 209.68,47.75 ; 5 cut-outs
AGND on TOP: 192.28,43.43 191.9,43.81 191.9,45.01 191.95,45.06 192.58,45.06 193.57,46.05 193.57,46.69 193.83,46.94 194.82,46.94 194.82,45.97 194.56,45.72 194.56,45.09 194.06,44.58 194.06,43.56 193.93,43.43 ; 3 cut-outs
AGND on BOTTOM: 191.9,43.56 191.64,43.81 191.64,44.86 192.66,45.87 192.66,48.51 192.79,48.64 194.06,48.64 194.18,48.51 194.18,46.99 194.44,46.74 194.44,45.72 194.06,45.34 194.06,43.99 194.01,43.94 192.91,43.94 192.53,43.56 ; 2 cut-outs
AGND on BOTTOM: 208.53,54.1 207.52,55.12 201.68,55.12 201.29,55.5 201.29,57.53 201.8,58.04 201.8,59.56 202.82,60.58 210.57,60.58 211.46,59.69 211.46,55.12 210.44,54.1 ; 4 cut-outs
AGND on L2GND: 137.18,6.13 136.58,6.73 136.58,7.77 137.08,8.26 141.76,8.26 141.86,8.16 141.86,6.28 141.72,6.13
AGND on L2GND: 231.42,31.1 231.07,31.46 220.27,31.46 217.61,34.11 217.61,35.23 218.5,36.12 218.5,37.67 214.43,41.74 211.79,41.74 210.95,42.58 208.46,42.58 208.09,42.22 208.09,41.63 207.67,41.21 206.45,41.21 206.2,41.47 204.5,41.47 204.43,41.53 204.43,44.58 203.99,45.02 199.34,45.02 198.82,44.5 198.82,43.97 198.8,43.95 196.09,43.95 195.53,43.4 192.36,43.4 191.88,43.87 191.88,45.01 191.95,45.07 192.53,45.07 193.56,46.1 193.56,46.68 193.83,46.95 196.17,46.95 196.7,47.49 197.39,47.49 197.78,47.88 197.78,48.59 196.61,49.76 196.61,50.98 196.8,51.17 197.56,51.17 198.21,51.81 198.21,54.05 198.58,54.42 199.01,54.42 200.72,56.13 200.72,58.24 200.47,58.5 200.47,59.05 200.59,59.17 201.42,59.17 201.66,59.41 201.66,60.12 202.14,60.59 205.08,60.59 205.4,60.91 205.4,62.03 205.17,62.26 205.17,63.95 205.79,64.58 213.76,64.58 216.07,62.28 216.07,55.81 213.19,52.94 213.19,49.91 214.51,48.59 214.75,48.35 225.19,48.35 227.44,46.1 228.96,44.58 229.43,44.12 229.43,38.99 230.74,37.67 232.41,36 235.24,36 235.24,31.1
AGND on L5GND: 225.35,31.46 222.46,34.35 219.28,34.35 218.5,35.13 218.5,37.67 214.43,41.74 211.79,41.74 210.95,42.58 208.46,42.58 208.09,42.22 208.09,41.63 207.67,41.21 206.45,41.21 206.2,41.47 204.5,41.47 204.43,41.53 204.43,44.58 203.99,45.02 199.34,45.02 198.82,44.5 198.82,43.97 198.8,43.95 196.09,43.95 195.53,43.4 192.36,43.4 191.88,43.87 191.88,45.01 191.95,45.07 192.53,45.07 193.56,46.1 193.56,46.68 193.83,46.95 196.17,46.95 196.7,47.49 197.39,47.49 197.78,47.88 197.78,48.59 196.61,49.76 196.61,50.98 196.8,51.17 197.56,51.17 198.21,51.81 198.21,54.05 198.58,54.42 199.01,54.42 200.72,56.13 200.72,58.24 200.47,58.5 200.47,59.05 200.59,59.17 201.42,59.17 201.66,59.41 201.66,60.12 202.14,60.59 205.08,60.59 205.4,60.91 205.4,62.03 205.17,62.26 205.17,63.95 205.79,64.58 213.76,64.58 216.07,62.28 216.07,55.81 213.19,52.94 213.19,49.91 214.51,48.59 214.75,48.35 225.19,48.35 227.44,46.1 228.96,44.58 229.43,44.12 229.43,38.99 230.74,37.67 232.02,36.4 232.02,32.18 231.29,31.46
AGND on L7GND: outline of 100 points within 137.3,2.48 233.69,64.63
GND on TOP: 189.23,11.3 188.85,11.68 188.85,14.86 188.24,15.47 185.75,15.47 185.7,15.52 185.7,15.88 185.8,15.98 187.38,15.98 187.78,16.38 189.74,16.38 190.12,16 190.12,12.95 190.25,12.83 190.25,11.56 189.99,11.3 ; 3 cut-outs
GND on TOP: 205.99,215.9 205.74,216.15 205.74,217.81 205.99,218.06 207.39,218.06 207.65,217.81 207.65,217.3 207.39,217.04 207.14,217.04 206.5,216.41 206.5,216.15 206.25,215.9
GND on TOP: 89.64,19.96 89.33,20.27 89.33,22.68 88.14,23.88 88.14,25.27 87.88,25.53 87.88,27.69 88.01,27.81 90.68,27.81 90.93,27.56 90.93,24.89 91.92,23.9 91.92,20.09 91.8,19.96 ; 3 cut-outs
GND on TOP: 230.76,196.34 230.64,196.46 230.64,197.27 229.95,197.96 229.38,197.96 229.22,198.12 229.22,199.28 228.98,199.52 228.98,200.79 229.11,200.91 230.56,200.91 231.39,200.08 231.39,196.6 231.14,196.34 ; 1 cut-out
GND on TOP: 29.72,208.53 29.34,208.91 29.34,211.96 29.72,212.34 33.91,212.34 34.04,212.22 34.04,210.44 34.54,209.93 35.43,209.93 35.81,210.31 35.81,210.95 36.2,211.33 36.7,211.33 36.96,211.07 36.96,209.04 36.45,208.53
GND on TOP: 15.49,163.32 15.24,163.58 15.24,167.89 15.62,168.28 18.67,168.28 19.94,167 19.94,164.34 19.68,164.08 16.51,164.08 15.75,163.32
GND on TOP: 124.69,94.87 124.56,95 124.56,95.53 123.65,96.44 119.89,96.44 119.86,96.42 119.86,97.36 119.96,97.46 122.83,97.46 122.94,97.36 122.94,96.85 123.01,96.77 124.16,96.77 124.21,96.72 124.51,96.72 124.84,97.05 124.84,97.46 124.99,97.61 125.65,97.61 125.86,97.41 125.86,95.12 125.6,94.87 ; 1 cut-out
GND on TOP: 132.72,72.64 131.83,73.53 129.92,73.53 128.78,74.68 128.78,75.56 129.29,76.07 135.89,76.07 136.02,75.95 136.02,73.28 135.38,72.64 ; 3 cut-outs
GND on TOP: 75.95,143 75.06,143.89 75.06,146.05 74.8,146.3 74.8,151.76 75.44,152.4 76.96,152.4 77.22,152.15 77.22,146.3 77.47,146.05 77.47,143.26 77.22,143
GND on TOP: 139.04,116.05 138.43,116.66 138.43,121.67 138.56,121.79 140.59,121.79 140.97,121.41 140.97,116.26 140.77,116.05
GND on TOP: 84.07,143.26 83.44,143.89 83.44,154.05 83.69,154.31 86.74,154.31 87.38,153.67 87.38,144.4 86.23,143.26
GND on TOP: 195.71,171.83 195.58,171.96 195.58,176.15 195.45,176.28 195.45,177.04 195.71,177.29 196.09,177.29 196.34,177.04 196.34,172.09 196.09,171.83
GND on TOP: 157.48,41.91 157.23,42.16 157.23,46.99 157.99,47.75 157.99,48.01 158.12,48.13 158.37,48.13 158.5,48.01 158.5,47.62 158.88,47.24 163.07,47.24 163.32,46.99 163.32,42.29 162.94,41.91
GND on TOP: 227.46,91.69 227.08,92.08 227.08,92.33 226.82,92.58 223.39,92.58 223.14,92.84 223.14,96.65 223.52,97.03 228.85,97.03 228.98,97.16 228.98,103.25 229.62,103.89 231.39,103.89 231.52,103.76 231.52,93.09 230.12,91.69
GND on TOP: 219.18,20.09 219.07,20.19 219.07,21.46 219.2,21.59 219.61,21.59 220.5,22.48 221.03,22.48 221.23,22.68 221.23,23.5 220.73,24 220.73,24.94 221.34,25.55 222.63,25.55 223.01,25.17 223.01,21.97 222.76,21.72 220.98,21.72 220.6,21.34 220.6,20.7 220.47,20.57 219.81,20.57 219.63,20.4 219.63,20.17 219.56,20.09 ; 7 cut-outs
GND on TOP: 215.93,182.47 215.65,182.75 215.65,185.67 215.77,185.8 217.3,185.8 217.55,186.06 217.55,187.58 216.66,188.47 215.52,188.47 215.38,188.61 215.38,189.75 216.33,190.7 219.53,190.7 220.12,191.29 220.12,196.14 220.62,196.65 222.45,196.65 222.58,196.52 222.58,191.39 222.61,191.36 222.61,190.86 223.65,189.81 223.65,188.82 224.71,187.76 224.71,183.92 224.61,183.82 222.33,183.82 222.1,183.59 222.1,182.6 221.97,182.47 ; 6 cut-outs
GND on TOP: 106.55,25.4 105.79,26.16 105.79,28.19 106.05,28.45 107.44,28.45 108.08,27.81 108.08,26.04 107.44,25.4 ; 2 cut-outs
GND on TOP: 6.1,181.61 5.84,181.86 5.84,187.07 6.1,187.32 7.24,187.32 7.37,187.2 7.37,183.9 7.75,183.51 7.75,181.74 7.62,181.61
GND on TOP: 15.75,200.53 15.37,200.91 15.37,202.95 15.62,203.2 17.27,203.2 17.65,202.82 17.65,200.66 17.53,200.53
GND on TOP: outline of 190 points within 159.26,0.76 235.24,101.85 ; 16 cut-outs
GND on TOP: 168.15,40.77 166.75,42.16 166.75,42.29 167,42.55 167.77,42.55 168.02,42.8 168.4,42.8 168.53,42.67 168.78,42.67 168.91,42.8 169.16,42.8 169.29,42.67 169.67,42.67 170.31,43.31 170.31,43.56 170.43,43.69 170.81,43.69 171.32,43.18 171.32,41.15 170.94,40.77
GND on TOP: 125.73,28.19 125.48,28.45 125.48,30.23 126.11,30.86 128.91,30.86 129.92,31.88 137.03,31.88 137.54,31.37 137.54,28.57 137.16,28.19
GND on TOP: 154.69,225.81 154.43,226.06 154.43,227.71 155.7,228.98 156.08,228.98 156.34,228.73 156.34,227.46 156.08,227.2 156.08,225.93 155.96,225.81
GND on TOP: 66.25,174.25 65.62,174.89 65.62,185.83 65.91,186.12 67.22,186.12 67.26,186.08 67.26,174.74 66.78,174.25
GND on TOP: 131.85,53.85 131.22,54.48 131.22,55.58 132.84,55.58 132.97,55.45 132.97,54.36 132.46,53.85 ; 2 cut-outs
GND on TOP: 43.66,109.98 43.31,110.34 43.31,113.03 42.8,113.54 42.8,114.05 42.29,114.55 41.5,114.55 41.22,114.83 41.22,115.93 41.27,115.98 43.59,115.98 43.69,116.08 43.69,118.9 43.66,118.92 43.66,119.68 43.74,119.76 45.09,119.76 45.24,119.91 45.24,121.56 45.59,121.92 46.48,121.92 46.61,121.79 46.61,118.41 47.38,117.64 47.38,115.94 48.26,115.06 48.26,110.11 48.13,109.98 ; 5 cut-outs
GND on TOP: 141.73,222.63 141.6,222.76 141.6,224.92 141.35,225.17 137.92,225.17 137.72,225.37 137.72,226.16 137.29,226.59 137.29,227.2 138.35,228.27 144.25,228.27 144.73,227.79 145.85,227.79 146.1,228.04 147.37,228.04 147.47,227.94 147.47,224.26 147.07,223.85 144.48,223.85 143.26,222.63
GND on TOP: 143.76,209.17 143,209.93 138.94,209.93 138.68,210.19 138.68,210.95 138.84,211.1 141.71,211.1 142.57,211.96 145.67,211.96 146.16,211.47 146.16,210.81 146.18,210.79 146.18,209.3 146.05,209.17 ; 3 cut-outs
GND on TOP: 146.08,11.58 145.85,11.81 145.85,13.06 145.44,13.46 145.44,14.43 145.67,14.66 146.45,14.66 146.56,14.77 146.56,14.96 146.43,15.09 146.43,16.54 146.53,16.64 146.53,17.55 146.61,17.63 147.5,17.63 147.55,17.58 147.55,16.64 147.47,16.56 147.27,16.56 147.14,16.43 147.14,14.88 147.09,14.83 147.12,14.81 147.12,13.34 147.4,13.06 147.4,11.76 147.22,11.58
GND on TOP: 203.2,19.94 203.07,20.07 203.07,21.74 202.9,21.92 202.9,22.78 202.97,22.86 203.91,22.86 204.52,23.47 204.52,24.61 204.8,24.89 205.89,24.89 205.94,24.84 205.94,24.33 205.92,24.31 205.92,22.58 205.87,22.53 205.54,22.53 205.1,22.1 205.1,21.51 204.98,21.39 204.24,21.39 203.96,21.11 203.96,20.07 203.84,19.94 ; 5 cut-outs
GND on TOP: 102.16,204.7 100.46,206.4 100.46,210.44 100.97,210.95 102.23,210.95 102.26,210.97 104.11,210.97 104.88,210.21 104.88,205.46 104.11,204.7 ; 1 cut-out
GND on TOP: 141.81,13.34 141.6,13.54 141.6,14.68 141.45,14.83 141.25,14.83 141.17,14.91 141.17,17.11 141.54,17.48 142.6,17.48 142.77,17.3 142.77,16.66 142.42,16.31 142.42,14.15 142.49,14.07 142.49,13.49 142.34,13.34 ; 1 cut-out
GND on TOP: 195.58,51.56 195.45,51.69 195.45,52.07 196.09,52.7 196.09,54.23 196.22,54.36 197.61,54.36 197.87,54.1 197.87,52.07 197.36,51.56 ; 4 cut-outs
GND on TOP: 166.12,217.58 166.01,217.68 166.01,219.99 165.76,220.24 164.49,220.24 164.03,219.79 164.03,218.72 163.7,218.39 162.26,218.39 162.13,218.52 162.13,219.13 161.67,219.58 161.67,220.09 161.8,220.22 162.56,220.22 163.04,220.7 163.04,225.15 162.71,225.48 162.71,228.78 162.92,228.98 170.87,228.98 171.07,228.78 171.07,218.31 170.33,217.58 ; 4 cut-outs
GND on TOP: 65.68,109.63 65.53,109.78 65.53,113.97 64.82,114.68 63.6,114.68 63.45,114.83 63.45,115.93 63.5,115.98 65.81,115.98 65.91,116.08 65.91,118.9 65.89,118.92 65.89,119.68 66.01,119.81 67.16,119.81 67.36,120.02 67.36,122.45 67.67,122.76 69.95,122.76 71.13,121.58 71.13,120.64 71.12,120.62 71.12,118.47 72.95,116.64 72.95,115.8 72.83,115.68 70.7,115.68 69.14,114.12 69.14,109.88 68.88,109.63 ; 3 cut-outs
GND on TOP: 117.86,226.03 117.5,226.39 117.5,228.45 117.7,228.65 119.58,228.65 119.58,226.16 119.46,226.03 ; 2 cut-outs
GND on TOP: 194.18,61.85 194.06,61.98 194.06,63.47 194.46,63.88 195.83,63.88 196.05,63.67 196.05,62.06 195.83,61.85 ; 2 cut-outs
GND on TOP: 109.8,26.42 108.79,27.43 108.79,29.77 108.85,29.83 108.85,31.36 107.95,32.26 106.3,32.26 106.17,32.38 106.17,34.16 106.81,34.8 112.9,34.8 114.43,33.27 114.43,32.77 113.92,32.26 112.14,32.26 111.76,31.88 111.76,30.86 112.14,30.48 114.3,30.48 114.43,30.35 114.43,27.3 114.3,27.18 113.28,27.18 112.52,26.42
GND on TOP: 188.98,102.24 188.73,102.49 188.73,105.07 188.89,105.24 189.18,105.24 190.03,104.4 191.21,104.4 191.49,104.68 191.49,105.21 191.65,105.36 213.75,105.36 214.18,104.93 214.18,102.76 213.66,102.24
GND on TOP: 135.24,55.38 135,55.63 135,58.42 135.13,58.55 136.65,58.55 136.78,58.42 136.78,58.14 137.16,57.76 138,57.76 138.1,57.66 138.1,55.68 137.81,55.38 ; 1 cut-out
GND on TOP: 153.95,197.26 153.67,197.54 153.67,202.59 153.95,202.87 155.65,202.87 156.46,202.06 156.46,199.49 155.68,198.7 155.68,198.42 154.51,197.26
GND on TOP: 144.34,100.39 143.26,101.47 143.26,104.65 143.38,104.78 144.53,104.78 146.05,103.25 146.94,103.25 147.19,103 147.19,101.35 146.24,100.39
GND on TOP: 77.72,109.47 77.56,109.64 77.56,112.18 77.85,112.47 77.85,115.9 77.9,115.95 80.21,115.95 80.31,116.05 80.31,118.87 80.29,118.9 80.29,119.81 80.37,119.89 81.66,119.89 81.89,120.12 81.89,122.28 82.17,122.56 82.68,122.56 82.77,122.47 82.77,119.82 84.02,118.57 84.02,118.31 84.01,118.3 84.01,109.86 83.63,109.47 ; 1 cut-out
GND on TOP: 56.81,110.32 56.77,110.36 55.24,110.36 55.12,110.49 55.12,111.63 54.74,112.01 54.74,114.3 54.36,114.68 52.48,114.68 52.32,114.83 52.32,115.93 52.37,115.98 54.69,115.98 54.79,116.08 54.79,118.9 54.76,118.92 54.76,119.63 54.91,119.79 56.13,119.79 56.49,120.14 56.49,122.28 56.64,122.43 57.15,122.43 57.28,122.3 57.28,119.86 58.5,118.64 58.5,118.34 58.48,118.33 58.48,116.14 59.41,115.22 59.41,114.63 59.11,114.33 59.11,113.67 58.19,112.75 58.19,111.71 ; 4 cut-outs
GND on TOP: 182.52,217.5 182.42,217.6 182.42,219.99 182.09,220.32 180.42,220.32 180.06,219.96 180.06,218.95 179.68,218.57 178.44,218.57 178.31,218.69 178.31,227.99 178.71,228.4 185.8,228.4 186.92,227.28 186.92,217.78 186.64,217.5 ; 4 cut-outs
GND on TOP: 91.26,108.76 90.65,109.37 90.65,114.07 90.07,114.66 89.1,114.66 88.95,114.81 88.95,115.9 89,115.95 91.31,115.95 91.41,116.05 91.41,118.87 91.39,118.9 91.39,119.74 91.41,119.76 92.84,119.76 93.12,120.04 93.12,121.44 92.81,121.74 92.81,122.25 92.91,122.35 94.18,122.35 94.31,122.22 94.31,119.94 94.32,119.93 94.32,119.52 95.12,118.72 95.12,118.31 95.11,118.3 95.11,115.53 95.63,115.01 95.63,112.14 96.39,111.38 96.39,109.86 95.3,108.76 ; 3 cut-outs
GND on TOP: 129.41,117.09 129.16,117.35 129.16,119.48 128.4,120.24 128.4,122.3 128.63,122.53 129.34,122.53 129.87,122 130.71,122 130.96,121.74 130.96,120.27 130.71,120.02 130.68,120.02 130.68,117.98 129.79,117.09 ; 1 cut-out
GND on TOP: 222.05,49.3 221.54,49.81 221.54,51.26 221.87,51.59 226.26,51.59 226.64,51.21 226.64,49.73 226.21,49.3 ; 2 cut-outs
GND on TOP: 154.46,214.6 154.05,215.01 154.05,216.79 152.91,217.93 152.91,219.33 153.54,219.96 153.54,225.3 153.67,225.43 156.46,225.43 156.84,225.04 156.84,219.58 156.53,219.27 155.18,219.27 154.97,219.05 154.97,214.78 154.79,214.6
GND on TOP: 144.91,63.25 143.97,64.19 140.82,64.19 140.28,63.65 137.06,63.65 136.75,63.35 134.82,63.35 134.75,63.42 134.75,64.39 134.39,64.74 134.39,65.84 134.49,65.94 135.64,65.94 136.39,65.19 136.94,65.19 137.57,64.57 138.81,64.57 138.94,64.69 138.94,65.41 139.06,65.53 140.31,65.53 140.56,65.28 140.56,64.85 140.89,64.52 141.99,64.52 142.16,64.69 146.63,64.69 146.69,64.64 146.94,64.64 147.32,65.02 147.32,65.79 146.84,66.27 146.84,69.22 147.27,69.65 147.27,70.94 146.71,71.5 140.79,71.5 140.59,71.7 140.59,74.17 140.97,74.55 149.35,74.55 153.16,78.36 153.16,87.76 153.42,88.01 155.7,88.01 157.35,86.36 157.35,85.47 157.48,85.34 158.37,85.34 158.5,85.22 158.5,84.07 159.26,83.31 162.31,83.31 162.69,82.93 162.69,78.99 161.8,78.11 159,78.11 157.61,76.71 157.61,71.5 157.99,71.12 158.62,71.12 158.88,70.87 158.88,67.44 157.99,66.55 150.85,66.55 149.95,65.65 149.09,65.65 147.7,64.26 147.71,64.26 147.71,64 147.7,64 147.7,63.37 147.57,63.25 ; 8 cut-outs
GND on TOP: 219.14,13.22 218.72,13.64 213.94,13.64 213.61,13.97 213.61,15.11 213.87,15.37 218.36,15.37 219.07,14.66 219.56,14.66 219.58,14.63 219.58,13.34 219.47,13.22
GND on TOP: 101.47,113.79 100.47,114.8 100.48,114.81 100.48,115.9 100.53,115.95 102.84,115.95 102.95,116.05 102.95,118.87 102.92,118.9 102.92,119.66 103.02,119.76 104.19,119.76 104.76,120.33 104.76,121.53 104.44,121.84 104.44,122.63 104.65,122.83 104.65,123.32 104.98,123.65 106.73,123.65 107.31,123.06 107.31,114.94 106.17,113.79 ; 1 cut-out
GND on TOP: 168.02,159 167.89,159.13 167.89,168.17 168.07,168.35 168.58,168.35 168.78,168.15 168.78,164.59 169.42,163.96 170.31,163.96 170.43,163.83 170.43,159.13 170.31,159 ; 11 cut-outs
GND on TOP: 148.46,30.23 148.34,30.35 148.34,31.88 148.59,32.13 149.1,32.13 149.35,32.38 149.35,34.67 148.59,35.43 147.19,35.43 147.07,35.56 147.07,37.08 147.19,37.21 147.19,38.1 146.94,38.35 146.94,38.73 147.07,38.86 147.45,38.86 150.24,36.07 150.24,32.74 150.85,32.13 150.85,30.43 150.65,30.23 ; 2 cut-outs
GND on TOP: 122.81,42.29 122.68,42.42 122.68,45.34 123.19,45.85 123.7,45.85 123.95,45.59 123.95,44.07 124.21,43.81 124.21,43.43 124.08,43.31 123.7,43.31 123.44,43.05 123.44,42.55 123.19,42.29 ; 2 cut-outs
GND on TOP: 219.84,96.27 218.69,97.41 218.69,100.71 218.82,100.84 220.47,100.84 220.73,100.58 220.73,96.77 220.22,96.27
GND on TOP: 137.77,13.16 137.67,13.26 137.67,16.31 136.88,17.09 135.31,17.09 134.95,17.45 134.95,17.86 135.25,18.16 136.88,18.16 137.31,17.73 137.77,17.73 137.95,17.55 137.95,17.07 138.56,16.46 138.56,13.26 138.46,13.16
GND on TOP: 204.65,11.89 204.28,12.26 204.28,13.91 203.71,14.48 200.15,14.48 199.26,13.59 199.26,12.45 199.14,12.32 197.23,12.32 197.1,12.45 197.1,14.22 197.23,14.35 197.23,16.64 197.36,16.76 199.01,16.76 199.52,16.26 203.96,16.26 204.74,15.48 206.49,15.48 206.53,15.44 206.53,13.44 206.39,13.3 205.4,13.3 205.03,12.93 205.03,11.99 204.93,11.89 ; 5 cut-outs
GND on TOP: 95.89,88.57 95.71,88.75 95.71,92 95.86,92.15 95.86,92.2 96.98,92.2 97.28,91.9 97.28,88.8 97.05,88.57 ; 2 cut-outs
GND on TOP: 28.83,221.49 28.45,221.87 28.45,223.52 28.69,223.76 30.75,223.76 30.76,223.77 40.39,223.77 40.51,223.65 40.51,223.14 40.39,223.01 38.1,223.01 36.58,221.49
GND on TOP: 137.59,197.82 137.59,200.13 137.72,200.25 139.06,200.25 139.47,199.85 139.47,197.94 139.14,197.61 137.8,197.61 ; 1 cut-out
GND on TOP: 14.1,224.03 13.84,224.28 13.84,224.54 14.86,225.55 18.29,225.55 18.41,225.43 18.41,225.17 18.16,224.92 17.22,224.92 16.59,224.28 15.37,224.28 15.11,224.03
GND on TOP: 93.09,146.43 92.84,146.69 92.84,153.8 92.96,153.92 95.38,153.92 95.76,153.54 95.76,147.07 95.12,146.43
GND on TOP: 113.17,86.86 113.03,87 113.03,88.72 113.46,89.15 113.46,89.99 113.61,90.14 115.09,90.14 115.34,89.89 117.2,89.89 117.37,89.71 117.37,88.6 117.14,88.37 115.21,88.37 114.5,87.66 114.5,87.05 114.31,86.86 ; 2 cut-outs
GND on TOP: 223.65,125.48 223.18,125.95 218.78,125.95 218.67,126.06 218.67,128.35 217.91,129.11 217.91,131.75 220.12,133.96 223.88,133.96 224.03,134.11 225.55,134.11 225.81,133.86 225.81,133.35 225.68,133.22 225.55,133.22 225.3,132.97 225.3,132.33 225.17,132.21 225.17,126.24 224.41,125.48 ; 4 cut-outs
GND on TOP: 14.68,114.55 14.3,114.94 14.3,118.36 14.81,118.87 20.47,118.87 20.93,118.41 20.93,117.47 21.18,117.22 22.1,117.22 22.35,116.97 24.51,116.97 25.02,116.46 25.02,115.44 24.13,114.55 ; 6 cut-outs
GND on TOP: 144.37,198.98 144.03,199.33 142.66,199.33 141.01,200.98 141.01,203.11 141.63,203.73 141.63,204.95 141.83,205.16 143.08,205.16 143.21,205.03 143.21,204.39 143.89,203.71 143.89,203.07 144.26,202.7 145.3,202.7 145.54,202.46 145.54,199.14 145.39,198.98 ; 2 cut-outs
GND on TOP: 116.28,99.19 115.52,99.95 114.71,99.95 114.71,102.26 115.95,103.5 117.98,103.5 119.25,102.23 119.25,101.04 117.4,99.19
GND on TOP: 16.79,212.19 15.88,213.11 12.95,213.11 12.7,213.36 12.7,217.68 13.08,218.06 19.56,218.06 19.81,217.81 19.81,217.17 18.59,215.95 18.59,212.29 18.49,212.19 ; 2 cut-outs
GND on TOP: outline of 192 points within 0.76,0.76 235.24,235.24 ; 2 cut-outs
GND on TOP: 134.77,130.3 134.49,130.58 134.49,132.84 129.41,137.92 129.41,139.57 129.92,140.08 137.26,140.08 138.82,138.52 138.82,135.52 137.29,133.99 137.29,130.43 137.16,130.3 ; 4 cut-outs
GND on TOP: 117.98,117.09 117.47,117.6 117.47,118.24 119.13,119.89 119.13,125.48 119.76,126.11 119.76,127.51 120.02,127.76 121.79,127.76 122.05,127.51 122.05,125.35 120.52,123.83 120.52,119.25 120.9,118.87 120.9,117.73 120.27,117.09 ; 9 cut-outs
GND on TOP: 114.43,208.53 114.3,208.66 114.3,210.44 115.32,211.46 115.32,214.38 115.44,214.5 118.87,214.5 119.38,215.01 120.78,215.01 122.05,213.74 122.05,210.31 121.79,210.06 121.16,210.06 120.52,210.69 117.98,210.69 115.82,208.53 ; 5 cut-outs
GND on TOP: 199.9,57.1 199.75,57.25 199.75,57.81 199.26,58.29 199.26,60.63 199.97,61.34 199.97,62.81 200.03,62.87 200.71,62.87 200.94,62.64 200.94,60.43 201.17,60.2 201.17,59.56 201.09,59.49 200.46,59.49 200.15,59.18 200.15,58.17 200.41,57.91 200.41,57.23 200.28,57.1 ; 3 cut-outs
GND on TOP: 146.18,107.44 145.92,107.7 143.64,107.7 143,108.33 143,150.88 145.03,152.91 145.03,153.54 146.05,154.56 147.96,154.56 148.34,154.18 148.34,151.38 147.19,150.24 147.19,146.81 147.4,146.61 148.16,146.61 149.48,145.29 149.48,142.37 150.11,141.73 152.65,141.73 153.8,140.59 156.36,140.59 158.55,138.4 158.55,130.48 159.25,129.78 159.25,128.16 159.51,127.89 161.93,127.89 162.31,128.27 162.31,130.18 161.29,131.19 160.91,131.19 160.66,131.44 160.66,137.29 161.67,138.3 181.74,138.3 183.77,140.34 208.28,140.34 211.07,137.54 211.07,131.44 214.5,128.02 214.5,118.9 215.77,117.63 215.77,116.66 215.57,116.46 188.72,116.46 187.83,117.35 180.85,117.35 180.47,116.97 166.12,116.97 166.11,116.98 148.35,116.98 147.57,116.2 147.57,114.68 147.07,114.17 146.56,114.17 146.18,113.79 146.18,109.73 147.45,108.46 147.45,107.7 147.19,107.44 ; 8 cut-outs
GND on TOP: 27.3,124.84 25.32,126.82 22.12,126.82 20.45,125.15 15.29,125.15 14.33,126.11 14.33,127.84 15.51,129.02 20.82,129.02 22.48,130.68 23.37,130.68 25.15,132.46 25.15,133.22 26.19,134.26 33.5,134.26 34.26,133.5 34.26,125.96 33.15,124.84
GND on TOP: 216.36,31.52 216.31,31.57 215.39,31.57 215.11,31.85 214.55,31.85 214.45,31.95 214.45,32.46 214.25,32.66 213.31,32.66 213.18,32.54 213.18,31.88 213.13,31.83 212.39,31.83 212.34,31.88 212.34,32.77 211.96,33.15 211.71,33.15 211.58,33.27 211.58,33.91 211.33,34.16 210.67,34.16 210.54,34.29 210.54,34.8 210.69,34.95 212.78,34.95 214.07,33.66 216.08,33.66 217.22,32.51 217.22,31.6 217.14,31.52 ; 4 cut-outs
GND on TOP: 14.86,182.75 14.61,183.01 14.61,188.47 15.11,188.98 18.54,188.98 18.92,188.59 18.92,183.51 18.16,182.75 ; 1 cut-out
GND on TOP: 24.51,139.95 23.88,140.59 23.88,145.54 24.89,146.56 29.59,146.56 30.1,147.07 30.1,150.37 30.35,150.62 34.67,150.62 35.43,149.86 35.43,140.72 34.67,139.95
GND on TOP: 134.75,38.86 134.24,39.37 134.24,41.15 132.21,43.18 132.21,46.99 132.84,47.62 132.84,49.28 133.73,50.16 137.39,50.16 137.85,49.71 139.15,49.71 139.71,49.15 139.71,48.17 139.67,48.13 134.26,48.13 134.26,48.11 133.73,47.57 133.73,44.2 134.37,43.56 135.51,43.56 136.02,43.05 136.02,39.12 135.76,38.86 ; 2 cut-outs
GND on TOP: 151.43,101.3 151,101.73 151,104.14 150.52,104.62 150.52,105.19 150.55,105.21 168.91,105.21 169.68,104.45 169.68,104.04 169.98,103.74 170.67,103.74 170.67,103.73 171.75,103.73 171.85,103.64 171.85,102.23 170.92,101.3
GND on TOP: 186.51,35.94 186,36.45 186,38.35 184.58,39.78 182.4,39.78 182.09,40.08 182.09,41.22 181.91,41.4 181.91,41.78 182.02,41.88 183.49,41.88 183.54,41.83 183.54,41.55 183.72,41.38 185.88,41.38 187.93,39.32 188.91,39.32 188.99,39.24 188.99,37.73 188.7,37.44 188.7,36.2 188.44,35.94 ; 2 cut-outs
GND on TOP: 216.53,216.36 216.31,216.59 214.58,216.59 214.43,216.74 212.52,216.74 212.37,216.89 212.37,218.72 211.56,219.53 211.56,221.13 211.58,221.16 211.58,223.06 212.14,223.62 215.32,223.62 215.87,223.06 216.94,223.06 217.12,222.88 217.12,216.41 217.07,216.36 ; 18 cut-outs
GND on TOP: 142.14,36.42 141.96,36.6 141.96,37.67 142.62,38.33 142.62,40.18 142.44,40.36 141.55,40.36 141.53,40.39 141.53,40.54 141.55,40.56 142.54,40.56 142.62,40.64 142.62,41.91 141.86,42.67 141.86,43.31 141.99,43.43 142.49,43.43 143.51,42.42 143.51,38.99 143.48,38.96 143.48,37.08 142.82,36.42
GND on TOP: 109.98,16.38 109.86,16.51 109.86,19.94 108.84,20.95 104.52,20.95 104.39,20.83 103.25,20.83 103,21.08 103,22.99 104.01,24 107.57,24 108.58,25.02 111.76,25.02 111.89,24.89 112.65,24.89 112.78,24.77 112.78,23.88 112.9,23.75 114.3,23.75 114.55,23.5 114.55,19.05 114.94,18.67 114.94,17.65 114.81,17.53 111.38,17.53 110.24,16.38
GND on TOP: 222.55,62.15 222.22,62.48 220.83,62.48 220.47,62.84 220.47,64.34 220.78,64.64 222.63,64.64 223.01,64.26 226.31,64.26 226.69,63.88 226.69,62.64 226.21,62.15 ; 2 cut-outs
GND on TOP: 105.79,126.36 105.03,127.13 105.03,132.33 106.81,134.11 116.46,134.11 119.63,137.29 119.63,139.45 119.76,139.57 124.59,139.57 126.36,141.35 126.36,144.02 126.24,144.15 123.19,144.15 122.81,144.53 122.81,144.91 122.94,145.03 124.84,145.03 125.09,144.78 125.98,144.78 127.13,145.92 128.4,145.92 128.78,145.54 128.78,141.48 125.35,138.05 123.83,138.05 112.14,126.36 ; 4 cut-outs
GND on TOP: 141.73,28.19 141.48,28.45 141.48,32.89 141.73,33.15 142.49,33.15 142.88,32.77 142.88,28.45 142.62,28.19
GND on TOP: 172.47,159.13 172.21,159.38 172.21,160.78 172.34,160.91 172.34,161.67 171.83,162.18 171.83,162.74 172.34,163.25 172.34,163.96 171.96,164.34 171.32,164.34 171.07,164.59 171.07,165.25 170.64,165.68 170.64,166.57 171.07,167 171.07,168.68 170.79,168.96 170.79,170.08 170.89,170.18 171.2,170.18 171.96,169.42 172.21,169.42 173.23,168.4 173.23,160.78 173.48,160.53 173.48,160.15 173.35,160.02 173.35,159.26 173.23,159.13 ; 9 cut-outs
GND on TOP: 6.38,155.6 6.3,155.68 6.3,155.91 7.62,155.91 7.62,156.11 6.3,156.11 6.3,156.39 7.62,156.39 7.62,156.62 6.3,156.62 6.3,156.9 7.65,156.9 7.65,157.1 6.3,157.1 6.3,157.35 6.35,157.4 8.36,157.4 8.46,157.3 8.46,155.8 8.26,155.6
GND on TOP: 130.3,197.74 130.05,197.99 130.05,200.66 130.3,200.91 131.06,200.91 131.19,200.79 132.33,200.79 132.97,200.15 132.97,197.87 132.84,197.74 ; 3 cut-outs
GND on TOP: 141.22,77.85 140.72,78.36 140.72,79.12 141.48,79.88 142.62,79.88 143,80.26 143,84.96 145.16,87.12 149.1,87.12 150.11,86.11 150.11,80.14 147.83,77.85
GND on TOP: 132.59,23.88 131.95,24.51 126.75,24.51 125.98,25.27 125.98,27.05 126.49,27.56 136.4,27.56 137.03,26.92 137.03,24.64 136.27,23.88
GND on TOP: 133.22,102.31 132.36,103.17 129.41,103.17 129.29,103.3 129.29,104.39 129.41,104.52 130.86,104.52 131.32,104.98 133.4,104.98 134.06,105.64 134.06,106.17 134.04,106.2 134.04,107.24 134.16,107.37 134.16,108.56 134.24,108.64 135.05,108.64 135.1,108.58 135.1,107.67 134.75,107.31 134.75,105.71 134.8,105.66 134.8,104.98 134.67,104.85 134.67,102.82 134.16,102.31 ; 2 cut-outs
GND on TOP: 126.11,39.75 125.98,39.88 125.98,41.66 126.36,42.04 129.16,42.04 129.67,42.55 131.19,42.55 131.32,42.42 131.7,42.42 131.83,42.29 131.83,40.89 130.68,39.75 ; 4 cut-outs
GND on TOP: 199.06,217.6 198.88,217.78 198.88,220.01 198.35,220.55 197.13,220.55 196.82,220.24 196.82,218.9 196.44,218.52 195.15,218.52 194.97,218.69 194.97,227.58 195.86,228.47 204.09,228.47 204.6,227.97 204.6,223.7 203.56,222.66 203.56,218.47 202.69,217.6 ; 1 cut-out
GND on TOP: 34.54,110.11 34.04,110.62 34.04,115.29 34.65,115.9 35.99,115.9 36.7,115.19 36.7,110.24 36.58,110.11 ; 2 cut-outs
GND on BOTTOM: 204.72,11.94 204.47,12.19 204.47,14.1 203.84,14.73 202.56,14.73 202.31,14.99 202.31,16.89 202.44,17.02 204.72,17.02 205.74,16 205.74,12.06 205.61,11.94 ; 1 cut-out
GND on BOTTOM: 92.46,111.89 90.42,113.92 90.42,115.57 90.55,115.7 90.91,115.7 91.41,116.2 91.41,118.87 91.39,118.9 91.39,119.51 91.73,119.85 92.41,119.85 92.81,120.26 92.81,122.73 92.96,122.89 93.85,122.89 94.11,122.63 94.11,119.63 95.1,118.64 95.1,116.48 96.52,115.06 98.17,115.06 98.3,114.94 98.3,112.14 98.04,111.89 ; 2 cut-outs
GND on BOTTOM: 150.88,122.05 146.05,126.87 146.05,153.29 147.29,154.53 152.12,154.53 153.54,155.96 157.53,155.96 158.53,156.96 159.5,156.96 160.02,157.48 160.02,157.61 160.27,157.86 161.54,157.86 161.8,157.61 161.8,156.21 162.05,155.96 163.58,155.96 164.97,157.35 164.97,157.81 165.07,157.91 165.66,157.91 165.74,157.84 165.74,157.35 163.83,155.45 163.83,151.38 163.07,150.62 163.07,150.37 161.29,148.59 161.29,136.53 162.18,135.64 162.18,127.25 162.43,127 162.43,122.56 161.93,122.05 ; 24 cut-outs
GND on BOTTOM: 87.25,196.34 86.36,197.23 86.36,199.39 88.14,201.17 89.53,201.17 89.66,201.04 89.66,197.87 88.14,196.34 ; 3 cut-outs
GND on BOTTOM: 221.23,125.86 221.11,125.98 217.55,125.98 216.92,126.62 216.92,129.11 217.17,129.36 217.17,132.05 219.18,134.06 227.33,134.06 228.04,133.35 228.98,133.35 229.18,133.15 229.18,132.08 225.4,132.08 225.17,131.85 225.17,126.49 224.54,125.86
GND on BOTTOM: 169.29,155.45 169.16,155.57 169.16,155.83 169.04,155.96 168.4,155.96 168.28,156.08 168.28,157.86 168.4,157.99 169.05,157.99 169.25,157.79 169.59,157.79 169.79,157.99 170.43,157.99 170.81,157.61 170.81,156.21 170.74,156.13 170.1,156.13 169.8,155.83 169.8,155.57 169.67,155.45 ; 4 cut-outs
GND on BOTTOM: 104.52,7.87 104.39,8 104.39,9.53 105.03,10.16 107.19,10.16 107.7,10.67 111.68,10.67 111.76,10.59 111.76,9.4 112.29,8.86 112.29,8.08 112.09,7.87
GND on BOTTOM: 75.18,146.94 74.8,147.32 74.8,151.76 75.44,152.4 77.34,152.4 77.85,151.89 77.85,147.7 77.09,146.94 ; 4 cut-outs
GND on BOTTOM: 142.37,36.58 142.24,36.7 142.24,37.97 142.88,38.61 142.88,40.77 142.24,41.4 142.24,42.04 141.35,42.93 140.97,42.93 140.72,43.18 140.72,43.69 140.84,43.81 141.48,43.81 141.73,43.56 142.24,43.56 143.26,42.55 143.26,42.29 143.89,41.66 143.89,40.39 144.53,39.75 144.53,38.86 143,37.34 143,36.83 142.75,36.58 ; 5 cut-outs
GND on BOTTOM: 161.67,42.29 161.42,42.55 160.53,42.55 160.4,42.42 157.73,42.42 157.61,42.55 157.61,46.61 157.86,46.86 158.37,46.86 158.5,46.99 158.5,47.5 158.62,47.62 159.94,47.62 160.01,47.56 160.72,47.56 160.73,47.57 161.37,47.57 161.65,47.85 162.2,47.85 162.81,47.24 162.81,42.42 162.69,42.29 ; 16 cut-outs
GND on BOTTOM: 168.02,40.77 166.37,42.42 166.37,47.37 165.61,48.13 165.61,49.71 164.72,50.6 162.36,50.6 162.1,50.34 160.81,50.34 160.63,50.52 159.44,50.52 159.16,50.8 159.16,51.33 159.26,51.44 160.05,51.44 160.15,51.54 160.15,53.34 160.91,54.1 166.24,54.1 167.77,52.58 169.16,52.58 169.29,52.45 169.29,51.94 169.16,51.82 168.02,51.82 167.77,51.56 167.77,50.93 167.89,50.8 168.28,50.8 168.4,50.67 168.4,48.51 167.89,48.01 167.26,48.01 167,47.75 167,46.43 167.23,46.2 167.77,46.2 167.87,46.1 167.87,45.52 167.82,45.47 167.13,45.47 167,45.34 167,44.07 167.26,43.81 167.26,43.05 167.46,42.85 170.21,42.85 170.36,43 170.36,43.59 170.46,43.69 170.89,43.69 171.07,43.51 171.07,41.91 169.93,40.77 ; 8 cut-outs
GND on BOTTOM: 109.98,16.51 109.86,16.64 109.86,20.19 108.46,21.59 107.44,21.59 106.68,20.83 103.25,20.83 102.87,21.21 102.87,22.99 103.89,24 107.57,24 108.58,25.02 112.01,25.02 112.65,24.38 112.65,24 112.9,23.75 114.3,23.75 114.49,23.56 114.49,19.32 113.84,18.67 113.84,18.03 113.72,17.91 113.28,17.91 112.39,17.02 111.12,17.02 110.62,16.51 ; 3 cut-outs
GND on BOTTOM: 101.47,79.5 100.97,80.01 100.97,86.61 101.6,87.25 106.55,87.25 108.71,85.09 109.22,85.09 109.73,84.58 110.74,84.58 113.03,86.87 116.59,86.87 117.47,85.98 117.47,83.57 114.68,80.77 110.24,80.77 108.97,79.5
GND on BOTTOM: 151.54,89.05 150.32,90.27 150.32,90.3 150.24,90.37 150.24,90.91 150.33,91 151.5,91 152.27,90.22 152.27,89.26 152.07,89.05 ; 1 cut-out
GND on BOTTOM: 129.03,120.14 128.65,120.52 128.65,125.35 128.91,125.6 130.43,125.6 130.81,125.22 130.81,120.4 130.56,120.14
GND on BOTTOM: 111.76,145.92 111.76,150.37 111.89,150.5 112.65,150.5 112.78,150.37 112.78,149.48 112.9,149.35 114.3,149.35 114.55,149.61 114.55,149.86 114.68,149.99 117.09,149.99 117.73,149.35 117.73,146.05 117.6,145.92 ; 10 cut-outs
GND on BOTTOM: 52.73,195.3 52.2,195.83 52.2,197.99 52.07,198.12 51.56,198.12 51.44,198.25 51.44,198.5 51.56,198.63 51.82,198.63 52.07,198.88 52.07,199.52 52.32,199.77 53.59,199.77 53.85,199.52 53.85,196.11 54.15,195.81 54.46,195.81 54.56,195.71 54.56,195.45 54.41,195.3 ; 9 cut-outs
GND on BOTTOM: 136.27,77.72 136.02,77.98 136.02,79.38 135.76,79.63 134.75,79.63 134.62,79.5 134.11,79.5 133.86,79.76 133.86,81.79 135.25,83.19 135.25,85.22 135.76,85.72 139.06,85.72 140.08,86.74 144.78,86.74 145.29,87.25 146.81,87.25 148.21,85.85 150.88,85.85 151.64,85.09 151.64,80.9 148.46,77.72
GND on BOTTOM: 79.12,112.65 78.54,113.23 78.54,115.77 78.77,116 80.01,116 80.31,116.31 80.31,120.32 81.51,121.51 81.51,122.5 81.71,122.71 82.22,122.71 82.65,122.28 82.65,120.02 84,118.67 84,116 84.38,115.62 85.6,115.62 85.85,115.37 85.85,112.9 85.6,112.65
GND on BOTTOM: 106.55,25.4 105.79,26.16 105.79,28.19 106.05,28.45 107.82,28.45 108.08,28.19 108.08,26.04 107.44,25.4
GND on BOTTOM: 108.79,204.27 108.69,204.37 108.69,206.96 108.94,207.21 109.65,207.21 109.98,206.88 109.98,204.44 109.8,204.27
GND on BOTTOM: 125.73,28.19 125.48,28.45 125.48,30.23 126.11,30.86 128.91,30.86 129.92,31.88 137.29,31.88 137.54,31.62 137.54,28.57 137.16,28.19
GND on BOTTOM: 130.94,23.75 130.18,24.51 126.75,24.51 125.98,25.27 125.98,27.05 126.49,27.56 136.4,27.56 137.03,26.92 137.03,24.38 136.4,23.75
GND on BOTTOM: 158.19,165.48 158.04,165.63 158.04,166.24 157.81,166.47 155.7,166.47 155.45,166.22 154.25,166.22 154.08,166.4 154.08,167.49 154.89,168.3 154.89,169.45 155.24,169.8 156.72,169.8 156.9,169.62 156.9,168.43 157.23,168.1 158.7,168.1 158.83,167.97 158.83,165.61 158.7,165.48 ; 10 cut-outs
GND on BOTTOM: 110.59,191.82 110.46,191.95 110.46,193.62 110.29,193.8 107.95,193.8 107.67,194.08 107.67,194.72 108.1,195.15 108.1,195.83 107.47,196.47 107.47,197.33 107.65,197.51 108.86,197.51 109.09,197.74 109.09,198.5 108.79,198.81 108.79,200.3 109.14,200.66 111.89,200.66 112.9,199.64 112.9,192.1 112.62,191.82 ; 6 cut-outs
GND on BOTTOM: 142.88,210.31 142.62,210.57 142.62,212.47 143,212.85 143,214.38 143.13,214.5 144.02,214.5 144.53,214 144.53,213.74 144.78,213.49 146.3,213.49 146.43,213.36 146.43,212.85 145.92,212.34 145.92,211.07 145.16,210.31 ; 1 cut-out
GND on BOTTOM: 142.11,222.88 141.6,223.39 141.6,225.04 141.48,225.17 137.67,225.17 137.03,225.81 137.03,227.2 138.1,228.27 144.22,228.27 145.16,227.33 145.16,223.27 144.78,222.88 ; 2 cut-outs
GND on BOTTOM: 217.75,182.5 217.53,182.73 217.53,183.54 217.32,183.74 215.77,183.74 215.72,183.79 215.72,186.77 215.95,186.99 216.94,186.99 217.17,187.22 217.17,188.09 216.87,188.39 215.85,188.39 215.8,188.44 215.8,190.12 216.18,190.5 219.71,190.5 220.14,190.93 220.14,198.93 221.74,200.53 223.39,200.53 223.65,200.28 223.65,199.57 223.63,199.56 223.63,198.77 222.43,197.56 222.43,190.3 222.77,189.95 222.77,188.07 221.97,187.27 221.97,186.13 222.22,185.88 224.56,185.88 224.71,185.72 224.71,182.65 224.56,182.5 223.44,182.5 223.34,182.6 223.34,183.36 223.04,183.67 222.07,183.67 221.87,183.46 221.87,182.6 221.77,182.5
GND on BOTTOM: 34.29,112.52 34.04,112.78 34.04,115.34 34.92,116.23 36.25,116.23 36.91,115.57 38.1,115.57 38.23,115.44 38.23,112.78 37.97,112.52 ; 1 cut-out
GND on BOTTOM: 144.88,100.48 144.4,100.97 144.4,103.3 144.6,103.5 145.34,103.5 145.61,103.77 146.8,103.77 147.78,102.79 147.78,100.71 147.55,100.48 ; 6 cut-outs
GND on BOTTOM: 117.86,117.09 115.95,119 115.95,122.81 119.25,126.11 120.78,126.11 121.79,127.13 127,127.13 127.89,126.24 127.89,118.62 126.36,117.09
GND on BOTTOM: 96.52,97.92 96.14,98.3 96.14,98.81 100.2,102.87 108.46,102.87 108.58,102.74 108.58,98.68 107.82,97.92
GND on BOTTOM: 195.83,172.59 195.45,172.97 195.45,173.99 192.79,176.66 192.53,176.66 192.02,177.16 192.02,180.97 192.41,181.36 197.1,181.36 197.61,180.85 197.61,177.67 196.47,176.53 196.47,172.75 196.32,172.59 ; 7 cut-outs
GND on BOTTOM: 66.99,174.19 66.94,174.24 66.3,174.24 66.29,174.25 66.29,174.69 66.41,174.81 66.41,175.39 66.12,175.67 64.91,175.67 64.76,175.82 64.76,177.25 64.9,177.39 66.12,177.39 66.37,177.64 66.37,179.38 66.21,179.54 64.98,179.54 64.78,179.74 64.78,180.16 64.92,180.3 64.92,180.81 64.78,180.95 64.78,181.32 64.9,181.44 66.16,181.44 66.29,181.56 66.29,183.4 66.13,183.56 65.1,183.56 64.76,183.9 64.76,185.24 64.9,185.38 65.5,185.38 65.52,185.36 66.11,185.36 66.73,185.98 67.79,185.98 68,185.78 68,175.36 67.99,175.36 67.99,174.39 67.79,174.19 ; 25 cut-outs
GND on BOTTOM: 12.95,213.11 12.57,213.49 12.57,217.81 12.83,218.06 17.91,218.06 18.8,217.17 18.8,216.03 18.54,215.77 18.54,213.87 17.78,213.11
GND on BOTTOM: 28.45,124.84 25.15,128.14 25.15,135.76 26.16,136.78 32.89,136.78 33.02,136.65 33.02,135.33 33.99,134.37 33.99,126.36 32.46,124.84 ; 11 cut-outs
GND on BOTTOM: 152.98,214.6 152.91,214.68 152.91,216.23 152.96,216.28 153.06,216.28 153.29,216.51 153.29,218.31 153.03,218.57 153.03,218.59 152.98,218.59 152.83,218.74 152.83,219.3 153.54,220.01 153.54,225.04 153.92,225.43 156.59,225.43 156.84,225.17 156.84,219.51 156.6,219.27 155.26,219.27 154.94,218.95 154.94,214.86 154.69,214.6 ; 2 cut-outs
GND on BOTTOM: 131.06,197.87 130.94,197.99 130.94,198.5 131.19,198.75 131.19,200.03 130.94,200.28 130.81,200.28 130.43,200.66 130.43,201.04 130.56,201.17 131.95,201.17 132.72,200.41 132.72,198.25 132.33,197.87
GND on BOTTOM: 163.73,217.58 162.46,218.85 162.46,228.3 163.14,228.98 170.87,228.98 171.07,228.78 171.07,220.34 170.94,220.22 168.35,220.22 168.05,219.91 168.05,217.68 167.94,217.58 ; 2 cut-outs
GND on BOTTOM: 209.17,11.94 209.04,12.06 209.04,13.46 209.17,13.59 210.19,13.59 210.69,14.1 211.46,14.1 211.71,13.84 211.71,12.06 211.58,11.94 ; 3 cut-outs
GND on BOTTOM: 64.9,112.65 64.69,112.85 64.69,115.32 65.91,116.54 65.91,118.9 65.89,118.92 65.89,119.53 66.23,119.88 68.73,119.88 68.75,119.89 69.27,119.89 69.6,119.56 69.6,113.16 69.09,112.65
GND on BOTTOM: 172.54,159.03 172.47,159.11 172.47,160.02 172.21,160.27 172.21,160.66 172.38,160.82 172.38,161.48 171.81,162.05 171.81,162.33 172.47,162.99 172.47,164.08 172.34,164.21 171.45,164.21 171.15,164.52 171.15,165.02 170.59,165.58 170.59,166.19 171.04,166.65 171.04,168.43 171.03,168.44 171.03,168.87 170.54,169.37 170.54,170.05 170.64,170.15 171.37,170.15 171.6,169.93 173.48,169.93 173.74,169.67 173.74,169.29 173.48,169.04 173.48,167.77 173.35,167.64 173.35,160.91 173.61,160.66 173.61,160.27 173.35,160.02 173.35,159.18 173.2,159.03 ; 16 cut-outs
GND on BOTTOM: 180.44,217.5 178.51,219.43 178.51,222.73 178.74,222.96 178.74,228.22 178.92,228.4 185.8,228.4 186.92,227.28 186.92,220.73 186.66,220.47 185.01,220.47 184.45,219.91 184.45,217.65 184.3,217.5 ; 2 cut-outs
GND on BOTTOM: 131.24,10.64 131.06,10.82 131.06,12.52 131.78,13.23 133.48,13.23 133.6,13.11 133.6,11.86 133.43,11.68 132.31,11.68 132,11.38 132,10.77 131.88,10.64 ; 1 cut-out
GND on BOTTOM: 200.03,123.7 192.28,131.44 187.58,131.44 187.45,131.57 187.45,133.99 187.2,134.24 187.07,134.24 186.94,134.37 186.94,135.64 186.31,136.27 184.91,136.27 184.53,136.65 184.53,140.84 180.09,145.29 180.09,146.81 180.21,146.94 180.21,151.89 179.96,152.15 179.45,152.15 177.16,154.43 177.16,155.57 177.42,155.83 178.94,155.83 179.07,155.96 179.07,158.5 179.45,158.88 180.97,158.88 181.36,159.26 181.36,159.89 181.1,160.15 180.34,160.15 180.21,160.27 180.21,163.58 180.34,163.7 180.72,163.7 181.1,164.08 183.01,164.08 183.13,164.21 183.13,164.59 183.26,164.72 183.39,164.72 183.9,165.23 183.9,165.51 183.97,165.58 184.68,165.58 184.91,165.35 184.91,164.85 185.14,164.62 185.95,164.62 186.18,164.85 186.18,165.48 186.31,165.61 186.69,165.61 186.82,165.48 186.82,164.34 187.07,164.08 187.71,164.08 188.09,164.47 188.09,165.35 188.34,165.61 188.59,165.61 188.85,165.35 188.85,164.72 189.1,164.47 193.8,164.47 195.83,162.43 199.77,162.43 201.42,160.78 201.42,153.16 206.88,147.7 206.88,141.86 210.06,138.68 210.06,124.46 209.3,123.7 ; 18 cut-outs
GND on BOTTOM: 148.46,30.23 148.34,30.35 148.34,32 148.46,32.13 150.5,32.13 151,31.62 151,30.48 150.75,30.23
GND on BOTTOM: outline of 92 points within 10.92,138.56 55.88,208.15 ; 7 cut-outs
GND on BOTTOM: 101.98,112.52 101.73,112.78 101.73,115.57 102.11,115.95 102.49,115.95 102.95,116.41 102.95,118.87 102.92,118.9 102.92,119.51 103.26,119.85 105.77,119.85 105.78,119.86 106.3,119.86 106.63,119.53 106.63,113.28 105.87,112.52
GND on BOTTOM: 42.67,112.52 42.42,112.78 42.42,115.44 42.67,115.7 43.31,115.7 43.69,116.08 43.69,118.9 43.66,118.92 43.66,119.53 44.01,119.88 44.58,119.88 44.83,120.13 44.83,122.38 45.36,122.91 45.97,122.91 46.43,122.45 46.43,119.23 46.44,119.21 46.44,119.13 46.44,119.12 46.48,119.08 46.48,118.87 47.37,117.98 47.37,116.08 47.38,116.07 47.38,115.86 47.65,115.6 49.68,115.6 49.76,115.52 49.76,112.62 49.66,112.52
GND on BOTTOM: 223.27,91.69 223.14,91.82 223.14,96.65 223.52,97.03 228.85,97.03 228.98,97.16 228.98,106.68 229.49,107.19 230.76,107.19 231.39,106.55 231.39,92.71 230.38,91.69
GND on BOTTOM: 195.48,217.6 194.92,218.16 194.92,227.74 195.63,228.45 204.11,228.45 204.6,227.97 204.6,225.93 203.15,224.49 202.41,224.49 202.01,224.08 202.01,221.56 200.91,220.47 200.91,217.7 200.81,217.6 ; 2 cut-outs
GND on BOTTOM: 141.6,28.45 141.48,28.57 141.48,32.89 141.73,33.15 142.49,33.15 142.88,32.77 142.88,28.7 142.62,28.45
GND on BOTTOM: 143.76,198.88 143.45,199.2 142.43,199.2 141.34,200.29 141.34,201.31 140.72,201.93 140.72,203.33 140.97,203.58 144.53,203.58 145.54,202.56 145.54,199.14 145.29,198.88
GND on BOTTOM: 230.76,196.34 229.62,197.49 229.62,198.88 228.98,199.52 228.98,200.79 229.11,200.91 230.89,200.91 231.78,200.03 231.78,196.6 231.52,196.34
GND on BOTTOM: 151.51,43.94 150.24,45.21 150.24,45.34 149.99,45.59 147.7,45.59 147.45,45.85 147.45,47.04 147.4,47.09 143.79,47.09 143.59,47.29 143.59,49.96 144.35,50.72 149.02,50.72 149.33,51.03 149.33,51.28 149.48,51.44 151.13,51.44 151.64,50.93 154.69,50.93 155.45,50.16 156.21,50.16 156.72,49.66 158.88,49.66 159,49.53 159,49.02 158.88,48.9 158.24,48.9 158.01,49.12 155.96,49.12 155.63,48.79 155.63,46.15 155.57,46.1 155.19,46.1 154.94,45.85 154.94,44.2 154.69,43.94 ; 13 cut-outs
GND on BOTTOM: 209.19,31.29 209.02,31.47 209.02,34.11 209.52,34.62 215.01,34.62 215.57,34.06 215.57,32.54 214.63,31.6 211.2,31.6 210.9,31.29 ; 5 cut-outs
GND on BOTTOM: 133.38,17.04 133.2,17.22 132.36,17.22 132.26,17.32 132.26,17.98 132.56,18.29 136.83,18.29 137.06,18.06 137.06,17.65 136.45,17.04 ; 1 cut-out
GND on BOTTOM: 30.1,209.3 29.21,210.19 29.21,211.96 29.46,212.22 35.94,212.22 36.96,211.2 38.61,211.2 38.86,210.95 38.86,209.68 38.48,209.3 ; 2 cut-outs
GND on BOTTOM: outline of 164 points within 0.76,0.76 235.24,235.24 ; 2 cut-outs
GND on BOTTOM: 186.56,4.57 186.18,4.95 186.18,7.49 186.31,7.62 188.47,7.62 188.98,8.13 188.98,14.73 189.15,14.91 190.04,14.91 190.37,14.58 190.37,8.38 188.47,6.48 188.09,6.48 187.83,6.22 187.83,5.71 188.21,5.33 191.64,5.33 192.66,6.35 206.88,6.35 207.9,7.37 211.2,7.37 211.84,6.73 211.84,5.21 211.2,4.57 ; 1 cut-out
GND on BOTTOM: 203.2,61.09 203.07,61.21 203.07,61.85 203.71,62.48 203.71,63.12 203.94,63.35 204.7,63.35 204.77,63.27 204.77,61.98 204.98,61.77 204.98,61.21 204.85,61.09 ; 2 cut-outs
GND on BOTTOM: 219.07,13.08 218.57,13.59 216.79,13.59 216.66,13.72 216.66,14.48 216.79,14.61 219.07,14.61 219.2,14.73 219.58,14.73 219.71,14.61 219.71,13.34 219.46,13.08
GND on BOTTOM: 189.99,68.07 188.85,69.22 188.85,77.47 187.83,78.49 185.93,78.49 183.01,75.56 177.67,75.56 175.39,73.28 164.47,73.28 162.94,74.8 162.94,78.36 167.26,82.68 200.15,82.68 201.42,81.41 201.42,75.69 200.91,75.18 196.72,75.18 195.96,75.95 195.96,80.64 195.58,81.03 194.94,81.03 194.31,80.39 194.31,68.83 193.55,68.07
GND on BOTTOM: 54.1,112.52 54,112.62 54,115.7 54.79,116.48 54.79,118.9 54.76,118.92 54.76,119.53 55.11,119.88 55.11,121.68 56.18,122.76 57,122.76 57.31,122.45 57.31,119.87 57.61,119.57 57.61,119.35 58.47,118.49 58.47,116.08 58.95,115.6 59.28,115.6 59.46,115.42 59.46,113.18 58.8,112.52
GND on BOTTOM: 168.02,159 167.89,159.13 167.89,168.05 168.17,168.33 168.55,168.33 168.78,168.1 168.78,164.52 169.01,164.29 169.37,164.29 169.7,163.96 170.56,163.96 170.69,163.83 170.69,163.12 170.1,162.53 170.1,161.52 170.69,160.93 170.69,159.26 170.43,159 ; 11 cut-outs
GND on BOTTOM: 138.99,115.29 138.3,115.98 138.3,121.79 138.68,122.17 140.34,122.17 140.97,121.54 140.97,115.52 140.74,115.29
GND on BOTTOM: 121.03,193.55 120.07,194.51 120.07,197.54 120.27,197.74 122.81,197.74 122.94,197.61 122.94,196.47 123.57,195.83 123.95,195.83 124.08,195.71 124.08,195.33 123.44,194.69 123.44,193.93 123.06,193.55
GND on BOTTOM: 135.76,62.74 135.33,63.17 135.33,64.97 135.51,65.15 139.95,65.15 140.08,65.02 140.08,62.99 139.83,62.74
GND on BOTTOM: 93.04,147.02 92.58,147.47 92.58,151 93.09,151.51 95,151.51 96.01,150.5 96.01,147.42 95.61,147.02
GND on BOTTOM: 28.83,221.62 28.45,222 28.45,223.65 29.08,224.28 37.72,224.28 38.1,223.9 38.1,222.12 37.59,221.62
GND on BOTTOM: 189.8,101.9 189.7,102 189.7,103.55 189.36,103.89 188.47,103.89 188.09,104.27 188.09,107.57 188.21,107.7 189.23,107.7 189.48,107.44 189.48,106.68 191.26,104.9 191.26,102.11 191.05,101.9 ; 1 cut-out
GND on BOTTOM: 42.67,150.62 42.16,151.13 42.16,154.31 44.2,156.34 46.48,156.34 46.61,156.21 46.61,151.38 45.85,150.62 ; 3 cut-outs
GND on BOTTOM: 161.42,28.19 160.73,28.88 160.73,35.61 160.4,35.94 160.15,35.94 160.02,36.07 160.02,36.32 160.15,36.45 160.6,36.45 160.73,36.58 160.73,38.1 160.6,38.23 160.15,38.23 160.02,38.35 160.02,38.73 159.77,38.99 158.5,38.99 158.12,38.61 158.12,38.35 157.99,38.23 157.73,38.23 157.48,38.48 157.48,38.86 158.24,39.62 160.55,39.62 161.32,38.86 162.18,38.86 162.43,39.12 162.43,39.5 162.56,39.62 163.07,39.62 163.32,39.88 163.32,40.39 163.45,40.51 163.96,40.51 163.96,39.12 164.21,38.86 166.88,38.86 167.64,38.1 168.53,38.1 168.78,38.35 168.78,38.73 168.91,38.86 169.29,38.86 170.81,37.34 170.81,34.04 170.75,33.97 170.75,33.08 170.56,32.89 170.56,29.46 169.29,28.19 ; 2 cut-outs
GND on BOTTOM: 153.9,197.38 153.64,197.64 153.64,198.48 153.97,198.81 153.97,202.67 154.03,202.72 155.85,202.72 156.49,202.08 156.49,199.21 154.71,197.43 154.71,197.38
GND on BOTTOM: 81.28,100.97 84.58,100.97 85.09,100.46 85.09,96.27 84.96,96.14 83.69,96.14 83.57,96.27 83.57,97.03 83.44,97.16 81.41,97.16 81.03,97.54 81.03,100.71
GND on BOTTOM: 170.43,4.57 169.8,5.21 169.8,5.97 169.42,6.35 164.47,6.35 163.96,5.84 163.96,5.08 163.83,4.95 163.07,4.95 162.69,5.33 162.69,7.62 165.1,10.03 167.51,10.03 167.64,9.91 167.64,7.87 168.4,7.11 169.54,7.11 169.8,6.86 171.32,6.86 172.21,5.97 173.74,5.97 173.86,5.84 173.86,4.7 173.74,4.57
GND on BOTTOM: 8.51,201.42 8,201.93 7.11,201.93 6.86,202.18 6.86,203.07 7.11,203.33 9.78,203.33 9.91,203.2 9.91,202.44 9.83,202.36 9.32,202.36 9.14,202.18 9.14,201.55 9.02,201.42 ; 2 cut-outs
GND on BOTTOM: 208.56,21.46 208.48,21.54 208.48,22.61 208.99,23.11 208.99,25.6 208.86,25.73 208.86,26.34 208.91,26.39 210.77,26.39 210.9,26.52 212.32,26.52 213.36,27.56 215.14,27.56 215.57,27.13 215.57,22.94 215.9,22.61 215.9,22.02 215.8,21.92 213.31,21.92 212.85,21.46 ; 15 cut-outs
GND on BOTTOM: 83.82,147.07 83.31,147.57 83.31,153.16 83.44,153.29 87.12,153.29 87.38,153.03 87.38,147.57 86.87,147.07
GND on BOTTOM: 175.9,101.98 175.77,102.11 175.77,103 175.01,103.76 173.61,103.76 173.48,103.89 173.48,104.39 173.61,104.52 174.5,104.52 174.62,104.65 178.69,104.65 179.2,104.14 179.2,102.36 178.82,101.98 ; 9 cut-outs
GND on BOTTOM: 14.1,223.77 13.84,224.03 13.84,224.79 14.35,225.3 16.51,225.3 16.76,225.55 17.4,225.55 17.65,225.3 17.65,224.66 16.76,223.77 ; 2 cut-outs
GND on BOTTOM: 120.42,94.61 120.02,95.02 120.02,97.03 120.14,97.16 123.06,97.16 123.19,97.28 123.19,98.3 122.68,98.81 122.68,100.08 122.81,100.2 125.35,100.2 126.24,99.31 126.24,95 125.86,94.61 ; 4 cut-outs
GND on BOTTOM: 93.73,69.6 91.57,71.75 91.57,80.64 95.25,84.33 95.25,93.98 95.5,94.23 96.39,94.23 99.19,97.03 108.08,97.03 109.35,98.3 109.35,101.85 109.73,102.23 110.36,102.23 111.12,101.47 111.12,95.38 110.62,94.87 102.74,94.87 100.46,92.58 100.46,89.92 97.54,87 97.54,80.14 96.39,78.99 96.39,71.75 96.14,71.5 94.87,71.5 94.74,71.37 94.74,69.72 94.61,69.6
GND on BOTTOM: 133.25,102.29 132.41,103.12 129.16,103.12 129.03,103.25 129.03,104.27 129.29,104.52 133.73,104.52 134.24,105.03 134.24,108.33 134.49,108.58 135.25,108.58 135.38,108.46 135.38,104.27 134.92,103.81 134.92,103.02 134.19,102.29
GND on BOTTOM: 110.62,26.42 110.6,26.43 109.84,26.43 108.84,27.43 108.84,29.84 108.97,29.97 108.97,31.57 107.7,32.84 107.7,34.54 107.95,34.8 111.12,34.8 111.38,35.05 112.52,35.05 112.65,34.92 113.54,34.92 114.17,34.29 114.17,33.4 114.4,33.17 114.4,32.82 113.97,32.38 112.39,32.38 111.89,31.88 111.89,30.73 112.14,30.48 114.3,30.48 114.43,30.35 114.43,27.3 114.3,27.18 113.28,27.18 112.52,26.42 ; 4 cut-outs
GND on BOTTOM: 199.06,38.71 198.42,39.34 198.42,43.48 199.59,44.65 203.73,44.65 204.08,44.31 204.08,42.81 204.09,42.8 204.09,41.4 204.85,40.64 204.85,39.17 204.39,38.71 ; 13 cut-outs
GND on BOTTOM: 70.64,174.5 70.13,175.01 70.13,186.82 70.36,187.05 70.64,187.05 70.95,186.74 70.95,186.25 71.24,185.97 71.77,185.97 71.88,185.86 71.88,174.75 71.63,174.5 ; 17 cut-outs
GND on BOTTOM: 154.69,225.81 154.56,225.93 154.56,228.09 155.4,228.93 156.13,228.93 156.34,228.73 156.34,228.24 156.21,228.12 156.21,226.06 155.96,225.81
