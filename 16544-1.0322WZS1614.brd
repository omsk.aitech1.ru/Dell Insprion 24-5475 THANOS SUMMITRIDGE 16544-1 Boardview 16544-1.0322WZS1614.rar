# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBAT1: length 5.9
  TOP w0.559: R246.1 179.14,21.67 v1(179.2,21.62)
  TOP w0.762: BT1.1 177.27,19.4 179.2,21.34 v1(179.2,21.62)
  BOTTOM w0.508: v2(179.04,20.8) 179.04,21.46 v1(179.2,21.62)
VBAT1_R: length 94.8
  TOP w0.508: 177.62,24.08 177.82,23.88 R246.2 ; R2669.1 125.93,58.88 v1(126.21,59.16) ; R247.1 180.21,23.88 R246.2 ; R246.2 179.14,24.3 180.02,25.18 180.45,25.18
  TOP w0.559: 176.94,24.77 177.62,24.08
  TOP w0.711: D4.2 181.24,21.6 181.24,22.95 v1(181.36,23.06) 182.02,23.72 182.02,25.18
  TOP w0.762: 180.45,25.18 182.02,25.18 Q16.G ; 176.94,24.77 170.41,24.77 167.74,27.43 165.68,27.43 v1(165.56,27.56)
  L3 w0.762: v1(142.54,35.46) 142.54,34.65 143.59,33.6 145.8,33.6 149.48,29.92 149.48,25.4 149.86,25.02 149.92,25.02 v1(149.94,25)
  BOTTOM w0.508: v1(126.21,59.16) 129.64,59.16 130.18,58.63 130.18,58.55 132.33,56.39 133.48,56.39 135.28,54.58 135.28,53.16 136.27,52.17 136.27,51.31 138.2,49.38 138.2,41.5 141.73,37.97 141.73,36.27 v1(142.54,35.46) ; v1(181.36,23.06) 181.25,22.96 TP32.1
  BOTTOM w0.762: v1(149.94,25) 150.89,25 151.68,24.21 151.68,22.27 152.37,21.58 154.63,21.58 160.6,27.56 v1(165.56,27.56)
VBAT_SB_N: length 1.2
  BOTTOM w0.508: v5(130.05,43.18) 129.54,42.67 v1(129.03,42.67)
VCC3_CAM:
  vias: v3(222.22,67.39)
VDDIO_AUDIO: length 23.1
  TOP w0.457: CPU1.AM15 v6(158.55,168.55)
  L3 w0.508: v6(158.55,168.55) 158.51,168.55 157.61,169.44 157.61,170.81 156.87,171.56 154.54,171.56 153.8,170.81 148.64,170.81 147.88,170.05 147.88,169.04 147.37,168.53 v1(146.94,168.53)
  BOTTOM w0.508: C1081.1 143.23,168.83 R2613.1 ; C1081.1 144.28,168.38 R2614.1 ; C1081.1 143.64,169.24 v2(145.58,169.24) 146.23,169.24 v1(146.94,168.53)
VDDNB_SN1: length 2.9
  TOP w0.508: PC171.1 214.82,189.83 v3(214.73,189.92) 213.92,189.92 PR149.2
VDDP_S5_PG: length 296.8
  TOP w0.114: R2537.2 115.89,41.68 110.19,41.68 v1(109.6,42.27) ; v1(92.74,14.05) 92,14.78 92,19.08 93.9,20.98 v3(97.18,20.98) 97.92,20.24 98.68,20.24 100.13,21.69 v1(100.3,21.69) ; PR334.2 145.41,212.69 PR333.2 PR355.2 142.37,212.69 141.95,212.27 v1(140.94,212.27)
  L4 w0.114: v1(140.94,212.27) 139.85,213.36 138.71,213.36 138.33,213.74 133.06,213.74 132.6,214.2 129.09,214.2 129.08,214.19 128.72,214.19 128.67,214.14 127.18,214.14 126.14,213.11 124.99,213.11 121.66,209.77 121.66,206.69 121.66,206.69 121.66,205.73 121.56,205.63 121.56,205.5 121.03,204.97 121.03,193.42 120.52,192.9 120.52,179.27 116.99,175.75 116.99,160.92 114.65,158.57 114.36,158.57 111.76,155.97 111.76,153.02 113.18,151.6 113.18,145.73 112.78,145.33 112.78,140.93 112.28,140.43 112.28,136.43 114.66,134.06 114.66,126.31 114.07,125.72 114.07,113.13 104.82,103.88 98.61,103.88 92.32,97.59 92.32,85.18 86.96,79.82 86.96,56.1 88.3,54.76 88.3,32.93 87.15,31.79 87.15,19.63 v1(92.74,14.05)
  L6 w0.102: v1(109.6,42.27) 109.25,42.62 107.79,42.62 107.46,42.95 106.1,42.95 102.16,39.01 102.16,36.87 99.92,34.63 99.92,27.18 100.33,26.77 100.33,22.78 100.3,22.76 v1(100.3,21.69)
VDDP_S5_PG_EC: length 7.4
  TOP w0.114: R2537.1 117.63,41.83 v3(118.58,42.77) 118.58,43.6 118.08,44.09 115.82,44.09 115.25,44.67 KBC1.61
VDDQ_BLEED_R1: length 3.8
  TOP w0.114: Q25.6 213.7,140.63 R400.2 v3(215.66,140.46)
VDDQ_BLEED_R2: length 5.4
  TOP w0.114: Q25.2 215.94,143.04 216.87,142.11 v3(217.23,142.11) 217.49,142.37 R399.2 216.41,143.26 215.98,143.69 Q25.3
0D6V_S0: length 7.3
  TOP w0.203: 229.16,135.97 PG82.1 PG80.1 228.4,136.04
  TOP w0.279: v1(146.99,104.75) 147.02,104.72 147.88,104.72 149.12,105.97 DIMM1.258
  TOP w0.305: v6(147.83,93.09) 148.63,93.09 149.12,92.6 DIMM2.258
  vias: v2(143.36,104.14) v2(231.8,135.86) v4(230.25,136.02) v4(230.25,135) v5(160.81,87.53) v5(223.52,86.74)
0D8V_PG: length 1.3
  BOTTOM w0.114: TP120.1 118.92,212.65 PR326.1
0D8V_VGA: length 37
  TOP w0.203: PG195.2 116.49,191.9 PG192.2 PG196.2 PG193.2 118.28,191.64 118.28,191.33 v4(118.62,190.98)
  TOP w0.254: v4(115.8,190.93) 115.6,191.13 PG195.2
  TOP w0.381: v6(82.35,178.79) 82.35,178.77 82.6,178.51 GPU1.AD36 ; v6(82.18,169.2) 81.8,169.57 GPU1.AN35 ; GPU1.AJ30 77.8,173.55 v6(78.25,174) ; GPU1.AA34 81,180.43 v6(81.39,180.04) 81.8,180.45 GPU1.AA35 ; GPU1.AE35 81.8,176.7 v6(82.21,176.29) ; GPU1.AJ35 81.8,173.2 v6(82.2,172.8) 81.8,172.4 GPU1.AK35 81.8,172.02 v6(82.2,171.62) 82.26,171.56 82.26,171.45 82.6,171.12 GPU1.AM36 ; GPU1.AG36 82.6,174.85 v6(82.25,175.2) 81.8,175.65 GPU1.AF35
  L6 w0.381: v6(78.25,174) 78.78,174 79.43,173.35 81.65,173.35 v6(82.2,172.8)
  BOTTOM w0.381: v6(82.2,171.62) 81.79,172.03 C611.1 ; v6(82.2,171.62) 81.55,170.97 R718.1 ; v6(82.2,171.62) 82.2,171.49 82.94,170.75 C616.1 ; v6(82.2,171.62) v6(82.2,172.8) ; v6(82.2,172.8) 82.2,175.15 v6(82.25,175.2) 82.3,175.25 C608.1 83.01,175.49 v6(82.21,176.29) 82.36,176.29 82.87,176.8 C609.1 83.08,177.22 C610.1 82.74,178.4 v6(82.35,178.79) 81.39,179.74 v6(81.39,180.04) 81.49,180.14 C619.1 81.26,180.77 80.85,180.77 80.63,180.56 C618.1 ; v6(82.2,172.8) 82.67,173.27 C617.1 ; C622.1 78.25,172.91 v6(78.25,174)
  vias: v4(116.76,190.91) v4(117.7,190.91) v5(117.09,189.99)
0D775V_S5: length 22.9
  TOP w0.508: v1(122.73,215.11) 122.73,215.04 122.81,214.96 PG153.2
  L6 w1.016: v1(131.69,211) 134.47,211 135.48,209.98 135.48,205.46 v1(134.24,204.22)
  BOTTOM w1.016: v1(122.73,215.11) 122.73,214.07 124,212.8 v2(125.25,212.8) 130.1,212.8 131.69,211.21 v1(131.69,211)
0D775V_VDDCR_SOC_S5: length 63.4
  TOP w0.381: CPU1.AJ18 160.77,165.23 160.23,165.23 CPU1.AK18 159.93,165 v6(159.51,164.58)
  L3 w0.762: v1(141.36,161.38) 144.87,161.38 146.05,162.56 149.89,162.56 151.03,163.7 153.77,163.7 153.95,163.88
  L4 w0.508: v1(139.13,190.66) 141.35,192.88 141.35,195.58 139.95,196.98 136.27,196.98 v4(135.13,198.12)
  L6 w0.508: v1(139.13,190.66) 138.73,190.27 138.73,187.68 143.64,182.78 143.64,176.28 144.17,175.74 144.17,166.01 141.36,163.21 v1(141.36,161.38)
  BOTTOM w0.508: v1(141.36,161.38) 141.36,161.35 141.17,161.16 140.26,161.16 PC62.1 ; C135.1 159.6,164.49 v6(159.51,164.58)
  vias: v2(135.13,199.19)
1D2V_MEM_S3: length 202.2
  TOP w0.203: v4(221.39,104.27) 221.64,104.01 PG84.2 PG86.2 PG81.2 PG79.2 PG78.2 PG76.2 PG75.2 PG85.2 222.33,97.84
  TOP w0.254: DIMM2.135 181.87,101.48 ; DIMM2.163 172.87,101.42 ; DIMM2.112 187.62,90.39 v6(187.48,90.25) ; DIMM2.159 173.87,101.41
  TOP w0.279: DIMM1.142 180.13,105.3 ; DIMM1.153 175.37,113.15 176.51,112.02 v6(176.56,112.02) ; DIMM1.112 187.62,105.82 187.6,105.79 187.6,105.66 187.22,105.28 ; DIMM1.130 183.13,105.22 ; DIMM1.154 175.12,105.34 ; DIMM1.124 184.62,105.28 ; DIMM1.159 173.87,116.82 v6(173.74,116.95) 173.46,116.95 172.87,116.36 DIMM1.163 ; v6(185.83,113.19) 185.83,113.2 184.87,114.16 DIMM1.123 ; DIMM1.118 186.13,107.85 187.93,109.65 v6(188.51,109.65) ; DIMM1.111 187.87,116.3 v6(187.11,117.06) 186.38,116.33 186.37,116.33 DIMM1.117 ; DIMM1.135 181.87,113.88 182.14,113.61 182.17,113.61 v6(182.48,113.31) ; v6(176.56,108.44) 176.62,108.37 DIMM1.148 ; v6(182.49,116.5) 182.97,116.5 183.37,116.09 DIMM1.129 ; v6(182.12,105.39) 181.62,105.89 DIMM1.136
  TOP w0.305: CPU1.AC32 v6(167.5,151.5) ; v6(164.51,150.55) 164.07,151 CPU1.AF32 ; v6(172.22,108.49) 173.16,108.49 173.63,108.02 DIMM1.160 ; DIMM2.111 187.87,101.38 187.6,101.65 ; DIMM2.118 186.12,90.48 v6(185.87,90.22) ; v6(175.51,149.48) 175.54,149.52 176.2,149.52 176.68,150 CPU1.N33 ; DIMM2.117 186.37,101.51 ; DIMM1.147 176.87,113.97 177.58,113.27 177.58,112.01 177.87,111.71 v6(178.13,111.71) ; CPU1.M34 v6(178.5,149.5) ; CPU1.V34 172,148.89 v6(172.4,148.5) 172.89,148 CPU1.U35 CPU1.T36 ; DIMM2.154 175.12,93.11 175.13,93.11 175.13,93.59 175.37,93.83 v6(175.39,93.83) ; CPU1.Y32 v6(169.5,151.5) ; DIMM2.141 180.37,97.59 180.22,97.43 v6(179.76,97.43) ; v6(181.88,90.24) 181.62,90.5 DIMM2.136 ; DIMM2.148 176.62,92.7 v6(177.12,93.19) ; DIMM2.142 180.12,90.35 v6(180.23,90.24) ; DIMM2.124 184.62,90.63 v6(184.22,90.22) ; v6(182.49,117.25) 181.29,117.25 180.37,116.33 DIMM1.141 ; CPU1.P35 176,148.03 v6(175.48,148.54) 175.03,149 CPU1.R34 CPU1.T33 ; DIMM2.130 183.12,90.53 v6(183.43,90.22) ; CPU1.AE30 v6(164.5,153.5) CPU1.AF29 ; CPU1.W33 CPU1.W34 ; DIMM2.129 183.37,101.78 ; DIMM2.160 173.63,92.81 173.54,92.9 173.54,95.35 v6(173.79,95.6) ; DIMM2.147 176.87,101.51 ; 184.87,101.37 DIMM2.123 ; CPU1.M31 v6(178.5,151.5) CPU1.L32 ; DIMM2.153 175.37,101.56
  TOP w0.33: CPU1.U32 172.74,151.26 172.74,151.36 v6(172.51,151.59) ; v6(170.54,143.5) 170.54,143.51 170.54,143.53 171,143.99 CPU1.W39 ; CPU1.P32 v6(176.5,151.5) ; v1(168.47,151.47) CPU1.AB32 ; CPU1.M37 v6(177.5,146.5) CPU1.N36 ; CPU1.L38 CPU1.K39 180,143.48 179.98,143.46 179.98,143 179.57,142.58 179,142.58 v6(178.99,142.6) ; CPU1.T39 174,143.37 v6(173.85,143.23) ; v6(164.72,142.99) 165,143.27 CPU1.AE39 ; CPU1.P38 176,145.09 175.09,146 CPU1.R37 175,146.03 v6(175.49,146.53) ; v6(165.56,149.51) 165.07,150 CPU1.AE33 ; v6(176.99,143.33) 177,143.34 CPU1.N39 ; v6(162.91,141.94) 162.89,141.94 162,142.83 CPU1.AH39 ; CPU1.AD37 v6(165.5,146.5) CPU1.AE36 ; CPU1.AB33 v6(168.5,150.5) ; v6(168.01,143.25) 168.01,143.53 168,143.54 CPU1.AB39 CPU1.AC38 ; CPU1.Y35 170,148.03 v6(170.49,148.52) 170.97,149 CPU1.W34 ; CPU1.AA37 v6(169.5,145.5) CPU1.Y38 ; CPU1.AB36 v6(168.5,146.5) ; CPU1.K36 v6(179.5,147.5) CPU1.L35 ; CPU1.U38 CPU1.V37 ; CPU1.AG37 v6(163.5,145.5) CPU1.AF38 ; v6(164.5,148.5) CPU1.AF35 CPU1.AG35 ; CPU1.AC35 v6(166.5,148.5) ; v1(170.49,146.54) 170.96,147 CPU1.W36 ; CPU1.R31 v6(175.5,152.5) ; CPU1.AD34 v6(166.5,149.5)
  TOP w0.381: CPU1.R28 v6(174.5,155.5) CPU1.T27 ; CPU1.Y29 v6(169.5,154.5) CPU1.AA28 v6(168.5,155.5) CPU1.AB27 ; CPU1.W28 171,155.03 v6(170.49,155.54) 170.03,156 CPU1.Y27 ; v6(172.41,146.5) 172,146.1 CPU1.V37 ; CPU1.M29 v6(177.5,153.5) CPU1.N30 ; CPU1.P27 176.5,155.5 v6(176.53,155.5) 176.53,155.47 CPU1.N28 176.48,154.48 v6(176.48,154.46) 176.46,154.46 CPU1.P29 ; v6(170.47,151.51) 170,151.98 CPU1.Y31 ; v6(168.5,153.5) CPU1.AB29 v6(167.5,154.5) CPU1.AC28 v6(166.5,155.5) CPU1.AD27 ; CPU1.V31 171.97,152 v6(171.53,151.56) ; CPU1.U30 v6(172.5,153.5) CPU1.V29 ; CPU1.V27 v6(172.5,155.5) CPU1.U28 v6(173.52,154.48) CPU1.T29 ; CPU1.AA34 CPU1.Y35 ; CPU1.AD31 v6(165.51,152.5) CPU1.AE30 ; v6(164.51,150.55) 164.51,150.49 CPU1.AE33 v6(164.5,149.5) ; CPU1.AF32 CPU1.AG33 CPU1.AG34 CPU1.AG35 ; v6(167.5,151.5) CPU1.AB31
  TOP w0.406: CPU1.AC30 v6(166.5,153.5) CPU1.AD29 v6(165.5,154.5) CPU1.AE28 v6(164.5,155.5) CPU1.AF27
  TOP w0.508: R2499.1 186.34,128.78 R8.1 186.34,130.48 v1(186.13,130.69) ; R117.1 175.9,85.78 176.63,85.04 177.88,85.04 178.49,85.65 178.49,90.25 v1(178.44,90.3) ; R400.1 213.87,136.67 v1(213.6,136.41) ; R14.1 187.39,127.92 v1(186.3,127.92)
  BOTTOM w0.203: 222.33,97.87 PG85.2 PG75.2 PG76.2 PG78.2 PG79.2 PG81.2 PG86.2 PG84.2 PG65.2
  BOTTOM w0.508: v1(213.6,136.41) 212.57,135.38 212.57,123.6 210.36,121.39
  vias: v2(154.48,120.07) v2(167.49,138) v2(168.28,101.37) v2(211.63,90.7) v2(214.38,117.53) v4(221.39,103.35) v4(221.39,102.44) v4(221.39,101.52) v4(221.39,100.61) v4(221.39,99.69) v4(221.39,98.76) v4(221.44,97.76) v4(221.39,96.75) v5(176.17,126.24) v5(180.64,133.53) v6(163.22,139.98) v6(163.5,127.81) v6(163.5,125.96) v6(163.47,125.09) v6(163.64,134.31) v6(163.64,133.42) v6(163.64,132.54) v6(163.64,131.65) v6(163.64,130.76) v6(163.64,129.87) v6(164.58,141.09) v6(164.58,139.18) v6(165.59,148.49) v6(165.98,142.49) v6(166.24,158.5) v6(167.46,158.55) v6(168.04,141.28) v6(169.29,158.45) v6(170.48,141.5) v6(170.46,139.24) v6(171.35,158.5) v6(172.19,112.17) v6(172.19,110.67) v6(172.9,158.52) v6(173.36,97.36) v6(173.7,102.44) v6(173.84,141.32) v6(173.84,140.03) v6(174.42,158.6) v6(174.98,142.7) v6(174.97,140.79) v6(175.87,96.49) v6(176,94.94) v6(176.58,110.57) v6(177.01,141.36) v6(177.55,97.1) v6(177.65,95.53) v6(177.98,93.93) v6(178.16,109.2) v6(178.19,107.04) v6(179.7,94.64) v6(180.02,104.11) v6(180.38,93.52) v6(180.97,142.67) v6(180.95,141.38) v6(182.14,111.18) v6(182.12,104.09) v6(182.07,102.79) v6(182.22,109.05) v6(183.11,97.36) v6(183.16,95.08) v6(183.59,108.56) v6(183.66,112.13) v6(183.66,110.71) v6(184.65,133.13) v6(184.65,132.24) v6(184.65,131.35) v6(184.65,130.46) v6(184.63,129.56) v6(185.07,98.45) v6(185.09,94.72) v6(185.23,96.23) v6(185.67,105.33) v6(185.7,104.27) v6(185.67,103.3) v6(186.05,111.86) v6(186.04,109.69) v6(186.77,95.6) v6(188.51,111.83) v6(189.23,93.93) v6(189.99,94.89) v6(190.89,112.87) v6(190.89,110.73) v6(190.89,109.3) v6(191.54,96.09)
1D5V_DVDD_IO_S5: length 13.3
  TOP w0.203: U6.19 206.1,41.16 206.25,41.02 206.93,41.02 207,40.96
  TOP w0.508: v1(208.74,40.03) 209.09,40.39 R2581.1 208.76,41.78 207.94,40.96 207,40.96
  BOTTOM w0.508: R269.1 L6.1 C311.1 208.96,38.56 C310.1 207.68,38.56 v2(207.56,38.68) 207.56,38.93 208.66,40.03 v1(208.74,40.03)
1D05V_PCH_S0:
  vias: v2(149.28,43.74) v2(163.53,48.74) v3(141.35,46.76) v3(144.48,46.02) v3(147.96,44.68) v4(144.7,44.6) v4(144.65,43.69) v4(145.62,43.71) v4(146.08,44.63) v4(147.07,44.07) v5(163.42,41.76) v6(150.6,43.4) v6(150.6,42.6) v6(151.4,43.4) v6(151.4,42.6) v6(153,43.4) v6(153,42.6) v6(154.6,43.4) v6(154.6,42.6) v6(155.4,43.42) v6(155.4,42.62) v6(156.2,44.2) v6(156.2,43.4) v6(156.2,42.6) v6(157,48.2) v6(157,47.4) v6(157.8,41) v6(158.6,41) v6(159.4,49) v6(161,48.2) v6(161.8,41) v6(162.6,49.8) v6(162.6,41) v6(164.2,49.8) v6(164.2,48.2) v6(164.2,47.4) v6(164.2,45.8) v6(164.2,45) v6(164.2,43.4) v6(164.2,42.6) v6(166.6,41)
1D05V_PCH_S0_CT1: length 3
  TOP w0.203: v1(140.97,40.28) 141.18,40.07 U39.12
  BOTTOM w0.254: C999.1 141.76,39.5 141.71,39.55 v2(141.33,39.55) 140.97,39.9 v1(140.97,40.28)
1D05V_PCH_S0_EN: length 4.1
  TOP w0.114: C997.1 145.05,39.88 144.86,40.07 U39.3 ; C997.1 145.92,39.89 145.92,40.49 146.27,40.83 R2411.2 ; C997.1 145.91,39.26 v3(146.3,38.86)
1D05V_PCH_S0_L:
  vias: v3(138.99,40.13)
1D05V_PCH_S5: length 3.6
  TOP w0.254: 143.51,34.52 PG129.2 ; PG127.2 146.56,34.57 ; 145.8,34.52 PG126.2 ; PG123.2 145.03,34.65 ; 144.27,34.57 PG124.2
  TOP w0.305: v6(155.63,40.89) 155.63,40.92 155.7,41 155.7,41.3 PCH1.V7
  TOP w0.356: PCH1.W15 v6(161.8,40.2)
  BOTTOM w0.508: v6(155.63,40.89) 155.8,41.07 156.4,41.07 C263.1 ; v6(161.8,40.2) 161.8,40.2 C264.1
  vias: v3(144.75,37.9) v4(144.53,36.7) v4(144.53,35.69)
1D05V_PCH_S5_PG: length 102.9
  TOP w0.114: R2474.2 117.47,43 117.75,43.28 v1(117.78,43.31)
  L4 w0.114: v1(143.1,14.15) 143.1,13.79 140.84,11.53 135.9,11.53 135.55,11.88 134.44,11.88 132.44,9.88 124.27,9.88 123.58,9.19 122.89,8.5 115.8,8.5 115.78,8.48 114.04,8.48 114.02,8.5 113.89,8.5 113.07,7.68 111.82,7.68 111.28,8.23 111.28,8.32 110.25,9.35 105.83,9.35 99.49,15.68 99.49,17.45 98.12,18.82 98.12,20.73 v1(98.3,20.9)
  L6 w0.102: v1(98.3,20.9) 98.78,21.39 98.78,22.32 99.47,23 99.47,25.69 99.05,26.11 98.91,26.25 98.91,34.62 101.45,37.16 101.45,39.62 100.08,41 v1(100.08,44.07)
  BOTTOM w0.114: v1(100.08,44.07) 100.86,44.86 103.56,44.86 104.15,44.27 v5(116.43,44.27) 116.82,44.27 v1(117.78,43.31) ; PR336.1 143.88,14.12 143.13,14.12 v1(143.1,14.15)
1D05V_PCH_S5_PG_EC: length 4.5
  TOP w0.114: R2474.1 116.09,43.24 115.52,43.81 114.68,43.81 v3(114.3,43.43) 114.05,43.69 114.05,45.4 KBC1.58
1D05V_S0:
  vias: v2(134.16,169.9) v2(145.24,172.03) v2(151.08,164.11) v2(151.23,170.71) v2(155.45,163.63) v4(127.53,200.38) v4(128.4,200.03) v4(128.88,197.43) v4(129.51,198.12) v4(131.55,187.45) v4(131.9,188.7) v4(132.51,187.76) v4(134.04,168.15) v4(135.28,168.25) v4(136.65,168.2) v6(155.5,164.54) v6(156.5,164.5) v6(156.49,163.48) v6(156.5,162.44) v6(157.5,164.5) v6(157.48,163.47) v6(157.5,162.44) v6(158.52,164.57)
1D05V_S0_EN: length 4.1
  TOP w0.114: U36.4 123.42,197.27 C971.1 R1217.2 122.17,198.12 v3(122.43,198.37)
1D5V_S5: length 222.5
  TOP w0.254: PG151.2 139.88,132.87 ; PG152.2 140.64,132.84
  L3 w0.508: v1(217.78,36.86) 217.78,40.34 221.36,43.92 221.36,59.26 209.65,70.97 209.65,72.47 v1(205.77,76.35)
  L4 w0.508: v1(205.77,76.35) 204.63,76.35 204.55,76.28 203.51,76.28 203.43,76.2 202.86,76.2 202.28,76.78 192.17,76.78 v1(192.1,76.85)
  L6 w0.508: v1(137.79,133.6) 137.79,129.89 140.79,126.9 140.79,124.24 141.33,123.7 141.33,112.63 142.75,111.21 142.75,93.22 143.64,92.33 143.64,89.79 145.54,87.88 145.54,86.87 151.56,80.85 155.63,80.85 157.07,82.3 157.63,82.3 158.22,81.71 159.74,81.71 160.1,82.07 160.1,83.6 163.16,86.66 182.07,86.66 191.88,76.85 v1(192.1,76.85)
  BOTTOM w0.508: L6.2 211.2,36.88 211.2,35.69 211.53,35.36 214.91,35.36 v2(215.44,35.89) 216.46,36.91 217.73,36.91 v1(217.78,36.86) ; v1(137.79,133.6) 137.77,133.63 136.45,133.63 136.43,133.61 134.11,133.61 132.21,135.51 132.21,138 133.76,139.55 133.76,144.86 136.05,147.15 139.15,147.15 140.11,148.11 141.45,148.11 142.39,149.05 142.39,154.48 143.61,155.7 143.61,165.56 143.23,165.94 R2613.2
1D05V_S5: length 19.6
  TOP w0.203: 151.87,198.48 151.61,198.73 PG108.2 PG107.2 PG111.2 PG113.2 PG115.2 148.24,198.29
  TOP w0.381: v6(160.18,166.91) 160.91,166.91 CPU1.AJ16 ; v6(160.36,166.19) 160.55,166 CPU1.AJ17
  BOTTOM w0.203: 151.97,198.48 151.73,198.71 PG118.2 PG119.2 PG117.2 149.79,198.71 PG116.2 PG114.2 147.9,198.71 147.67,198.48
  BOTTOM w0.254: v6(160.18,166.91) 160.28,166.8 160.76,166.8 160.96,167 161.72,167 162.02,167.3 162.02,172.67 161.69,173 160.97,173 R84.1
  vias: v1(127.39,206.98) v1(127.85,209.19) v1(128.33,207.04) v1(128.65,209.3) v1(129.29,201.22) v1(129.9,200.74) v1(139.57,202.95) v2(147.68,197.76) v4(123.6,199.87) v4(124.84,201.8) v4(124.79,196.32) v4(124.84,195.33) v4(146.15,185.55) v4(146.99,186.11) v4(148.69,197.76) v4(149.71,197.76) v4(150.85,197.76) v4(151.99,197.76) v6(126.24,199.19) v6(126.24,198.25) v6(126.24,197.31)
1D5V_S5_PG: length 1.3
  TOP w0.114: PR214.1 127.61,126.23 TP119.1
1D05V_S5_PWRGD: length 115.1
  TOP w0.114: R486.1 v3(99.43,226.21) 98.68,226.21 v1(98.35,225.88) ; v1(11.35,206.12) 11.28,206.12 11.07,206.32 PR347.2
  L3 w0.114: v1(11.35,206.12) 9.63,206.12 6.45,209.3 6.45,214.52 8.64,216.7 8.64,218.31 13.18,222.86 15.47,222.86 17.39,224.78 25.28,224.78 25.78,224.28 39.15,224.28 43.48,228.61 95.27,228.61 97.99,225.88 v1(98.35,225.88)
1D5V_VDDBT_RTC: length 175.8
  TOP w0.381: v6(159.51,168.52) 159,168.01 CPU1.AL15
  TOP w0.508: 130.99,48.72 R2770.2 130.4,51.02 129.95,50.57 v1(129.72,50.57)
  L3 w0.508: v1(138.99,86.46) 137.08,88.37 137.08,93.68 136.07,94.68 136.07,96.37 136.66,96.96 136.66,98.72 137.01,99.06 137.01,100.41 138.79,102.18 138.79,129.64 139.01,129.86 139.01,142.65 138.3,143.36 137.16,143.36 136.47,144.04 136.47,145.4 134.04,147.84 134.04,152.26 134.18,152.4 134.18,154.9 134.44,155.16 134.44,156.44 135.56,157.56 135.61,157.56 136.11,158.06 136.11,159.1 134.67,160.53 134.67,161.63 135.55,162.51 138.11,162.51 139.74,164.14 142.25,164.14 144.99,166.88 145.68,166.88 146.44,166.88 146.51,166.81 147.36,166.81 147.75,167.2 147.75,167.69 149.22,169.16 156.46,169.16 157.69,167.94 158.89,167.94 159.47,168.52 v6(159.51,168.52) ; v1(129.72,50.57) 129.72,55.22 129.21,55.73 129.21,57.96 130.02,58.78 130.02,62.1 129.01,63.12 127.76,63.12 127.38,63.5 127.38,71.76 123.32,75.83 123.32,79.2 v1(123.93,79.81)
  BOTTOM w0.254: C142.1 158.09,168.79 158.34,169.04 158.99,169.04 v6(159.51,168.52)
  BOTTOM w0.508: v1(123.93,79.81) 124.04,79.92 124.04,79.98 v5(126.24,82.17) 126.24,88.01 127.13,88.9 127.92,88.9 129.19,87.63 132.84,87.63 134.01,86.46 v1(138.99,86.46) ; v6(159.51,168.52) 160.25,169.26 C141.1
1D8V_HDT: length 40.4
  TOP w0.508: v1(226.06,156.46) 225.43,157.1 R2784.2 225.26,157.33 HDT1.19 ; v1(212.47,152.4) 214.78,152.4 215,152.61 R20.1 ; v1(225.04,146.18) 224.76,145.9 HDT1.1
  L3 w0.508: v1(226.06,156.46) 226.47,156.06 226.47,147.6 v1(225.04,146.18) ; v1(212.47,152.4) 212.42,152.35 v1(212.42,148.77)
  L4 w0.508: v1(225.04,146.18) 223.14,146.18 218.67,150.65 217.02,150.65 215.26,152.4 v1(212.47,152.4)
  BOTTOM w0.508: v1(212.42,148.77) 211.46,147.8 Q80.S
  vias: v5(211.8,151.38)
1D8V_KBC: length 17.9
  TOP w0.356: RN2406.2 126.28,63.16 v1(125.73,62.61) 125.63,62.71 RN2406.1
  TOP w0.381: R2729.2 126.17,75.88 R2671.1 126.17,74 126.03,73.86 126.03,73.43 126.04,73.43 U45.8 125.47,71.6 v1(125.17,71.6)
  L3 w0.381: v1(125.17,71.6) 125.17,68.83 125.25,68.76 125.25,63.09 v1(125.73,62.61)
  BOTTOM w0.381: v2(126.36,63.34) 126.34,63.33 126.34,63.22 v1(125.73,62.61)
1D8V_S0: length 506.6
  TOP w0.203: C418.1 198.91,31.19 197.56,29.84 U8.17 ; U6.24 206.16,43.16 206.68,43.69 207.61,43.69 v1(207.66,43.64) ; U7.17 214.4,29.08 v1(214.5,29.18)
  TOP w0.356: RN1.2 197.73,168.1 197.96,168.33 ; RN1.1 197.27,167.45 197.37,167.35 197.96,167.35
  TOP w0.381: CPU1.AK20 v6(160.58,162.48)
  TOP w0.406: CPU1.AJ20 v6(160.58,163.48)
  TOP w0.508: Q87.D 121.6,116.98 v1(120.19,115.57) ; R22.1 197.05,170.1 197.62,169.53 197.62,168.9 197.96,168.56 197.96,167.35 R32.1 199.01,167.21 201.6,167.21 202.69,166.12 v1(202.69,165.2) 202.23,164.74 202.23,164.7 201.98,164.45 201.98,158.95 202.19,158.74 R1228.1 202.19,154.31 R1229.1 203.49,154.22 v1(204.24,153.47) ; R2633.2 v1(135.43,161.32) ; R19.1 214.15,149.12 214.06,149.17 213.95,149.28 213.73,149.28 213.34,149.68 R2778.1 213.23,149.78 v1(213.23,151.18) 213.56,151.18 213.84,150.9 R18.1 ; C418.1 199.03,31.23 v1(199.03,32.03) ; v1(146.2,42.7) 146.3,42.6 R2411.1 ; v1(223.34,218.14) 223.34,218.19 223.28,218.25 PC127.1 PR90.1 ; Q1.G 210.16,153.54 210.16,152.08 R16.1 210.64,151.99 v1(211.2,152.55) ; v1(197.1,175.95) 198.29,177.14 R2744.2 198.24,178.59 R2743.1 198.15,179.85 Q77.G ; PR396.1 133.6,51.71 132.21,50.32 132.21,47.88 v1(132.38,47.7)
  L3 w0.381: v6(160.58,163.48) 160.93,163.84 160.93,164.19 161.01,164.26 161.01,164.72 160.68,165.05 160.66,165.05 159.05,166.65 155.3,166.65
  L3 w0.508: v1(199.03,32.03) 199.16,32.03 199.85,32.72 199.85,37.16 200.84,38.15 203.58,38.15 205.71,40.28 205.71,43.28 206.22,43.79 207.19,43.79 207.34,43.64 v1(207.66,43.64) ; v1(117.47,94.64) 117.47,91.19 120.32,88.34 120.32,85.64 123.29,82.67 v1(123.29,81.76) 123.32,81.74 123.32,81.69 125.27,79.73 125.27,79.38 128.4,76.25 128.4,74.93 132.77,70.56 132.77,65.88 132.82,65.81 132.87,65.69 132.97,65.17 132.97,56.49 132.77,56.28 132.77,53.9 132.18,53.31 132.18,51.99 132.5,51.68 132.5,50.78 132.23,50.51 132.23,47.85 v1(132.38,47.7) ; v1(211.3,144.78) 211.91,145.39 211.91,146.99 213.23,148.31 v1(213.23,151.18) ; 155.3,166.65 154.81,167.13 151.39,167.13 150.64,166.39 150.05,166.39 149.8,166.64 148.25,166.64 147.66,166.05 145.79,166.05 145.72,166.12 v1(145.36,166.12) 142.62,163.38 140.51,163.38 140.51,163.37 140.06,163.37 v1(140.03,163.35) 138.35,161.67 135.79,161.67 v1(135.43,161.32) ; v1(197.1,175.95) 198.3,177.14 v1(201.83,177.14) ; v6(160.58,163.48) v6(160.58,162.48)
  L4 w0.508: v1(223.34,218.14) 216.31,211.1 216.31,207.47 214.58,205.74 213.54,205.74 212.65,204.85 212.65,204.65 211.02,203.02 210.6,203.02 210.21,202.64 210.21,202.21 209.22,201.22 209.22,201.05 203.49,195.33 v1(202.01,195.33) ; v1(213.23,151.18) 212.17,151.18 211.2,152.15 v1(211.2,152.55) ; v1(141.1,199.85) 141.1,199.19 143.79,196.49 143.79,192.17 139.94,188.32 v1(139.55,188.32) ; v4(141.33,42.34) 141.83,41.83 141.83,35.24 143.41,33.66 145.16,33.66 151.51,27.3 152.4,27.3 152.86,26.85 154.71,26.85 156.41,25.15 165.74,25.15 169.52,21.36 172.26,21.36 174.97,18.65 176.52,18.65 179.55,15.62 v1(179.96,15.62)
  L6 w0.508: 201.93,195.33 201.12,195.33 199.9,194.11 195.5,194.11 191.77,197.84 157.05,197.84 155.7,196.49 145.82,196.49 142.95,199.36 141.58,199.36 v1(141.1,199.85) ; 201.93,195.33 v1(202.01,195.33) ; 201.93,195.33 201.93,194.5 198.81,191.37 198.81,187.66 198.81,183.9 201.83,180.87 v1(201.83,177.14) ; v1(117.47,94.64) 118.72,95.89 118.72,98.9 120.36,100.54 120.38,100.54 120.77,100.93 120.77,100.93 121.06,101.22 121.06,114.71 v1(120.19,115.57) ; v1(139.55,188.32) 145.29,182.58 145.29,166.19 v1(145.36,166.12)
  BOTTOM w0.406: v1(197.1,175.95) 197.1,173.9 R2739.2 197.49,173.52 197.49,172.85 197.01,172.38 196.96,172.38 196.67,172.09 194.87,172.09 194.39,171.6 194.39,170.61 ; 194.39,170.61 Q75.2 ; 194.39,170.61 Q75.5
  BOTTOM w0.508: R326.2 197.94,29.21 197.94,32.21 ; Q80.D 212.47,150.42 v1(213.23,151.18) ; v1(132.38,47.7) 132.38,44.12 130.43,42.16 R2707.1 130.11,42.1 129.29,41.27 126.4,41.27 Q71.G ; 197.94,32.21 198.12,32.03 v1(199.03,32.03) ; 197.94,32.21 197.97,32.23 R273.2 ; 197.94,32.21 194.89,32.21 194.36,31.67 190.8,31.67 188.37,29.24 187.88,29.24 186.03,27.38 186.03,22.76 183.59,20.32 183.59,17.58 181.64,15.62 v1(179.96,15.62) ; C143.1 140.26,162.37 140.26,163.09 140.03,163.32 v1(140.03,163.35) ; v1(123.29,81.76) 123.32,81.76 123.34,81.79 123.95,81.79 125.27,83.11 125.27,88.82 126.11,89.66 128.24,89.66 129.29,88.61 131.38,88.61 R2728.1 ; R83.2 145.33,166.15 v1(145.36,166.12) ; v6(160.58,162.48) 160.09,162.97 C144.1 ; v1(201.83,177.14) 201.83,170.43 202.69,169.57 v1(202.69,165.2) ; C316.1 C317.1 207.73,43.63 207.72,43.64 v1(207.66,43.64)
  vias: v2(205.38,28.88) v2(211.71,27.56) v4(141.2,43.28) v4(161.39,78.61) v4(162.28,60.99) v4(162.43,78.61) v4(162.99,60.3) v4(215.52,145.19) v4(216.59,145.29) v4(228.6,90.3) v4(229.62,90.3)
1D8V_S0_CT2: length 3.6
  TOP w0.203: U39.10 141.2,40.87 140.92,41.15 v1(140.61,41.15)
  BOTTOM w0.508: v1(140.61,41.15) 140.74,41.27 v2(141.6,41.27) 142.25,40.63 C979.1
1D8V_S0_EN: length 4.6
  TOP w0.114: U39.5 144.66,40.87 145.01,41.22 v1(145.36,41.22)
  BOTTOM w0.114: C977.1 144.72,41.25 145.34,41.25 v1(145.36,41.22) 145.82,41.22 146.06,40.98 R1218.2 146.3,39.83 v2(146.38,39.75)
1D8V_S5: length 351.7
  TOP w0.203: 137.01,123.39 136.8,123.19 PG142.2 PG141.2 PG138.2 PG135.2 PG134.2 PG137.2 132.18,123.19 132,123.37
  TOP w0.381: CPU1.AJ15 160.96,168 v6(160.46,167.5) 160,167.96 CPU1.AK15
  TOP w0.508: R368.1 133.85,153.4 133.32,152.88 v4(133.02,152.88) ; PG150.2 133.71,132.69 v1(132.82,132.69) ; R2581.2 211.63,40.77 212.84,40.77 v1(213.81,39.8) ; v4(140.11,211.56) 139.7,211.96 PG215.2 ; Q84.D 124.82,133.73 124.94,133.6 124.94,133.4 125.17,133.18 127.32,133.18 127.93,133.8 129.6,133.8 v1(129.92,133.48) ; PG154.2 127.25,212.34 127,212.6 125.89,212.6 125.29,211.99 125.29,211.52 ; v1(130.07,55.91) 130,55.83 123.59,55.83 R2412.1 ; v4(126.24,211.71) 125.98,211.46 125.35,211.46 125.29,211.52 ; v1(128.02,114.66) 126.12,114.66 Q88.D ; 125.29,211.52 PR215.1 ; R2784.1 225.43,158.09 225.04,158.48 212.52,158.48 v1(211.71,159.28)
  L3 w0.508: v1(149.48,168.53) 149.73,168.28 149.73,168.25 150.22,167.77 155.07,167.77 155.51,167.33 159.5,167.33 159.69,167.52 160.44,167.52 v6(160.46,167.5) ; v1(200.61,196.88) 200.61,193.85 199.75,192.99 199.75,187.18 203.23,183.7 203.37,183.7 205.84,181.23 205.84,168.9 208.91,165.83 208.91,162.74 211.71,159.94 v1(211.71,159.28)
  L4 w0.508: v1(175.21,19.43) 175.28,19.43 175.28,19.46 172.62,22.12 169.93,22.12 166.14,25.91 156.74,25.91 154.84,27.81 154.84,27.83 154.43,28.24 151.64,28.24 145.27,34.62 144.55,34.62 143.79,35.38 143.79,41.25
  L6 w0.508: v1(200.61,196.88) 198.42,199.06 148.54,199.06 143.13,204.47 143.13,209.19 141.02,211.3 140.36,211.3 v4(140.11,211.56) ; v1(175.21,19.43) 176.02,19.43 180.33,23.74 180.42,23.74 180.8,24.13 182.2,24.13 188.02,29.95 189.99,29.95 192.56,32.51 192.56,33.2 193.09,33.73 195.38,33.73 197,35.36 204.42,35.36 205.23,34.54 211.96,34.54 212.65,35.23 212.65,38.64 v1(213.81,39.8) ; v1(128.02,114.66) 129.67,113 129.67,111.46 133.91,107.21 136.42,107.21 136.78,107.57 138.81,107.57 138.81,107.57
  BOTTOM w0.508: R2614.2 144.37,166.83 144.37,164.85 ; v6(160.46,167.5) 160.27,167.69 C140.1 ; 144.37,164.85 147.29,164.85 149.48,167.03 v1(149.48,168.53) ; 144.37,164.85 144.37,162.15 146.28,160.25 PC65.1 146.28,159.11 146.72,158.66 R1235.1 146.72,155.44 145.64,154.36 144.17,154.36 143.25,153.44 143.25,148.16 140.84,145.75 137.11,145.75 136.14,144.78 136.14,142.01 139.9,138.25 139.9,127.23 v4(136.83,124.16) ; v4(144.75,42.57) 144.6,42.42 C976.1 ; v1(211.71,159.28) 211.71,157.48 210.95,156.72 Q82.D
  vias: v4(124.56,78.79) v4(125.22,78.03) v4(126.24,159.26) v4(129.54,186.69) v4(130.12,48.11) v4(132.23,57.66) v4(133.91,85.55) v4(134.29,124.18) v4(134.52,84.86) v4(135.48,124.13) v4(143.38,43.31) v5(128.65,159.38) v5(131.95,153.03)
1D8V_S5_PG: length 336.1
  TOP w0.114: v1(140.94,216.33) 142.17,217.56 143.87,217.56 144.12,217.81 146.2,217.81 146.65,217.36 PR362.1 ; PR218.2 125.4,216.41 v1(125.68,216.13) ; PR339.1 135.3,102.87 134.9,102.46 v1(134.9,102.16) ; PR337.1 151.73,12.79 152.43,13.49 v1(152.43,14.07) ; v1(120.5,132.77) 121.56,131.7 v3(121.56,131.57) 122.3,130.84 122.3,130.48 124.38,128.41 124.7,128.41 126.96,126.15 126.96,125.23 v1(129.01,123.19) 129.11,123.19 129.64,122.66 PR210.1
  L3 w0.114: v1(186.16,74.47) 186.16,72.67 184.33,70.85 184.33,64.27 184.56,64.05 184.56,28.99 176.22,20.65 166.32,20.65 v1(165.38,19.71)
  L4 w0.114: v1(165.38,19.71) 164.13,20.95 161.06,20.95 155.91,15.8 155.89,15.8 155.62,15.53 155.51,15.53 153.72,13.74 152.76,13.74 v1(152.43,14.07) ; v1(140.94,216.33) 130.63,216.33 130.53,216.43 125.98,216.43 v1(125.68,216.13)
  L6 w0.102: v1(186.16,74.47) 186.16,74.57 182.81,77.92 182.4,78.33 170.08,78.33 169.8,78.61 167.67,78.61 167.11,78.05 157.22,78.05 156.74,77.57 154.93,77.57 154.6,77.9 146.69,77.9 144.88,79.71 140.87,79.71 138.73,77.57 135.53,77.57 129.69,83.41 129.69,96.03 133.07,99.4 133.07,100.23 134.9,102.06 v1(134.9,102.16) 134.65,102.16 134.26,101.78 133.17,101.78 131.67,103.28 128.12,103.28 125.09,106.3 125.09,113.45 125.09,113.45 125.09,116.19 126.24,117.33 126.24,117.82 127.12,118.7 127.12,118.7 127.53,119.12 127.53,119.71 127.53,119.71 127.53,121.72 v1(129.01,123.19) ; v1(120.5,132.77) 120.5,165.25 118.34,167.41 118.34,175.34 119.15,176.15 119.15,184.4 124.49,189.74 124.49,192.15 126.26,193.93 127.79,193.93 129.03,195.17 129.03,196.62 131.57,199.16 131.57,200.89 131.06,201.4 130.3,201.4 129.08,202.62 129.08,204.22 129.39,204.53 129.39,209.14 129.39,209.44 128.93,209.91 128.63,209.91 127.03,211.51 127.03,214.35 125.68,215.7 v1(125.68,216.13)
1D8V_SPI: length 76.9
  TOP w0.381: v1(139.73,102.27) 141.29,102.27 141.76,101.8 141.76,100.04 141.88,99.91 141.88,97.79 142.01,97.66 142.01,89.76 140.56,88.32 v1(140.56,88.11) ; Q88.S 123.16,115.16 Q87.S ; Q88.S 125.33,116.84 126.6,115.57 v1(128.02,115.57) ; Q88.S 124.85,117.65 123.98,118.52 121.53,118.52 R2766.1 121.48,119.84 C2517.1 ; U4.8 133.08,89.92 132.05,88.9 C297.1 R244.2 133.74,87.59 v1(133.88,87.73)
  L6 w0.381: v1(139.73,102.27) 139.73,103.25 137.8,105.17 135.78,105.17 134.51,106.44 132.75,106.44 132.26,105.94 131.67,105.94 128.85,108.76 128.85,112.76 127.71,113.91 127.27,114.35 127.27,114.99 127.69,115.4 127.86,115.4 v1(128.02,115.57)
  BOTTOM w0.254: 137.76,102.39 139.55,102.39 139.66,102.27 v1(139.73,102.27) 140.21,101.79 140.21,98.26 R2663.1 ; 137.76,102.39 137.99,102.15 RN16.2 ; 137.76,102.39 137.58,102.39 137.34,102.15 RN16.1
  BOTTOM w0.381: v1(140.56,88.11) 139.93,87.48 v5(137.01,87.48) 134.14,87.48 v1(133.88,87.73) 133.17,88.44 R2728.2
1D8V_SPI_EN: length 5.6
  TOP w0.114: Q86.3 122.97,111.19 122.3,110.52 v3(122.12,110.52) 121.34,111.3 R2765.2 121.52,111.84 Q86.2
1D8V_SPI_EN2: length 13.6
  TOP w0.114: R2764.2 129.77,116.01 129.77,114.71 128.87,113.8 v3(128.84,113.8) 127.62,113.8 126.3,112.49 Q86.6 125.21,112.49 124.43,113.26 122.15,113.26 121.67,112.78 R2763.2 121.34,113.23 121.13,113.44 Q87.G
1D8V_SPI_EN3: length 4.3
  TOP w0.114: v3(128.98,115.21) 128.58,115.62 R2764.1 128.57,116.32 C2516.1 127.94,117.4 127.39,116.84 Q88.G
1D8V_VGA: length 215.8
  TOP w0.254: PG222.2 94.55,155.77 ; PG223.2 94.68,156.66
  TOP w0.381: GPU1.AR27 75.17,168.2 75.05,168.31 75.04,168.31 v6(74.8,168.55) 74.65,168.55 GPU1.AP26 73.86,169 v6(73.55,169.3) 73.47,169.3 73,169.77 GPU1.AN25 ; GPU1.AM25 73.23,170.37 73.36,170.37 73.52,170.21 v6(73.58,170.21) 73.99,169.8 GPU1.AN26 74.35,169.8 v6(74.8,169.35) 75.05,169.35 GPU1.AP27
  TOP w0.508: 32.65,135.97 32.64,135.96 R2777.1 ; 32.65,135.97 R541.2 v1(33.52,135.99) ; 32.65,135.97 R543.2 31.51,135.94 R545.2 R547.2 R549.2 27.95,135.94 R551.1 ; R484.2 102.41,223.11 102.13,222.83 v1(102.13,222.78) ; PR344.1 107.45,144.75 PR239.2 106.37,144.76 PC409.1 105.2,144.95 PC276.1 105.1,146.04 PR228.1 104.39,146.07 104.16,146.3 v1(104.01,146.3) ; R560.1 97.44,149.14 L28.1 98.45,147.36 C2515.1 98.47,146.92 98.98,146.41 101.5,146.41 101.98,146.89 101.98,147.79 v1(101.8,147.97) ; v1(104.07,148.18) PR229.1 105.24,149.22 PR230.1
  L3 w0.254: v1(33.52,135.99) 33.52,136.01 36.79,139.28 37.35,139.28 37.39,139.32 45.78,139.32 45.8,139.29 56.7,139.29 56.71,139.28 70.09,139.28 70.38,139.57 94.28,139.57 96.04,141.33 96.04,144.88 99.37,148.21 101.56,148.21 v1(101.8,147.97)
  L6 w0.508: v1(101.8,147.97) 100.65,149.12 99.31,149.12 94.11,154.33 94.11,155.58 v4(93.8,155.88) ; v1(102.13,222.78) 103.61,222.78 106.27,220.12 v1(106.27,215.87) 106.27,209.8 106.63,209.45 108.56,209.45 111.53,206.48 111.53,203.78 112.95,202.36 112.95,193.9 113.97,192.89 113.97,184.24 112.78,183.05 112.78,169.84 110.45,167.51 106.01,167.51 103.26,164.77 101.3,164.77 98.85,162.33 98.85,162.06 97.79,160.99 97.79,160.99 v4(93.73,156.92)
  BOTTOM w0.508: R2776.1 33.72,136.19 v1(33.52,135.99) ; v1(104.01,146.3) 104.24,146.3 104.8,146.86 104.8,147.43 104.07,148.16 v1(104.07,148.18) 102.02,148.18 v1(101.8,147.97) ; C593.1 74.83,165.89 75.83,166.89 75.98,166.89 76.43,167.34 L27.1 ; v1(106.27,215.87) 105.51,215.11 R489.2
  vias: v2(73.66,167) v2(77.34,161.04) v2(85.6,158.62) v2(92.33,158.37)
1D8V_VGA_PG: length 256.4
  TOP w0.114: v1(107.21,208.13) 107.21,208.61 104.01,211.81 v1(103.38,211.81) ; v1(109.75,202.64) 109.75,202.65 109.65,202.76 109.65,203.34 109.36,203.63 R1196.2 ; v1(108.28,162.33) 108.28,162.37 108.05,162.6 PR378.2 ; PR393.2 8.63,207.07 PR404.2 8.04,206.62 7.81,206.38 v1(6.35,206.38)
  L3 w0.114: v1(97.41,228.09) 95.25,230.25 42.88,230.25 38.49,225.87 26.44,225.87 25.73,226.57 15.37,226.57 13.37,224.57 13.3,224.57 13.3,224.57 12.65,224.57 7.05,218.97 7.05,217.36 4.7,215.01 4.7,208.03 6.27,206.45 6.28,206.45 v1(6.35,206.38)
  L4 w0.114: v1(97.41,228.09) 97.41,224.28 98.27,223.42 102.49,223.42 103.38,222.53 103.38,221.95 104.32,221.01 113.23,221.01 117.25,216.99 119.38,216.99 119.81,216.56 119.81,215.75 v1(119.76,215.7) 117.3,215.7 109.73,208.13 v1(107.21,208.13) ; v1(109.75,202.64) 109.75,202.67 109.75,202.67 109.75,200.56 109.98,200.33 109.98,194.44 110.74,193.68 110.74,191.01 110.87,190.88 110.87,188.82 108.66,186.61 108.66,185.09 112.63,181.12 112.63,171.11 111.43,169.92 111.43,168.83 110.75,168.15 109.67,168.15 109.63,168.1 108.99,168.1 107.44,166.56 107.44,163.21 108.28,162.37 v1(108.28,162.33) 108.28,162.3 106.5,160.52 106.5,159.36 106.47,159.32 106.47,158.94 108.03,157.38 108.03,150.8 109.14,149.68 109.14,144.45 109.7,143.89 109.7,143.18 v1(109.4,142.88)
  BOTTOM w0.114: R492.2 102.4,212.79 v1(103.38,211.81) ; PC502.1 112.21,145.53 PR232.1 112.19,144.92 PR235.2 111.75,143.5 v5(111.33,143.08) 111.12,142.88 v1(109.4,142.88) ; v1(107.21,208.13) 107.34,208.13 108.33,207.14 108.33,204.21 108.64,203.9 109.05,203.9 109.75,203.2 v1(109.75,202.64) ; v1(119.76,215.7) 120.7,214.76 120.7,213.03 119.77,212.1 PR320.1
1D35V_MEM_VGA: length 549.5
  TOP w0.203: v6(73.19,221.76) 73.6,221.34 VRAMB1.H12
  TOP w0.254: v6(66,218.5) 66,218.5 66.37,218.13 VRAMB1.M3 66.48,218.13 66.8,218.45 v6(66.8,218.5) ; 37.89,216.11 PG241.2 ; 38.02,219.16 PG244.2 ; 37.96,217.64 PG239.2 ; VRAMB2.D12 48.27,216.13 v6(48.31,216.13) 48.33,216.13 VRAMB2.D11 ; VRAMD2.M12 v6(59.22,145.48) VRAMD2.L11 ; v6(75.6,217.7) 75.6,217.73 VRAMB1.M14 75.31,218.24 75.31,218.82 VRAMB1.L14 ; v6(74,218.5) 74.4,218.9 VRAMB1.L13 ; 38.07,213.83 PG245.2 ; 37.91,218.4 PG238.2 ; v6(52.79,149.54) 52.79,149.55 52.43,149.9 VRAMD2.F3 v6(52,149.5) ; v6(92.48,218.51) 92.1,218.13 VRAMA2.F3 v6(91.7,218.5) VRAMA2.G4 ; 37.91,214.59 PG243.2 ; 37.99,216.87 PG240.2 ; v6(66.8,221.7) 66.77,221.7 VRAMB1.H3 66.8,220.93 v6(66.8,220.9) ; VRAMB1.L2 65.6,218.9 v6(65.2,218.5) 64.8,218.9 VRAMB1.L1 ; 37.91,215.35 PG242.2
  TOP w0.3: VRAMB2.F12 v6(48.3,217.7)
  TOP w0.305: VRAMB2.C5 v6(53.9,215.3) ; VRAMB1.K12 73.6,219.7 v6(73.2,219.3) 73.17,219.3 VRAMB1.L11 ; VRAMB1.D11 72.8,224.5 v6(73.2,224.1) 73.6,224.5 VRAMB1.D12 ; VRAMB1.K3 66.37,219.73 v6(66,220.1) ; VRAMB2.P11 v6(48.3,224.9) VRAMB2.P12 v6(47.5,224.9) ; VRAMA2.L1 v6(94.1,221.7) ; v6(75.75,222.75) 75.6,222.9 75.33,222.9 75.3,222.93 VRAMB1.F14 ; v6(82.25,184.8) 81.8,184.35 GPU1.V35 ; VRAMC1.H12 v6(28.3,201.7) VRAMC1.G11 ; VRAMD2.K3 v6(52.8,146.3) VRAMD2.L4 ; v6(94.14,214.52) 94.08,214.52 VRAMA2.B1 ; VRAMB2.G14 v6(45.9,219.3) ; VRAMD1.B3 v6(24.3,157.5) ; VRAMD1.H12 v6(28.3,164.7) VRAMD1.G11 ; GPU1.AE13 61.4,176.87 v6(60.96,176.43) ; v6(72.4,225.7) 72.03,225.33 VRAMB1.C10 ; VRAMB1.L13 74.51,218.93 74.59,219.01 75.01,219.01 75.09,218.93 VRAMB1.L14 ; VRAMC2.P1 25.5,185.45 25.52,185.47 25.52,185.62 v6(25.71,185.81) ; VRAMB2.L11 v6(48.3,221.7) VRAMB2.K12 ; VRAMD1.F12 v6(26.7,164.7) ; VRAMD1.F12 v6(27.5,165.5) VRAMD1.G13 v6(27.5,166.3) ; VRAMD1.F12 v6(27.5,164.7) ; VRAMB2.P14 45.82,224.5 v6(45.72,224.4) ; VRAMD1.P1 v6(33.9,155.9) ; VRAMC2.D11 33.51,177.2 v6(33.91,177.6) 34.3,177.99 VRAMC2.C10 ; VRAMD2.P3 v6(52.8,143.1) ; v6(66,225.72) 66.02,225.72 66.4,226.1 VRAMB1.B3 ; VRAMC1.G2 v6(27.5,194.5) VRAMC1.F3 ; v6(53.6,151.09) 53.61,151.09 VRAMD2.E5 ; v6(75.8,224.5) 75.77,224.53 VRAMB1.D14 ; v6(25.1,202.5) VRAMC1.D12 v6(25.1,201.7) VRAMC1.D11 ; VRAMC1.R10 34.3,200.51 v6(33.9,200.91) 33.89,200.91 VRAMC1.P11 v6(33.9,201.7) 33.9,201.7 33.5,202.1 VRAMC1.P12 ; VRAMD1.D1 25.5,156.06 25.5,155.76 25.47,155.74 v6(25.47,155.69) ; v6(32.24,155.89) 32.23,155.9 32.23,155.97 VRAMD1.M1 v6(31.5,156.7) ; VRAMD1.E10 26.3,163.08 v6(26.48,162.9) ; VRAMA2.K12 v6(85.3,221.7) VRAMA2.L11 v6(85.3,222.5) VRAMA2.M12 ; VRAMC2.M14 27.1,174.42 v6(27.34,174.18) ; VRAMC2.H3 VRAMC2.G2 ; VRAMC2.G2 31.1,184.48 31.21,184.59 31.21,185.01 31.1,185.12 VRAMC2.G1 v6(30.7,185.6) ; VRAMC2.G2 v6(31.5,184) VRAMC2.F3 31.9,183.58 v6(31.51,183.19) 31.12,182.8 VRAMC2.G4 ; VRAMD2.P14 v6(61.8,143.5) ; v6(28.3,182.4) VRAMC2.L4 v6(28.3,183.2) VRAMC2.K3 v6(29.1,183.2) ; VRAMC2.B12 35.09,176.4 v6(34.69,176) ; VRAMA2.N10 86.92,223.7 v6(87.1,223.52) ; 67.2,222.1 67.17,222.1 66.8,221.73 v6(66.8,221.7) ; 67.2,222.1 v6(67.6,221.7) ; 67.2,222.1 VRAMB1.G4 ; v6(50.19,143.71) 50.38,143.52 50.53,143.52 50.55,143.5 VRAMD2.P1 ; VRAMA2.P11 v6(85.3,224.9) VRAMA2.P12 v6(84.5,224.9) ; v6(99.77,199.62) 100.1,199.29 VRAMA1.M1 ; VRAMA1.F14 104.9,188.37 v6(104.68,188.16) ; VRAMA1.P14 v6(98.1,188.4) ; VRAMB2.F1 56.72,218.1 v6(57.1,217.71) ; VRAMA1.E5 v6(105.7,195.4) ; v6(45.72,226.18) 45.8,226.1 VRAMB2.T14 ; v6(72.4,224.1) 72.37,224.1 VRAMB1.E10 ; VRAMC2.D1 33.5,185.26 v6(33.9,185.66) ; v6(61.6,150.3) VRAMD2.F14 61.31,149.79 61.31,149.21 VRAMD2.G14 61.09,148.99 60.51,148.99 VRAMD2.G13 v6(60,149.5) VRAMD2.F12 ; VRAMD2.B14 v6(61.6,153.5) ; v6(107.67,191.59) 107.3,191.96 VRAMA1.C10 ; VRAMC1.B12 v6(24.3,202.5) ; VRAMC1.L1 v6(31.5,193.7) VRAMC1.L2 v6(31.5,194.5) VRAMC1.M3 v6(31.5,195.3) VRAMC1.L4 ; VRAMC1.F3 v6(26.7,194.5) ; VRAMC1.F3 v6(27.5,195.3) VRAMC1.G4 v6(28.3,195.3) ; VRAMB1.T1 64.67,214.93 64.37,215.23 v6(64.37,215.29) ; VRAMD1.L4 VRAMD1.M3 v6(31.5,157.5) VRAMD1.L2 v6(31.5,156.7) ; VRAMD1.M14 31.9,167.03 v6(32.08,167.21) ; VRAMC2.F1 31.9,185.26 v6(32.28,185.63) ; v6(68.4,225.7) 68.03,225.33 VRAMB1.C5 ; v6(108.1,199.85) 108.1,199.85 VRAMA1.B1 ; VRAMD2.B3 v6(52,153.5) ; VRAMB1.D1 64.68,224.53 64.63,224.48 64.38,224.48 v6(64.19,224.29) ; v6(27.5,166.3) VRAMD1.F14 ; v6(27.5,166.3) VRAMD1.G14 ; VRAMC2.T3 v6(24.3,184) ; v6(94.28,226.2) 94.01,226.2 93.99,226.18 93.78,226.18 VRAMA2.T1 ; VRAMB2.G13 v6(47.5,219.3) VRAMB2.H12 v6(48.3,219.3) VRAMB2.G11 ; VRAMA2.T3 v6(92.5,225.7) ; VRAMD1.L1 v6(31.5,156.7) ; VRAMD2.H3 v6(52,147.9) ; VRAMA1.B12 v6(107.7,190) ; VRAMC1.C10 v6(24.3,200.1) ; VRAMB1.R10 72.37,216.1 v6(72.4,216.1) 72.8,216.5 VRAMB1.P11 ; VRAMD2.L1 v6(50.4,146.3) ; VRAMD2.D14 v6(61.6,151.9) ; VRAMB1.F12 73.2,222.53 v6(73.2,222.5) 72.83,222.13 VRAMB1.G11 ; VRAMA2.M12 v6(85.3,223.3) ; VRAMA2.M12 v6(84.5,222.5) VRAMA2.L13 v6(83.7,222.5) ; VRAMD1.P14 v6(33.9,167.1) ; v6(48.3,222.5) VRAMB2.M12 ; VRAMB2.M12 v6(47.5,222.5) VRAMB2.L13 v6(46.7,222.5) ; VRAMB2.M12 v6(48.3,223.3) ; VRAMB2.M3 v6(54.7,222.5) VRAMB2.L4 v6(54.7,221.7) ; VRAMB2.M3 v6(55.5,223.3) ; VRAMB2.M3 v6(55.5,222.5) VRAMB2.L2 ; VRAMB2.G4 v6(54.7,218.5) VRAMB2.F3 v6(55.5,218.5) VRAMB2.G2 ; VRAMB1.P1 64.8,216.53 65.18,216.91 65.18,216.96 v6(65.19,216.96) ; v6(28.24,174.35) 27.9,174.69 VRAMC2.L14 ; VRAMD2.T3 v6(52,142.3) ; v6(28.3,185.6) 28.26,185.6 27.9,185.24 VRAMC2.L1 ; v6(64.4,223.3) 64.77,222.93 VRAMB1.F1 ; VRAMD2.R10 v6(58.4,142.3) ; v6(57.24,222.76) 57.06,222.76 56.92,222.9 VRAMB2.M1 ; VRAMD2.N10 v6(58.4,143.9) VRAMD2.P11 v6(59.2,143.9) VRAMD2.P12 ; VRAMC2.G11 v6(30.7,176.8) VRAMC2.H12 ; v6(66.8,224.9) 66.43,224.53 VRAMB1.D3 ; VRAMD2.F1 v6(50.4,150.3) ; VRAMA1.G2 v6(104.52,197.98) VRAMA1.F3 v6(105.3,197.2) ; VRAMA2.N5 90.14,223.7 v6(89.94,223.89) ; v6(33.1,158.3) VRAMD1.P3 ; VRAMB1.B12 73.6,226.1 73.96,225.74 74,225.74 v6(74,225.73) ; VRAMC1.F14 v6(27.5,203.3) ; v6(27.5,203.3) VRAMC1.G14 ; v6(27.5,203.3) VRAMC1.G13 27.53,202.53 27.53,202.52 v6(27.5,202.49) 27.11,202.1 VRAMC1.F12 ; VRAMC1.L13 v6(30.7,202.5) VRAMC1.K12 v6(30.7,201.7) VRAMC1.L11 ; v6(26.18,197.06) 26.3,196.94 VRAMC1.E5 ; v6(83.7,222.5) VRAMA2.M14 ; v6(83.7,222.5) VRAMA2.L14 ; v6(74.8,217.7) 75.2,218.1 VRAMB1.M14 ; VRAMB2.C10 v6(49.1,216.1) VRAMB2.D11 ; VRAMC1.K3 v6(29.9,194.5) ; VRAMA2.M3 v6(92.5,222.5) VRAMA2.L2 ; VRAMA2.M3 v6(91.7,222.5) VRAMA2.L4 v6(91.7,221.7) VRAMA2.K3 92.09,221.3 v6(91.7,220.91) ; VRAMA2.M3 v6(92.5,223.3) ; VRAMB2.P1 v6(57.32,224.5) ; v6(32.31,192.9) 31.91,193.3 VRAMC1.M1 ; v6(23.8,192.72) 23.9,192.82 VRAMC1.B1 ; VRAMA2.G11 85.68,218.9 85.32,219.27 v6(85.31,219.27) 85.31,219.29 VRAMA2.H12 v6(84.5,219.3) VRAMA2.G13 ; VRAMC2.B1 35.1,185.22 v6(35.54,185.65) ; VRAMC2.E10 v6(32.3,177.6) ; v6(83.85,190.8) 83.4,190.35 GPU1.L37 ; VRAMA2.D12 84.9,216.49 v6(85.27,216.12) 85.66,216.5 VRAMA2.D11 85.72,216.5 86.13,216.09 v6(86.13,216.09) 86.14,216.09 86.14,216.06 VRAMA2.C10 ; v6(102.87,197.21) 102.91,197.21 VRAMA1.H3 ; VRAMD1.C10 v6(24.3,163.1) ; v6(74,217.7) 73.6,218.1 VRAMB1.M12 73.63,218.13 v6(74,218.5) ; VRAMA1.P3 v6(98.9,197.2) ; VRAMB1.E5 68.57,223.73 v6(68.6,223.7) ; VRAMB2.T1 57.18,226.1 v6(57.28,226.2) ; VRAMC1.M12 v6(32.3,201.7) ; v6(67.6,216.9) 68,217.3 VRAMB1.N5 ; VRAMB2.D3 v6(54.7,216.9) ; VRAMC2.L2 v6(27.5,184) VRAMC2.M3 v6(26.7,183.2) ; VRAMD1.L14 v6(30.7,167.1) ; VRAMA1.P12 v6(98.9,190) ; VRAMD2.G11 v6(59.2,148.7) VRAMD2.H12 ; v6(90.92,216.92) 90.55,217.3 VRAMA2.E5 ; VRAMC1.M14 v6(32.3,204.1) ; VRAMD1.T14 v6(35.5,167.1) ; v6(82.88,216.07) 83.3,216.49 VRAMA2.D14 ; VRAMB1.G2 65.63,222.13 v6(66,222.5) 66.4,222.9 VRAMB1.F3 66.43,222.93 v6(66.8,223.3) ; VRAMA1.H12 103.7,190.8 v6(103.73,190.8) 103.73,190.83 VRAMA1.G11 v6(104.5,190.8) VRAMA1.F12 104.9,190.37 v6(104.5,189.97) 104.13,189.6 VRAMA1.G13 ; v6(33.95,204.14) 33.95,204.14 33.51,203.7 VRAMC1.P14 ; v6(50.39,151.91) 50.39,151.91 VRAMD2.D1 ; VRAMB1.L4 66.8,218.53 v6(66.8,218.5) ; v6(64.24,226.1) 64.27,226.13 VRAMB1.B1 ; VRAMA2.E10 v6(86.1,217.7) ; VRAMD1.L11 v6(30.7,164.7) VRAMD1.K12 v6(30.7,165.5) VRAMD1.L13 ; v6(75.77,226.2) 75.7,226.13 VRAMB1.B14 ; v6(52.94,223.82) 53.06,223.7 VRAMB2.N5 ; VRAMB1.N10 72.03,217.33 v6(72.4,217.7) ; VRAMC1.H3 v6(29.1,195.3) ; v6(67.6,215.29) 67.64,215.32 67.64,215.36 VRAMB1.R5 ; VRAMD1.T12 v6(35.5,164.7) ; v6(92.48,218.51) 92.87,218.9 VRAMA2.G2 ; VRAMC1.N5 v6(33.1,196.1) ; VRAMC2.T12 v6(24.3,176) ; v6(65.99,214.53) 66.4,214.93 VRAMB1.T3 ; VRAMD1.E5 26.3,159.74 26.3,159.74 26.3,159.94 v6(26.18,160.06) ; v6(61.6,167.75) 62.05,168.2 GPU1.AR14 ; VRAMB2.L1 v6(57.1,221.7) ; VRAMB2.D14 v6(45.88,216.08) ; VRAMA2.B14 v6(82.9,214.5) ; VRAMD1.F1 27.1,155.78 v6(27.2,155.68) ; VRAMA1.T3 v6(96.5,198) ; VRAMA2.B12 v6(85.3,214.5) ; VRAMD2.L11 v6(59.2,146.3) VRAMD2.K12 ; VRAMD2.C10 v6(58.4,151.9) VRAMD2.D11 ; VRAMD1.R10 34.3,163.51 v6(33.91,163.9) 33.51,164.3 VRAMD1.P11 v6(33.9,164.7) VRAMD1.P12 ; v6(26.48,199.9) 26.3,200.08 VRAMC1.E10 ; VRAMA1.R5 v6(97.3,196.4) ; VRAMA2.F1 93.72,218.1 v6(94.11,217.71) ; VRAMA2.B3 v6(92.5,214.5) ; VRAMB1.M1 64.43,217.76 v6(64.36,217.76) ; VRAMC2.T1 v6(23.9,185.8) ; VRAMB2.T3 v6(55.5,225.7) ; VRAMC1.T1 35.1,193.27 v6(35.5,192.87) ; VRAMD1.C5 v6(24.3,159.1) ; VRAMB2.B3 v6(55.5,214.5) ; VRAMD2.L13 v6(60,145.5) 59.6,145.1 VRAMD2.M12 ; VRAMC1.T3 v6(35.5,194.5) ; VRAMA1.E10 105.7,191.96 v6(106.1,191.57) 106.13,191.57 106.5,191.2 VRAMA1.D11 106.5,191.2 v6(106.1,190.8) 106.1,190.8 VRAMA1.D12 ; VRAMD1.M12 v6(32.3,164.7) ; VRAMA2.G14 v6(82.9,219.3) ; v6(64.4,221.7) 64.8,222.1 VRAMB1.G1 ; VRAMC2.P3 v6(25.1,183.2) ; v6(33.07,159.08) 33.07,159.13 VRAMD1.N5 ; v6(55.6,195.55) 56.05,195.1 GPU1.E6 ; VRAMA2.T12 v6(84.5,225.7) ; VRAMC2.E5 v6(33.1,182.4) ; v6(98.1,199.59) 98.49,199.2 VRAMA1.P1 ; VRAMD1.D11 v6(25.1,164.7) VRAMD1.D12 v6(25.1,165.5) ; VRAMC2.D14 v6(33.9,174.4) ; VRAMA1.B3 v6(107.7,198) ; VRAMC1.D14 25.5,204.24 v6(25.6,204.35) ; VRAMD2.G4 53.2,149.13 52.8,149.54 v6(52.79,149.54) ; VRAMB2.D1 v6(57.1,216.1) ; VRAMA2.C5 v6(90.9,215.3) ; VRAMA1.P11 v6(98.1,191.6) VRAMA1.R10 ; VRAMC2.L13 v6(27.5,176) ; v6(25.6,167.28) 25.5,167.18 VRAMD1.D14 ; VRAMB2.E10 v6(49.1,217.7) ; VRAMB2.F14 45.97,217.77 45.9,217.77 45.9,217.76 v6(45.89,217.76) ; VRAMC1.F12 v6(26.7,201.7) ; VRAMC1.F12 27.5,201.7 v6(27.51,201.7) ; VRAMD2.M1 v6(50.4,144.7) ; VRAMA1.L1 v6(100.5,198.8) VRAMA1.L2 v6(100.5,198) VRAMA1.M3 v6(100.5,197.2) VRAMA1.L4 ; v6(108.2,188.15) 108.1,188.25 VRAMA1.B14 ; VRAMB1.P3 66.43,216.53 v6(66.8,216.9) ; VRAMD2.M14 61.6,145.1 v6(61.78,145.28) ; VRAMC2.T14 23.9,174.53 23.9,174.33 23.8,174.23 v6(23.8,174.19) ; VRAMC1.N10 v6(32.3,200.9) ; v6(94.34,224.48) 93.72,224.48 VRAMA2.P1 ; VRAMC2.R10 v6(24.3,177.6) ; v6(96.51,199.64) 96.51,199.59 96.9,199.2 VRAMA1.T1 ; VRAMB2.B1 56.7,214.85 57.04,214.51 57.09,214.51 v6(57.15,214.45) ; VRAMD2.E10 v6(58.4,150.3) ; VRAMB2.E5 v6(53.9,216.9) ; VRAMB2.R5 v6(53.9,225.7) ; VRAMB2.B14 v6(45.9,214.5) ; VRAMA2.R5 v6(90.9,225.7) ; v6(99.7,188.4) VRAMA1.M14 100.18,188.8 100.29,188.69 100.71,188.69 100.82,188.8 VRAMA1.L14 100.9,188.88 101.01,188.99 101.01,189.41 100.9,189.52 VRAMA1.L13 v6(100.5,190) VRAMA1.M12 ; v6(27.24,192.71) 27.12,192.83 27.12,193.09 27.1,193.11 VRAMC1.F1 ; v6(75.62,216.14) 75.56,216.14 75.2,216.5 VRAMB1.P14 ; VRAMA1.K3 v6(102.1,198) ; VRAMD2.D12 v6(60,151.1) ; VRAMB2.H3 v6(55.5,220.1) ; VRAMA2.M1 93.87,222.9 93.9,222.87 94.28,222.87 v6(94.39,222.76) ; v6(74,222.5) 74.37,222.13 VRAMB1.G13 ; VRAMB1.G14 75.6,221.73 v6(75.6,221.7) ; VRAMA2.P14 82.82,224.5 v6(82.72,224.4) ; VRAMA1.D3 106.9,197.2 v6(106.9,197.2) ; VRAMA2.R10 v6(86.9,225.7) ; v6(25.5,174.2) 25.5,174.54 VRAMC2.P14 ; VRAMC1.L14 v6(30.7,204.1) ; VRAMD1.R5 v6(34.7,159.1) ; v6(29.1,158.3) VRAMD1.H3 v6(28.3,158.3) VRAMD1.G4 v6(27.5,158.3) VRAMD1.F3 v6(27.5,157.5) VRAMD1.G2 27.9,157.02 27.79,156.91 27.79,156.49 27.9,156.38 VRAMD1.G1 v6(28.3,155.9) ; VRAMA1.G1 v6(103.7,199.6) ; v6(53.6,152.7) VRAMD2.C5 ; VRAMA1.L11 v6(101.3,190.8) VRAMA1.K12 ; v6(50.21,141.86) 50.25,141.9 VRAMD2.T1 ; VRAMC1.R5 v6(34.7,196.1) ; VRAMC1.D1 25.5,192.68 v6(25.52,192.66) ; VRAMA1.N5 v6(98.9,196.4) ; VRAMA1.G4 v6(103.7,197.2) ; VRAMD2.G2 v6(52,149.5) ; VRAMD2.G1 v6(50.4,148.7) ; VRAMC2.B3 v6(34.7,184) ; VRAMC1.B14 23.9,204.24 v6(23.82,204.32) ; VRAMA2.D3 v6(91.7,216.9) ; VRAMB2.K3 v6(54.7,220.9) ; VRAMA2.F14 83.18,218.1 82.87,217.79 v6(82.87,217.79) ; VRAMC2.P12 v6(25.9,176.8) VRAMC2.P11 v6(25.9,177.6) VRAMC2.N10 ; VRAMA2.P3 v6(91.7,224.9) ; v6(61.77,141.76) 61.64,141.88 61.46,141.88 61.45,141.9 VRAMD2.T14 ; v6(24.3,181.58) 24.7,181.98 VRAMC2.R5 ; VRAMB2.P3 v6(54.7,224.9) ; v6(32.3,174.4) VRAMC2.F14 31.82,174.8 31.71,174.69 31.29,174.69 31.18,174.8 VRAMC2.G14 31.1,174.88 30.99,174.99 30.99,175.41 31.1,175.52 VRAMC2.G13 v6(31.5,176) VRAMC2.F12 v6(32.3,176) ; v6(23.82,167.28) 23.9,167.2 VRAMD1.B14 ; VRAMD2.L14 61.25,145.9 v6(61.62,146.27) ; VRAMC2.N5 v6(26.3,181.4) ; VRAMC1.T14 v6(35.5,204.1) ; VRAMC1.P1 v6(33.9,192.9) ; VRAMC2.B14 v6(35.5,174.4) ; v6(46.7,222.5) VRAMB2.L14 ; v6(46.7,222.5) VRAMB2.M14 ; VRAMB1.T12 73.6,214.9 73.23,214.53 v6(73.2,214.53) ; VRAMA2.G1 v6(94.1,219.3) ; VRAMA1.F1 v6(105.3,199.6) ; VRAMD2.B1 v6(50.4,153.5) ; VRAMC1.G1 v6(28.3,192.9) ; VRAMB2.G1 v6(57.1,219.3) ; VRAMA1.D1 106.5,199.35 106.45,199.39 106.45,199.72 v6(106.37,199.81) ; VRAMA2.H3 v6(92.5,220.1) ; VRAMC2.K12 v6(28.3,176.8) VRAMC2.L11 v6(27.5,176.8) VRAMC2.M12 ; VRAMC1.D3 v6(25.1,195.3) ; VRAMB1.T14 75.22,214.93 v6(75.64,214.51) ; VRAMD1.B1 23.9,155.88 23.9,155.88 23.76,155.74 v6(23.76,155.7) ; VRAMA1.G14 104.1,188.67 103.9,188.47 103.9,188.4 v6(103.78,188.29) ; VRAMC1.B3 v6(24.3,194.5) ; VRAMB1.P12 73.63,216.53 v6(74,216.9) ; v6(99.7,191.6) VRAMA1.N10 ; v6(82.72,226.18) 82.8,226.1 VRAMA2.T14 ; VRAMA1.D14 v6(106.5,188.2) ; VRAMD1.K3 v6(29.9,157.5) ; VRAMD2.R5 v6(54.4,142.3) ; VRAMA2.F12 v6(85.3,217.7) ; VRAMD2.M3 v6(52,145.5) VRAMD2.L2 ; VRAMA1.T12 v6(96.5,190.8) ; VRAMC2.M1 v6(26.7,185.6) ; VRAMB2.B12 v6(48.3,214.5) ; VRAMC2.D12 v6(33.1,176) ; VRAMC1.T12 v6(35.5,201.7) ; VRAMD1.T3 v6(35.5,157.5) ; v6(94.12,216.11) 94.09,216.11 VRAMA2.D1 ; VRAMC2.C5 v6(34.7,182.4) ; v6(32.3,163.9) VRAMD1.N10 ; VRAMA1.C5 v6(107.7,195.6) ; VRAMB2.N10 49.92,223.7 v6(50.1,223.52) ; VRAMB2.T12 v6(47.5,225.7) ; VRAMD1.T1 v6(34.7,156.7) ; VRAMB2.R10 v6(49.9,225.7) ; VRAMD2.T12 v6(60,142.3) ; v6(25.1,158.3) VRAMD1.D3 ; VRAMD2.N5 v6(54.6,144.3) ; VRAMC1.C5 v6(24.3,196.1) ; VRAMC1.P3 v6(33.1,195.3) ; VRAMD2.B12 v6(59.2,153.5) ; VRAMA1.T14 v6(96.5,188.4) ; VRAMD2.D3 v6(52.8,151.1) ; VRAMD1.B12 v6(24.3,165.5) ; v6(33.1,183.2) VRAMC2.D3
  TOP w0.381: GPU1.E20 68.05,195.1 v6(67.6,195.55) ; v6(80.65,182.4) 80.2,181.95 GPU1.Y33 ; GPU1.L27 75.85,190.65 ; GPU1.AC9 58.2,179.54 58.62,179.96 59.28,179.96 v6(59.33,180.01) ; v6(59.31,177.58) 59.8,178.07 GPU1.AD11 ; v6(66.4,170.95) 66.85,171.4 GPU1.AL19 ; v6(57.75,175.2) 58.2,175.65 GPU1.AF9 ; v6(79.18,183.6) 78.6,183.02 GPU1.W31 ; v6(61.26,188.69) 61.31,188.69 GPU1.P14 ; GPU1.R31 78.6,186.88 v6(78.99,187.27) ; v6(80.8,193.85) 80.35,193.4 GPU1.G33 ; GPU1.AW17 64.6,164.9 65.17,165.47 65.17,166.03 v6(65.2,166.06) ; v6(72.4,190.65) 71.95,190.2 GPU1.L24 ; v6(64,169.35) 64.45,169.8 GPU1.AN17 ; v6(77.19,188.32) 76.88,188.32 GPU1.N29 76.35,188.6 v6(76,188.25) ; GPU1.W13 61.4,183.15 v6(60.95,183.6) ; GPU1.G29 76.75,193.4 v6(77.2,193.85) ; GPU1.J14 62.05,191.8 v6(61.6,192.25) ; v6(62.8,166.15) 63.25,166.6 GPU1.AU15 ; GPU1.L17 64.15,190.65 ; GPU1.L20 68.05,190.2 v6(67.6,190.65) ; GPU1.AN20 68.05,169.8 67.7,169.45 67.59,169.45 v6(67.56,169.42) ; GPU1.J23 70.02,191.22 ; GPU1.AR18 65.65,168.2 v6(65.2,167.75) ; v6(80.65,186) 80.2,185.55 GPU1.U33 ; GPU1.J26 74.35,191.8 v6(74.8,192.25) ; GPU1.M12 v6(60.3,189.7)
  TOP w0.4: v6(56.95,182.4) 56.6,182.75 GPU1.W7 ; GPU1.U11 59.35,185.85 v6(59.35,186) ; v6(62.8,189.05) 62.95,189.05 GPU1.N15 ; GPU1.AG5 54.9,174.75 v6(55.35,175.2) ; GPU1.AG11 59.35,174.15 v6(59.35,174) ; GPU1.E12 60.55,195.55 v6(60.4,195.55) ; v6(83.85,187.2) 83.85,187.05 GPU1.R37 ; v6(61.7,171.7) GPU1.AK14 ; v6(61.7,171.7) v6(60.95,172.8) 60.95,172.95 GPU1.AJ13 ; v6(61.7,171.7) 62,171.4 GPU1.AL15 ; GPU1.AK9 57.75,171.75 v6(57.75,171.6) ; GPU1.J18 65.35,192.25 v6(65.2,192.25) ; GPU1.AU11 59.35,166.15 v6(59.2,166.15) ; GPU1.M5 54.45,189.45 v6(54.45,189.6) ; v6(73.6,189.05) 73.45,189.05 GPU1.N25 ; v6(60.4,164.45) 60.55,164.45 GPU1.AW12 ; GPU1.AE7 56.6,177.25 v6(56.95,177.6) ; GPU1.E27 75.25,195.1 v6(74.8,194.65) ; v6(62.8,193.85) 62.95,193.85 GPU1.G15 ; GPU1.G19 67.25,193.4 v6(67.6,193.05) ; GPU1.E17 64.75,195.1 v6(65.2,194.65) ; v6(59.22,193.76) 59.44,193.76 GPU1.G11 ; v6(56.15,187.2) 56.15,187.05 GPU1.R7 ; 75.85,190.65 v6(76,190.65) ; GPU1.AM5 54.45,170.55 v6(54.45,170.4) ; GPU1.P35 82.25,188.25 v6(82.25,188.4) ; v6(55.35,184.8) 54.9,185.25 GPU1.U5 ; GPU1.U39 85.55,185.85 v6(85.55,186) ; GPU1.G25 72.75,193.4 v6(72.4,193.05) ; GPU1.AN7 56.15,169.35 v6(56.15,169.2) ; v6(78.4,192.25) 78.25,192.25 GPU1.J30 ; GPU1.AJ7 56.15,172.95 v6(56.15,172.8) ; GPU1.P30 v6(78.3,188.3) ; GPU1.V9 57.75,184.65 v6(57.75,184.8) ; v6(66.33,189.04) 66.56,189.04 GPU1.N19 ; v6(85.55,189.6) 85.55,189.45 GPU1.M39 ; v6(60.95,187.2) 60.95,187.08 61.16,186.86 61.16,186.84 61.4,186.61 GPU1.R13 ; v6(79.6,195.55) 79.45,195.55 GPU1.E32 ; 70.02,191.22 70.02,190.48 69.99,190.45 v6(69.99,190.41) ; 64.15,190.65 v6(64,190.65) ; v6(54.45,194.4) 54.45,194.25 GPU1.F5 ; GPU1.Y11 59.35,182.25 v6(59.35,182.4)
  BOTTOM w0.089: v6(50.4,153.5) VRAMD2.B1 51.59,153.1 51.99,153.5 v6(52,153.5) 52.23,153.5 52.63,153.1 53.2,153.1 v6(53.6,152.7)
  BOTTOM w0.254: 37.93,214.75 PG199.2 ; 38.22,217.03 PG207.2 ; 38.04,219.32 PG246.2 ; 38.08,217.79 PG205.2 ; 37.96,213.98 PG247.2 ; 38.04,215.51 PG198.2 ; 38.06,216.27 PG203.2 ; 38.01,220.08 PG202.2 ; 38.06,218.56 PG206.2
  BOTTOM w0.305: C857.1 36.2,156.8 v6(35.5,157.5)
  BOTTOM w0.381: C813.1 24.16,202.64 v6(24.3,202.5) ; R644.2 45.15,225.61 v6(45.72,226.18) 45.79,226.26 C786.1 ; v6(54.45,194.4) 53.73,193.68 C697.1 53.52,193.7 C722.1 ; v6(78.99,187.27) 78.77,187.05 R611.1 ; v6(77.2,189.05) 77.15,189.1 C709.1 ; C889.1 55.59,142.28 55.2,141.9 ; C897.1 v6(106.1,190.8) ; R645.2 25.98,168.01 C1113.1 ; C792.1 57.31,224.51 v6(57.32,224.5) ; v6(35.54,185.65) 35.41,185.78 C851.1 ; v6(33.95,204.14) 34.11,204.3 C810.1 ; v6(54.6,144.3) 54.7,144.4 R661.2 R662.2 ; v6(107.7,195.6) 106.9,194.8 C839.1 105.68,194.5 R674.2 ; v6(75.75,222.75) 75.63,222.63 C767.1 ; C1114.1 61.63,143.67 v6(61.8,143.5) 62.24,143.5 62.43,143.31 R666.2 ; C757.1 90.71,224.45 90.15,223.89 v6(89.94,223.89) ; R631.2 R630.2 52.37,223.82 v6(52.94,223.82) 52.97,223.79 C1110.1 ; v6(26.7,185.6) 26.79,185.69 C849.1 ; v6(25.5,174.2) 25.92,173.78 C844.1 25.97,173.44 25.97,172.35 R710.2 ; v6(24.3,200.1) 24.48,200.28 C809.1 ; C762.1 87.68,224.1 v6(87.1,223.52) ; C768.1 75.63,224.67 v6(75.8,224.5) 75.89,224.41 C777.1 77.09,224.41 77.6,223.9 77.6,223.19 R643.2 ; C833.1 58.1,223.15 57.76,222.81 57.29,222.81 v6(57.24,222.76) ; C831.1 94.33,221.93 v6(94.1,221.7) ; C774.1 73.22,224.08 v6(73.2,224.1) ; v6(24,160.5) 24.44,160.06 C872.1 ; v6(26.7,164.7) 26.55,164.85 C859.1 25.25,164.85 v6(25.1,164.7) ; C1108.1 89.78,225.54 89.78,224.05 v6(89.94,223.89) ; R674.2 105.56,195.26 v6(105.7,195.4) 106.12,195.82 C898.1 ; R674.2 105.55,194.4 R673.2 ; v6(26.3,181.4) 26.42,181.28 R706.2 R705.2 ; R684.2 94.5,218.9 v6(94.1,219.3) ; 55.2,141.9 54.81,141.9 v6(54.4,142.3) ; 55.2,141.9 C832.1 57.42,141.9 C875.1 58.06,141.96 v6(58.4,142.3) ; R632.2 69.54,223.74 C830.1 ; v6(55.5,223.3) 55.41,223.21 C788.1 ; C785.1 45.76,217.89 v6(45.89,217.76) ; v6(23.9,185.8) 23.79,185.69 C848.1 ; v6(89.94,223.89) 89.42,223.38 R672.2 R675.2 ; C776.1 72.21,223.91 v6(72.4,224.1) ; v6(33.9,174.4) 33.89,174.39 C846.1 ; v6(66.33,189.04) 66.41,189.13 R613.1 ; v6(26.18,197.06) 26.7,196.54 C805.1 ; v6(26.18,197.06) 26.16,197.04 C808.1 24.59,196.67 24.3,196.39 ; v6(26.18,197.06) 26.67,197.55 R676.2 R677.2 ; v6(94.39,222.76) 94.24,222.76 93.98,222.5 C750.1 ; v6(47.5,225.7) 47.37,225.83 C797.1 ; v6(24.3,181.58) 24.59,181.87 C854.1 24.69,182.17 C1112.1 ; v6(108.2,188.15) 108.58,188.53 108.58,188.98 ; v6(48.3,224.9) 48.26,224.86 C795.1 ; v6(53.9,225.7) 53.9,225.7 C798.1 ; C816.1 22.76,199.16 22.76,200.04 v6(22.7,200.1) 22.51,200.29 C812.1 ; C791.1 56.97,226.51 v6(57.28,226.2) ; C802.1 27.43,192.9 v6(27.24,192.71) ; C803.1 26.79,194.59 v6(26.7,194.5) ; C770.1 71.58,225.3 72,225.3 v6(72.4,225.7) ; C901.1 108.35,190 108.31,190 ; R619.1 62.64,183.74 61.95,183.05 61.5,183.05 v6(60.95,183.6) ; v6(94.11,217.71) 94.29,217.53 C752.1 ; v6(64.4,223.3) 64.38,223.28 64.38,222.94 64.31,222.81 C778.1 ; v6(45.72,224.4) 45.86,224.26 C796.1 ; C758.1 82.95,225.96 v6(82.72,226.18) 81.84,225.3 R688.2 ; C793.1 55.5,222.5 v6(55.5,222.5) ; v6(25.1,202.5) 25.1,202.69 24.78,203.01 R691.2 ; C870.1 32.16,167.34 32.08,167.26 v6(32.08,167.21) ; v6(45.88,216.08) 45.7,215.9 C784.1 ; R628.2 26.42,160.92 26.42,160.3 v6(26.18,160.06)
  BOTTOM w0.4: v6(82.87,217.79) 82.86,217.79 82.84,217.8 82.29,217.8 C755.1 ; C860.1 26.29,163.09 v6(26.48,162.9) ; C806.1 33.9,192.4 v6(33.9,192.9) ; v6(96.5,188.4) 96.09,187.99 C903.1 ; v6(24.3,184) 24.16,184.14 C853.1 ; v6(107.7,198) 108.31,198 C895.1 ; v6(87.1,223.52) 86.91,223.71 C759.1 ; v6(24.3,176) 23.69,176 C840.1 ; C789.1 57.39,216.1 v6(57.1,216.1) ; C858.1 24.01,165.79 v6(24.3,165.5) ; C804.1 23.8,193.09 v6(23.8,192.72) ; C882.1 49.93,150.3 v6(50.4,150.3) ; v6(25.6,167.28) 25.6,167.5 25.67,167.57 25.67,167.7 C1113.1 ; C1115.1 106.37,199.26 v6(106.37,199.81) ; v6(106.9,197.2) 106.19,197.2 C904.1 106.01,197.2 v6(105.3,197.2) ; 27.49,156.4 27.49,156.01 27.24,155.76 27.24,155.71 v6(27.2,155.68) 27.24,155.68 27.27,155.65 28.05,155.65 v6(28.3,155.9) ; 27.49,156.4 27.49,157.49 v6(27.5,157.5) ; 27.49,156.4 C869.1 ; v6(82.88,216.07) 82.84,216.03 82.83,216.03 82.69,215.89 C760.1 ; C877.1 50.82,143.71 v6(50.19,143.71) ; C841.1 25.9,176.09 v6(25.9,176.8) ; v6(86.9,225.7) 86.31,225.7 C763.1 ; C753.1 93.91,226.2 v6(94.28,226.2) ; C891.1 100.09,188.01 v6(99.7,188.4) ; v6(61.6,153.5) 62.01,153.91 C888.1 ; v6(98.1,188.4) 98.1,187.51 C894.1 ; C886.1 61.99,149.91 v6(61.6,150.3) ; C761.1 84.36,225.84 v6(84.5,225.7) ; v6(99.77,199.62) 99.77,199.66 99.7,199.73 99.7,200.09 C902.1 ; v6(72.4,225.7) 71.16,226.94 C782.1 70.85,226.69 v6(70.85,226) ; C811.1 32.3,204.61 v6(32.3,204.1) ; v6(32.31,192.9) 32.31,192.89 32.29,192.86 32.29,192.28 C807.1 ; v6(25.52,192.66) 25.52,192.69 25.49,192.72 C801.1 ; v6(24,178.9) 23.31,178.9 C855.1 23.31,178.59 v6(24.3,177.6) ; v6(25.9,177.6) 26.14,177.84 C842.1 ; v6(26.3,181.4) 25.89,181.4 25,180.51 ; v6(33.9,155.9) 33.9,155.56 C864.1 ; v6(94.34,224.48) 94.29,224.48 94.26,224.51 C754.1 ; C814.1 23.82,203.83 v6(23.82,204.32) ; v6(85.3,223.3) 85.19,223.41 85.19,224.79 v6(85.3,224.9) ; v6(82.9,214.5) 82.29,213.89 C756.1 ; v6(108.1,199.85) 108.1,199.76 108.21,199.65 C899.1 ; C751.1 94.16,214.52 94.16,214.52 v6(94.14,214.52) ; v6(25.1,183.2) 25.81,183.2 C852.1 25.99,183.2 v6(26.7,183.2) ; C847.1 35.5,174.17 v6(35.5,174.4) ; R709.2 30.76,185.66 v6(30.7,185.6) ; 108.31,190 v6(107.7,190) ; C772.1 75.66,216.11 75.64,216.14 v6(75.62,216.14) ; v6(96.51,199.64) 96.51,199.7 96.51,199.71 C892.1 ; C780.1 64.29,217.69 64.35,217.76 v6(64.36,217.76) ; v6(88.42,226.21) 88.45,226.25 88.45,226.91 C765.1 88.07,227.3 87.02,227.3 v6(86.98,227.34) ; C790.1 49.31,225.7 v6(49.9,225.7) 50.6,226.4 50.6,226.51 C799.1 ; 25,180.51 C836.1 ; 25,180.51 25,180.71 24.3,181.41 v6(24.3,181.58) ; v6(59.22,193.76) 59,193.76 58.47,193.23 C698.1 ; C871.1 34.11,167.31 v6(33.9,167.1) ; v6(106.1,191.57) 105.77,191.89 C896.1 ; v6(60,142.3) 60,141.69 C876.1 ; v6(103.7,199.6) 104.41,199.6 C905.1 104.59,199.6 v6(105.3,199.6) ; v6(35.5,167.1) 36.11,167.71 C866.1 ; R639.2 57.17,219.23 v6(57.1,219.3) ; C872.1 v6(26.18,160.06) 26.18,159.58 C862.1 ; v6(54.6,144.3) 54.6,144.09 C889.1 ; C863.1 27.4,158.2 v6(27.5,158.3) ; C881.1 52.91,146.19 v6(52.8,146.3) ; C775.1 66.91,221.81 v6(66.8,221.7) ; R632.2 69.09,223.73 69.06,223.7 v6(68.6,223.7) ; C845.1 31.91,174.01 v6(32.3,174.4) ; v6(23.76,155.7) 23.76,155.74 23.8,155.78 23.8,156.09 C867.1 ; C764.1 91.91,223.3 v6(92.5,223.3) ; C1111.1 23.69,194.5 v6(24.3,194.5) ; C868.1 25.49,155.75 25.47,155.74 v6(25.47,155.69) ; C880.1 52.8,143.81 v6(52.8,143.1) ; C865.1 32.29,155.32 32.29,155.83 32.24,155.88 v6(32.24,155.89) ; v6(50.4,153.5) 50.39,153.49 C883.1 ; v6(74,225.73) 74,225.74 74,225.75 74,226.31 C779.1 ; v6(59.35,174) 59.98,174.62 60.93,174.62 C696.1 61.21,174.64 61.98,174.64 62.31,174.97 62.31,175.1 R620.1 ; v6(103.7,197.2) 103.81,197.09 C900.1 ; v6(108,193.25) 108.59,193.25 C838.1 108.75,192.59 108.4,192.59 107.7,191.89 107.7,191.62 v6(107.67,191.59) ; C885.1 58.21,144.09 v6(58.4,143.9) ; C861.1 23.69,157.5 v6(24.3,157.5) ; v6(75.77,226.2) 75.98,226.41 C769.1 ; R665.2 50.1,149 v6(50.4,148.7) ; v6(61.77,141.76) 61.67,141.76 61.58,141.67 C878.1 ; C771.1 66,226.31 66,225.73 v6(66,225.72) ; v6(50.21,141.86) 50.22,141.86 50.28,141.86 50.35,141.79 C879.1 ; v6(55.5,225.7) 55.5,226.31 C787.1 ; C799.1 50.79,227.3 50.01,227.3 v6(49.96,227.35) ; C799.1 51.45,226.64 v6(51.45,226) ; C887.1 62.49,151.9 v6(61.6,151.9) ; v6(52,142.3) 52,141.69 C874.1 ; v6(75.64,214.51) 75.65,214.5 75.83,214.5 C773.1 ; v6(50.4,146.3) 50.4,145.59 C884.1 50.4,145.41 v6(50.4,144.7) ; C794.1 49.91,223.71 v6(50.1,223.52) ; v6(32.28,185.63) 32.31,185.66 C850.1 ; 24.3,196.39 v6(24.3,196.1) ; v6(64.37,215.29) 64.3,215.23 64.3,215.2 63.78,214.68 C781.1 ; C708.1 60.93,172.78 v6(60.95,172.8) ; C843.1 23.92,174.08 23.8,174.19 v6(23.8,174.19) ; v6(66.8,223.3) v6(66.8,224.9) ; C1109.1 75.99,218.09 v6(75.6,217.7)
  BOTTOM w0.508: v6(106.5,188.2) 105.89,187.59 R687.2 ; v6(25.6,204.35) 25.6,204.39 25.73,204.52 C815.1 ; C906.1 105.22,200.7 105.22,199.68 v6(105.3,199.6) ; R633.2 R632.2 ; C710.1 78.69,183.11 v6(79.18,183.6) ; R628.2 R629.2
  vias: v1(21.21,170.69) v1(21.21,169.67) v1(21.34,174.24) v1(21.34,173.23) v1(21.46,171.7) v1(46.63,157.78) v1(50.06,199.47) v1(50.8,199.16) v1(50.77,198.32) v1(90.93,201.68) v1(91.19,200.79) v1(94.79,207.44) v1(94.92,208.43) v2(31.47,151.31) v2(37.69,151.76) v2(39.4,219.86) v2(51.33,200.63) v2(91.39,199.67) v4(27.28,150.9) v4(27.25,149.99) v4(27.25,149.05) v4(27.28,148.11) v4(28.24,150.88) v4(28.22,149.96) v4(28.22,149.02) v4(28.24,148.08) v4(29.24,150.9) v4(29.21,149.99) v4(29.24,149.02) v4(29.24,148.11) v4(38.96,218.77) v4(38.99,217.7) v4(38.99,216.59) v4(39.01,215.42) v4(39.04,214.27) v4(39.04,213.11) v4(39.95,218.77) v4(39.98,217.7) v4(39.98,216.59) v4(40.01,215.42) v4(40.03,214.27) v4(40.03,213.11) v6(21.13,201.4) v6(22.6,196.1) v6(22.6,190.05) v6(22.6,189.08) v6(22.58,188.17) v6(24,198.55) v6(51.3,224) v6(52.55,226) v6(53.9,227.4) v6(71.21,223.79) v6(89.66,226.31) v6(90.9,227.4)
