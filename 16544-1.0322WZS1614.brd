# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCORE_VSUM_N: length 41.1
  TOP w0.254: PR113.1 204.2,206.65 205.77,206.65 v1(206.1,206.98) 206.1,206.88 205.84,206.63 PR133.1 ; PR116.2 216.38,212.31 PC139.2 216.65,212.38 216.66,212.37 217.26,212.37 PR111.2 218.3,213.41 PC143.1 219.27,213.41 219.27,212.62 PR117.2 219.42,212.37 218.19,211.14 v1(218.19,211.07) ; PR142.1 205.46,202.86 v1(205.46,203.48) ; v1(204.65,210.29) 204.67,210.29 204.88,210.08 205.44,210.08 205.77,209.75 PR124.1
  L6 w0.254: v1(206.1,206.98) 206.1,207.21 208.06,209.17 215.78,209.17 216.87,210.26 217.55,210.26 218.19,210.9 v1(218.19,211.07)
  BOTTOM w0.254: PC137.1 217.56,212.2 PC140.2 ; PC137.1 PC506.1 PC135.1 ; PC137.1 217.78,211.51 218.19,211.1 v1(218.19,211.07) ; v1(205.46,203.48) 205.46,204.5 206.1,205.13 v1(206.1,206.98) v5(206.1,209.2) 206.1,209.73 205.54,210.29 v1(204.65,210.29)
PWR_VCORE_VSUM_P: length 31.3
  TOP w0.254: PR111.1 217.29,213.5 217.06,213.27 PC139.1 v1(216.46,214.3) ; v1(210.64,206.58) 209.7,207.52 PR125.1 209.42,207.49 PR134.1 209.8,205.49 211.1,205.49 211.48,205.1 211.48,201.4 v3(211.4,201.32) 210.21,200.13 PR143.1
  L4 w0.254: v1(216.46,214.3) 216.46,213.77 212.34,209.65 211.48,209.65 211.46,209.68 211.05,209.68 209.75,208.38 209.75,207.47 v1(210.64,206.58)
  BOTTOM w0.203: v1(216.46,214.3) 216.43,214.33 216.43,214.38 215.9,214.91 215.9,215.37 215.64,215.63 215.64,215.8 215.5,215.94 PU6.16
  BOTTOM w0.254: PR109.1 215.77,213.61 v1(216.46,214.3) 216.74,214.02 PC140.1
PWR_VCOREA_BOOT: length 5.5
  BOTTOM w0.203: PU6.24 212.3,215.83 211.76,215.29
  BOTTOM w0.508: PR120.2 211.68,212.6 v2(211.68,213.44) 211.68,215.21 211.76,215.29
PWR_VCOREA_BOOT_A: length 3.5
  BOTTOM w0.508: v5(208.86,210.05) PR120.1 208.31,211.71 207.77,211.18 PC149.2
PWR_VCOREA_HG: length 25.9
  L4 w1.016: v4(206.71,215.34) 206.65,215.34 205.46,214.15 199.36,214.15 194.84,209.63 188.59,209.63 187.63,208.66 v4(187.63,207.09)
  BOTTOM w0.203: 211.07,216.41 211.5,216.84 PU6.25
  BOTTOM w1.016: PR118.2 v4(187.63,207.09)
  vias: v5(209.8,215.67)
PWR_VCOREA_HG_A: length 4.6
  L6 w1.016: v4(192.63,211.23) v4(188.87,211.23)
  BOTTOM w0.508: v4(192.63,211.23) v2(192.63,210.34)
PWR_VCOREA_LG: length 18.4
  L4 w1.016: v4(197.97,219.81) 198.12,219.66 199.39,219.66 ; v4(201.8,219.79) 201.68,219.66 199.39,219.66 ; 199.39,219.66 199.52,219.53 199.52,218.82 200.61,217.73 203.38,217.73 204.24,218.59 206.96,218.59 208.03,217.53 208.76,217.53 208.79,217.55 209.17,217.55 209.19,217.53 210.06,217.53 v4(210.13,217.6)
  BOTTOM w0.203: v4(210.13,217.6) 210.21,217.6 210.82,218.21 PU6.27
  vias: v2(202.64,220.12)
PWR_VCOREA_PH: length 21.1
  L4 w1.016: v4(205.18,216.64) 205.18,216.56 204.55,215.93 198.63,215.93 v4(194.13,211.43)
  BOTTOM w0.203: PU6.26 210.95,217.81 210.74,217.6 210.74,217.39 210.27,216.92 209.45,216.92 209.17,217.2
  BOTTOM w0.508: v4(205.18,216.64) 205.1,216.56 205.1,214.89 206.23,213.77 206.38,213.77 207.21,212.93 PC149.1
  vias: v4(189.18,208.08) v4(191.39,208.23) v4(193.32,206.38) v4(193.75,207.77) v4(195.22,207.11) v4(195.61,208.36) v4(196.98,208.84) v4(197.26,207.47) v4(197.97,209.63) v4(198.55,210.92) v4(199.44,208.99) v4(199.82,210.41) v4(200.79,209.63) v4(200.99,211.07) v4(201.9,209.02) v4(202.13,210.49) v5(208.51,217.7)
PWR_VCOREA_SNB: length 2.6
  TOP w0.508: PC150.1 v3(195.4,216.74) PR121.2
PWR_VCOREA_VSUM_N_A: length 19.5
  TOP w0.254: v1(204.85,209.37) 204.85,209.25 205.75,208.34 PR124.2 PR123.2 PR122.2 ; PG41.2 196.16,204.39 195.99,204.57 195.99,205.23 v1(196.16,205.41)
  BOTTOM w0.254: 197.23,205.51 196.27,205.51 v1(196.16,205.41) ; 197.23,205.51 203.45,205.51 205.33,207.39 205.33,208.89 v1(204.85,209.37) ; 197.23,205.51 v5(197.23,205.13)
PWR_VCOREA_VSUM_P_A: length 22.3
  TOP w0.254: PR126.2 210.5,208.65 209.7,209.45 PR125.2 208.48,208.48 208.48,208.1 208.18,207.8 205.44,207.8 v1(204.77,208.46) ; v1(195.2,205.44) 195.2,204.72 194.89,204.42 PG42.2
  BOTTOM w0.254: v5(202.67,206.32) 202.67,206.02 ; 202.67,206.02 195.78,206.02 v1(195.2,205.44) ; 202.67,206.02 203.24,206.02 204.01,206.79 204.01,207.85 204.62,208.46 v1(204.77,208.46)
PWR_VCOREB_BOOT: length 2.2
  BOTTOM w0.203: PU6.34 210.7,221.01 210.38,221.33 210.06,221.65 210.06,222.12
  vias: v5(209.55,223.01)
PWR_VCOREB_BOOT_A: length 3.1
  BOTTOM w0.508: v5(205.92,225.53) PR128.1 205.51,223.62 PC155.2
PWR_VCOREB_HG: length 48.5
  L6 w0.635: v4(170.81,207.26) 170.79,207.26 170.54,207.52 170.54,212.24 173.41,215.11 185.37,215.11 192.68,222.43 204.17,222.43 v4(204.85,221.74)
  BOTTOM w0.203: 208.86,221.95 209.3,221.95 210.63,220.61 PU6.33
  BOTTOM w1.016: v4(170.81,207.26) 170.69,207.39 PR127.2
  vias: v5(208.18,222.22)
PWR_VCOREB_HG_A: length 3.8
  L6 w0.635: v4(172.64,211.1) v4(176.43,211.1)
  vias: v2(170.81,211.96)
PWR_VCOREB_LG: length 33.3
  L6 w0.635: v4(209.17,220.34) 205.69,223.82 190.68,223.82 186.59,219.74 v4(185.45,219.74) 185.42,219.71 v4(181.56,219.71)
  BOTTOM w0.203: PU6.31 210.34,219.81 209.8,220.34 v4(209.17,220.34)
  vias: v2(186.94,219.84)
PWR_VCOREB_PH: length 43.3
  L6 w0.635: v4(207.95,219.02) 206.3,220.68 203.94,220.68 203.58,221.03 193.26,221.03 185.95,213.72 181.18,213.72 v4(178.64,211.18)
  BOTTOM w0.203: PU6.32 210.42,220.21 209.7,220.93 208.71,220.93
  BOTTOM w0.508: PC155.1 202.92,221.97 204.7,220.19 206.55,220.19
  vias: v4(172.8,208.15) v4(174.14,210.08) v4(174.24,208.48) v4(176.05,210.06) v4(175.97,208.46) v4(177.47,208.23) v4(177.7,210.24) v4(178.74,209.22) v4(178.69,207.77) v4(180.01,207.98) v4(180.11,211.2) v4(181.18,208.91) v4(181.66,210.46) v4(183.03,209.25) v4(183.69,210.97) v4(185.22,209.14) v4(185.75,211.23) v5(208.08,220.37)
PWR_VCOREB_SNB: length 2.3
  TOP w0.508: PR129.2 v3(178.94,216.88) PC156.1
PWR_VCOREB_VSUM_N_A: length 41.2
  TOP w0.254: PR132.2 PR131.2 PR133.2 205.83,205.18 204.98,205.18 v1(204.83,205.03) ; v1(179.48,203.35) 179.16,203.67 179.16,205.46 179.41,205.71 PG46.2
  BOTTOM w0.254: v2(179.43,201.6) 179.07,201.6 ; 179.07,201.6 179.07,202.94 v1(179.48,203.35) ; 179.07,201.6 179.07,200.74 180.55,199.26 201.47,199.26 203.91,201.71 203.91,204.29 204.65,205.03 v1(204.83,205.03)
PWR_VCOREB_VSUM_P_A: length 45.3
  TOP w0.254: PG47.2 178.23,205.71 178.65,205.3 178.65,203.67 v1(178.33,203.35) ; PR135.2 210.15,204.66 PR134.2 208.94,203.94 208.38,204.5 207.85,204.5 207.75,204.6 206.83,204.6 206.73,204.5 205.18,204.5 204.8,204.11 v1(204.77,204.11)
  BOTTOM w0.254: 204.42,202.49 204.42,203.86 204.67,204.11 v1(204.77,204.11) ; 204.42,202.49 204.42,201.5 201.68,198.75 180.34,198.75 178.56,200.53 178.56,203.12 v1(178.33,203.35) ; 204.42,202.49 v2(204.77,202.49)
PWR_VCOREC_BOOT: length 0.8
  BOTTOM w0.203: 211.5,222.58 PU6.36
  vias: v5(209.58,224.82)
PWR_VCOREC_BOOT_A: length 3.5
  BOTTOM w0.508: v5(207.06,228.14) 208.43,228.14 PR137.1 208.48,229.26 PC161.1
PWR_VCOREC_HG: length 73.1
  L4 w0.762: v4(210.26,228.7) 210.26,229.46 209.19,230.53 207.87,230.53 207.51,230.89 178.21,230.89 172.47,225.15 162.92,225.15 157.86,220.09 157.86,215.26 155.19,212.6 155.19,210.19 v4(157.1,208.28)
  BOTTOM w0.203: PU6.37 212.3,223.33 211.96,223.67
  vias: v5(211.23,224.97)
PWR_VCOREC_HG_A: length 5.1
  TOP w0.635: PU15.4 v4(160.1,210.92)
  L4 w0.635: v4(160.1,210.92) 160.02,211 156.67,211 v4(156.59,210.92)
  vias: v2(157.1,209.17)
PWR_VCOREC_LG: length 58.3
  TOP w0.635: v4(165.13,219.81) PU17.4
  L4 w0.762: 166.93,219.63 166.93,220.45 167.77,221.28 173.3,221.28 179.85,227.84 206.25,227.84 209.98,224.1 v4(213.03,224.1) ; 166.93,219.63 165.3,219.63 v4(165.13,219.81) ; 166.93,219.63 168.73,219.63 v4(168.88,219.79)
  BOTTOM w0.203: v4(213.03,224.1) 213.03,224.05 213.1,223.97 PU6.39
  vias: v5(170.81,219.07)
PWR_VCOREC_PH: length 71.9
  L4 w0.762: v4(212.19,225.96) 210.41,225.96 207.37,229.01 207.24,229.01 206.88,229.36 178.84,229.36 173.53,224.05 173.53,224.05 173.1,223.62 163.88,223.62 161.49,221.23 161.49,211.81 v4(162.05,211.25)
  BOTTOM w0.203: PU6.38 212.7,223.54 212.45,223.8 212.45,225.15
  BOTTOM w0.508: PC161.2 210.69,229.87 211.58,228.98 211.63,228.93 211.63,228.3 212.04,227.89 212.04,227 v2(211.99,226.95)
  vias: v4(158.5,208.2) v4(159.26,209.78) v4(159.77,208.66) v4(160.38,207.59) v4(160.96,208.99) v4(162.36,207.52) v4(162.53,209.75) v4(163.4,211.1) v4(163.63,208.69) v4(164.82,210.67) v4(165.35,208.86) v4(166.07,209.98) v4(166.7,211.23) v4(167.49,209.12) v4(167.64,210.31) v4(168.5,211.2) v4(169.01,209.55)
PWR_VCOREC_SNB: length 2.3
  TOP w0.508: PC162.1 v3(162.61,216.74) PR138.2
PWR_VCOREC_VSUM_N_A: length 55.5
  TOP w0.254: v1(163.22,203.83) 162.9,204.15 162.9,205.17 163.35,205.61 PG52.2 ; v1(205.36,200.86) 205.79,201.29 PR142.2 205.8,201.65 PR140.2 206.84,201.64 PR141.2
  BOTTOM w0.254: 177.57,200.33 179.92,197.99 202.18,197.99 205.02,200.84 205.33,200.84 v1(205.36,200.86) ; 177.57,200.33 v2(177.8,200.56) ; 177.57,200.33 177.25,200.66 163.28,200.66 162.92,201.02 162.92,203.52 v1(163.22,203.83)
PWR_VCOREC_VSUM_P_A: length 57.3
  TOP w0.254: PG51.2 162.15,205.46 162.39,205.22 162.39,204.15 v1(162.07,203.83) ; PR144.2 208.99,201.7 PR143.2 207.37,200.08 205.44,200.08 205.31,199.95 v1(205.28,199.95)
  BOTTOM w0.254: v1(162.07,203.83) 162.41,203.5 162.41,202.31 ; v2(162.05,202.31) 162.41,202.31 ; 162.41,202.31 162.41,200.81 163.07,200.15 177.04,200.15 179.71,197.49 202.39,197.49 204.9,200 205.23,200 v1(205.28,199.95)
PWR_VDDC_ADDRESS: length 6.3
  TOP w0.203: PU39.41 115.4,152.37 115.32,152.45 115.32,153.9 114.58,154.64
  TOP w0.254: 114.58,154.64 114.15,155.07 v3(114.15,156.06) 114.17,156.06 114.22,156.11 115.23,156.11 PR249.1
PWR_VDDC_CONFIG: length 4.6
  TOP w0.203: PU39.21 115.8,144.55
  TOP w0.254: 115.8,144.55 116.08,144.27 v1(116.08,144.15)
  BOTTOM w0.254: PR258.2 114.2,144.76 v5(114.81,144.15) v1(116.08,144.15)
PWR_VDDC_EN: length 37.4
  TOP w0.203: PU39.13 111.53,145.74
  TOP w0.254: v1(109.91,144.4) 110.18,144.4 111.14,145.36 111.14,145.36 111.53,145.74
  L6 w0.254: v1(107.62,124.99) 108.74,124.99 112.7,128.96 112.7,131.47 106.76,137.41 106.76,141.26 107.02,141.53 107.02,142.1 108.66,143.74 108.66,143.87 109.19,144.4 v1(109.91,144.4)
  BOTTOM w0.254: PG228.1 v5(104.72,124.42) 105.3,124.99 v1(107.62,124.99) ; PR235.1 109.98,144.48 v1(109.91,144.4)
PWR_VDDC_PALERT#: length 3.7
  TOP w0.203: 115.57,143.89 115.4,144.06 PU39.20
  TOP w0.254: PR247.1 115.85,142.89 115.85,143.61 115.57,143.89
PWR_VDDC_PCLK: length 3.4
  TOP w0.203: 114.6,144.15 PU39.18
  TOP w0.254: 114.6,144.15 114.6,143.86 114.27,143.53 PR245.1
PWR_VDDC_PDATA: length 3.4
  TOP w0.203: PU39.19 115,144.21
  TOP w0.254: 115,144.21 115,143.75 115.11,143.64 v3(115.11,143.43) 115.29,143.26 PR246.1
PWR_VDDC_PG: length 4.8
  TOP w0.203: 113.76,144.87 113.8,144.92 PU39.16
  TOP w0.254: v3(110.9,142.99) 112.03,142.99 PR405.1 112.03,143.53 112.39,143.89 112.8,143.89 113.76,144.85 113.76,144.87
PWR_VDDC_PG_A: length 9.8
  TOP w0.254: v1(108.1,141.6) 107.77,141.94 107.77,141.96 107.46,142.27 PR345.2 ; v1(110.95,139.12) 111.31,139.48 PR231.2 111.91,139.48 111.91,140.65 TP122.1 112.03,140.79 PR405.2
  L3 w0.254: v1(110.95,139.12) 110.95,140.49 109.83,141.6 v1(108.1,141.6)
PWR_VDDC_SALERT#: length 3.6
  TOP w0.203: PU39.9 110.88,147.74 110.59,147.45
  TOP w0.254: 110.59,147.45 110.13,146.99 v3(109.78,146.99) 109.6,146.81 PR243.1
PWR_VDDC_SCLK: length 3.5
  TOP w0.203: PU39.8 110.45,148.14 109.93,147.62 109.75,147.62
  TOP w0.254: PR237.1 108.83,147.62 109.75,147.62
PWR_VDDC_SDATA: length 3.9
  TOP w0.203: PU39.10 110.99,147.34 110.68,147.04 110.68,146.93
  TOP w0.254: 110.68,146.93 110.06,146.31 109.13,146.31 PR238.1
PWR_VDDC_TEMP: length 9.1
  TOP w0.203: v1(112.98,153.21) 113.26,152.93 113.68,152.93 114.2,152.41 PU39.44
  L6 w0.254: v1(112.98,153.21) 112.98,153.46 113.57,154.05 115.7,154.05 v1(116.15,153.59)
  BOTTOM w0.254: v1(116.15,153.59) 116.15,153.67 116.09,153.73 PC298.1 116.09,155.52 PR265.2 116.07,156.3 v2(115.85,156.51)
PWR_VDDC_TEMP_A: length 39.3
  TOP w0.254: PQ9.B 106.29,137.48 107.07,136.7 107.61,136.7 PQ9.C 107.81,136.49 108.84,135.46 114.88,135.46 v1(115.11,135.69) ; v1(114.76,156.87) 114.86,156.97 115.9,156.97 116.42,157.49 PC299.1
  L4 w0.254: v1(114.76,156.87) 114.55,156.67 114.55,155.55 115.6,154.51 115.6,151.33 117.09,149.83 117.09,147.8 114.08,144.79 114.08,140.39 113.64,139.94 113.64,136.93 114.88,135.69 v1(115.11,135.69)
  BOTTOM w0.254: v1(115.11,135.69) 115.24,135.56 115.98,135.56 v2(116.15,135.74) ; v1(114.76,156.87) 114.76,155.96 115.15,155.56 115.16,155.56 PR265.1
PWR_VDDC_TEMP_B: length 40.4
  TOP w0.254: PQ9.E 108.05,135.52 108.61,134.95 114.88,134.95 v1(115.06,134.77) ; v1(114.67,157.78) 114.76,157.78 115.06,157.48 115.48,157.48 PC299.2
  L4 w0.254: v1(114.67,157.78) 114.67,157.75 114.05,157.12 114.05,155.34 115.09,154.3 115.09,151.12 116.59,149.62 116.59,148.01 113.58,145 113.58,140.6 113.13,140.15 113.13,136.72 113.92,135.93 113.92,135.92 v1(115.06,134.77)
  BOTTOM w0.254: v1(115.06,134.77) 115.47,134.36 v2(115.94,134.36) ; PR266.1 114.15,155.69 114.15,157.23 114.67,157.75 v1(114.67,157.78)
PWR_VDDC_THWN: length 62.3
  BOTTOM w0.254: PR310.2 43.38,121.84 45.47,123.93 49.55,123.93 49.98,123.49 53.54,123.49 53.73,123.3 PR296.2 54.79,122.88 55.58,123.67 58.52,123.67 59.07,124.22 PR282.2 67.93,124.22 68.3,124.59 71.37,124.59 72.2,123.76 PR309.2 86.02,123.76 86.44,123.34 PR295.2 86.75,123.56 87.07,123.88 88.16,123.88 88.62,123.42 v2(91.49,123.42) 91.64,123.57 98.25,123.57 98.4,123.42 PR281.2 99.15,123.79 99.78,124.42 PG228.2
PWR_VDDC_VCC: length 8.4
  TOP w0.203: PU39.42 115,152.28 114.99,152.3 114.99,152.86 v1(114.53,153.31)
  TOP w0.508: PR221.2 112.78,155.68 114.53,153.92 v1(114.53,153.31)
  BOTTOM w0.508: PC274.1 113.78,151.25 v2(114.05,151.51) 114.53,151.99 v1(114.53,153.31)
PWR_VDDC_VCCS: length 10.3
  TOP w0.203: PU39.43 114.6,152.48 113.79,153.29 v1(113.79,153.52)
  TOP w0.254: v1(113.79,153.52) 112.85,154.46 PC275.1
  BOTTOM w0.254: PC298.2 114.26,154.58 PR266.2 PR268.2 113.08,154.03 113.59,153.52 v1(113.79,153.52) 113.79,153.19 v2(113.01,152.4) 112.46,151.85 PC300.2
PWR_VDDC_VDDIO: length 4.4
  TOP w0.203: 110.55,146.2 110.55,146.29 111.2,146.94 PU39.11
  TOP w0.254: 110.55,146.2 109.99,145.65 v3(109.86,145.65) 109.85,145.64 109.38,145.64 109,145.26 108.99,145.26 108.49,144.76 PR239.1
PWR_VDDC_VINSEN: length 8.4
  TOP w0.203: v1(116.46,143.38) 116.46,143.51 116.59,143.64 116.59,144.53 116.2,144.91 PU39.22
  TOP w0.381: v1(116.46,143.38) 116.97,142.88 116.97,142.81 PR233.1
  BOTTOM w0.508: v5(117.37,143.06) 116.78,143.06 v1(116.46,143.38) 116.79,143.71 116.79,144.44 116.48,144.75 116.48,145.24 PC278.1 116.17,145.55 PR234.1
PWR_VDDC_VRHOT: length 6
  TOP w0.203: PU39.15 113.4,145 112.8,144.4 111.85,144.4 v3(111.68,144.23)
  TOP w0.254: PR240.1 110.43,142.47 110.24,142.66 110.24,143.26 111.13,144.15 111.6,144.15 v3(111.68,144.23)
PWR_VDDCA_BOOT: length 4.4
  TOP w0.305: PU40.4 96.25,119.22 95.86,118.82 v1(95.71,118.82)
  BOTTOM w0.508: v2(97.38,119.53) 97.38,119.15 97.37,119.15 PC309.1 96.18,118.82 v1(95.71,118.82)
PWR_VDDCA_BOOT_A: length 2.8
  BOTTOM w0.508: PC309.2 98.14,117.23 PR275.1 98.23,116.06 v2(97.92,115.75)
PWR_VDDCA_EN_A: length 4.1
  TOP w0.254: v1(98.07,122.64) 98.66,122.06 PU40.39
  BOTTOM w0.254: v1(98.07,122.64) 97.93,122.78 v2(96.93,122.78) 96.78,122.63 96.78,121.9 PR277.1
PWR_VDDCA_ISEN_N: length 78
  TOP w0.203: v1(117.65,152.48) 117.3,152.48 117,152.18 PU39.37
  TOP w0.254: v1(101.88,132.13) 101.77,132.03 100.25,132.03 99.85,132.44 99.8,132.48 PG162.1
  BOTTOM w0.254: v1(101.88,132.13) 102.2,131.81 102.67,131.81 108.06,126.42 112.49,126.42 116.43,130.35 124.72,130.35 130.68,136.31 130.68,138.45 132.36,140.13 132.36,150.01 129.79,152.57 129.79,155.7 127.51,157.99 126.07,157.99 123.32,155.24 123.32,154.22 122.66,153.56 122.66,153.26 v5(122.12,152.73) PC293.1 119.74,152.73 PC294.1 119.44,152.44 118,152.44 117.71,152.42 v1(117.65,152.48)
PWR_VDDCA_ISEN_P: length 74.7
  TOP w0.254: PG161.1 99.95,131.32 100.15,131.52 101.34,131.52 v1(101.88,130.98)
  BOTTOM w0.254: v5(123.22,156.46) 123.52,156.16 ; 123.52,156.16 125.86,158.5 127.72,158.5 130.3,155.91 130.3,152.78 132.87,150.22 132.87,139.92 131.19,138.24 131.19,136.1 124.94,129.84 116.64,129.84 112.7,125.91 107.85,125.91 102.45,131.31 102.2,131.31 v1(101.88,130.98) ; 123.52,156.16 122.81,155.45 122.81,154.43 122.33,153.95 PR259.2
PWR_VDDCA_ISEN_P_A: length 6.3
  TOP w0.203: PU39.38 116.6,152.44 117.12,152.96
  TOP w0.254: v1(118.14,153.26) 117.42,153.26 117.12,152.96
  BOTTOM w0.254: v1(118.14,153.26) 118.01,153.39 118.01,153.99 v2(118.19,154.16) PC294.2 119.82,154.16 120.08,153.95 PR259.1
PWR_VDDCA_PH: length 9.4
  TOP w0.305: v1(96.34,116.18) 96.34,117.41 96.65,117.72 PU40.7 ; v6(100.47,116.64) 100.16,116.33 PU40.15
  L3 w0.508: v6(100.47,116.64) 99.65,115.82 97.44,115.82 97.08,116.18 v1(96.34,116.18)
  BOTTOM w0.508: v1(96.34,116.18) 96.7,116.54 PR275.2
  vias: v2(97.41,129.41) v2(99.31,126.87) v2(100.97,129.54) v4(96.09,127.66) v4(96.06,126.7) v4(96.39,125.35) v4(96.95,128.14) v4(97,127.13) v4(96.98,126.16) v4(97.54,124.59) v4(98.91,124.64) v4(101.98,128.04) v4(102.01,127.03) v4(102.01,125.91) v6(100.53,120.24) v6(100.52,119.35) v6(100.52,118.47) v6(100.49,117.53) v6(101.35,120.24) v6(101.33,119.35) v6(101.33,118.47) v6(101.33,117.6) v6(101.31,116.61) v6(102.08,120.24) v6(102.12,119.33) v6(102.07,118.47) v6(102.09,117.63) v6(102.14,116.56)
PWR_VDDCA_PWM: length 46.7
  TOP w0.203: PU39.1 111.29,150.94 110.36,151.87 110.36,152.27
  TOP w0.254: 110.36,152.27 v3(110.34,152.29) 109.52,153.11 v1(109.47,153.11) ; PR279.2 95.42,124.01 v1(94.79,124.64)
  L3 w0.254: v1(109.47,153.11) 109.47,152.7 110.54,151.64 110.54,145.9 105.16,140.51 105.16,125.22 103.2,123.27 96.16,123.27 v1(94.79,124.64)
PWR_VDDCA_PWM_A: length 3.2
  TOP w0.254: PU40.40 98.16,121.78 v3(96.93,123.01) 96.4,123.54 PR279.1
PWR_VDDCA_SMOD#: length 3.4
  TOP w0.254: v3(95.65,122.51) 95.4,122.26 PR273.1 95.7,121.49 96.48,120.72 PU40.1
PWR_VDDCA_SNB: length 2.8
  TOP w0.508: v3(106.93,124.33) 105.75,124.33 PC310.1 104.58,124.24 PR271.2
PWR_VDDCA_THWN#: length 3.6
  TOP w0.254: PU40.38 99.16,122.31 v1(98.93,122.53)
  BOTTOM w0.254: v1(98.93,122.53) 99.29,122.17 v2(99.95,122.17) 100.04,122.26 PR281.1
PWR_VDDCB_BOOT: length 4.2
  TOP w0.305: v1(84.45,119.2) 84.47,119.22 PU42.4
  BOTTOM w0.508: v2(85.95,119.72) 85.95,119.18 PC330.1 84.45,119.09 v1(84.45,119.2)
PWR_VDDCB_BOOT_A: length 2.8
  BOTTOM w0.508: v2(85.98,116.03) 86.18,116.03 86.69,116.54 PR290.1 86.69,118.38 PC330.2
PWR_VDDCB_EN_A: length 4.4
  TOP w0.254: PU42.39 87.12,122.04 86.09,123.08 v1(85.95,123.08)
  BOTTOM w0.254: v1(85.95,123.08) 86.03,123 86.03,122.99 86.36,122.66 v2(86.36,122.17) 86.36,122.14 86.58,121.92 PR292.1
PWR_VDDCB_ISEN_N: length 81.9
  TOP w0.203: 119.2,151.13 118.61,150.54 PU39.35
  TOP w0.254: 119.2,151.13 119.2,152.32 120.21,153.32 120.21,154.11 122.06,155.97 PC292.1 124.34,155.97 124.65,156.27 PC291.1 126.56,156.27 v1(126.57,156.26) ; v1(90.35,132.13) 90.09,131.88 88.69,131.88 88.29,132.28 PG172.1
  BOTTOM w0.254: v1(126.57,156.26) 127.4,156.26 127.57,156.09 127.94,155.72 ; 127.94,155.72 128.52,155.14 128.52,151.81 131.09,149.24 131.09,140.77 129.31,138.99 129.31,137.01 126.16,133.86 125.74,133.86 118.36,133.86 116.79,132.28 113.93,132.28 112.44,133.77 95.54,133.77 93.54,131.78 90.7,131.78 v1(90.35,132.13) ; 127.94,155.72 v5(127.66,155.45)
PWR_VDDCB_ISEN_P: length 72.3
  TOP w0.254: PR257.2 126.02,157.8 v1(126.62,157.2) ; v1(90.35,130.98) 89.96,131.37 88.59,131.37 88.32,131.09 PG171.1
  BOTTOM w0.254: 115.49,131.78 117,131.78 118.57,133.35 125.53,133.35 126.37,133.35 129.81,136.8 129.81,138.78 131.6,140.56 131.6,149.45 129.03,152.02 129.03,155.35 127.2,157.18 127.08,157.18 v1(126.62,157.2) ; 115.49,131.78 v2(115.49,131.42) ; 115.49,131.78 113.72,131.78 112.23,133.26 95.75,133.26 93.75,131.27 90.63,131.27 v1(90.35,130.98)
PWR_VDDCB_ISEN_P_A: length 11.6
  TOP w0.203: PU39.36 118.3,150.94 118.75,151.38
  TOP w0.254: 118.75,151.38 118.75,152.4 119.82,153.48 119.82,154.88 121.92,156.97 v3(122.56,156.97) 123.07,157.49 PC292.2 124.76,157.49 PR257.1
PWR_VDDCB_PH: length 9.5
  TOP w0.305: PU42.15 88.62,116.33 v6(88.94,116.64) ; PU42.7 85.08,117.72 84.81,117.45 v1(84.81,116.18)
  L3 w0.508: v1(84.81,116.18) 85.29,116.18 85.65,115.82 88.12,115.82 v6(88.94,116.64)
  BOTTOM w0.508: v1(84.81,116.18) 84.81,116.78 PR290.2
  vias: v2(85.72,129.29) v2(88.52,127.38) v2(90.04,129.29) v4(84.94,127.66) v4(84.91,126.7) v4(85.8,128.14) v4(85.83,126.16) v4(85.85,127.13) v4(86.56,124.64) v4(87.76,124.64) v4(88.87,124.64) v4(90.83,128.04) v4(90.86,127.03) v4(90.86,125.91) v6(89,120.24) v6(88.99,119.35) v6(88.99,118.47) v6(88.96,117.53) v6(89.81,120.24) v6(89.8,119.35) v6(89.8,118.47) v6(89.8,117.6) v6(89.77,116.61) v6(90.54,118.47) v6(90.55,120.24) v6(90.59,119.33) v6(90.56,117.63) v6(90.61,116.56)
PWR_VDDCB_PWM: length 55.9
  TOP w0.203: PU39.2 111.21,150.54 109.65,152.1 v1(108.64,152.1)
  TOP w0.254: PR294.2 83.8,123.37 84.33,122.84 v1(84.33,122.71)
  L3 w0.254: v1(108.64,152.1) 109.09,151.64 109.09,150.38 109.07,150.36 109.07,146.12 97.97,135.03 83.43,135.03 82.94,134.54 82.94,124.7 84.33,123.32 v1(84.33,122.71)
  BOTTOM w0.254: v1(108.64,152.1) 108.74,151.99 v2(109.59,151.99)
PWR_VDDCB_PWM_A: length 3.6
  TOP w0.254: PU42.40 86.62,121.86 86.16,122.33 85.93,122.33 85.09,123.17 v3(85.08,123.17) 84.69,123.56 PR294.1
PWR_VDDCB_SMOD#: length 3.7
  TOP w0.254: PU42.1 85.1,120.72 84.07,121.75 PR288.1 83.46,122.02 v3(83.46,122.81)
PWR_VDDCB_SNB: length 2.8
  TOP w0.508: PR285.2 92.61,124.16 93.57,124.16 v3(93.6,124.13) 93.93,123.8 PC332.1
PWR_VDDCB_THWN#: length 2.9
  TOP w0.254: PU42.38 87.62,122.41 87.64,122.43 v1(87.64,122.51)
  BOTTOM w0.254: v2(88.68,122.48) 87.67,122.48 v1(87.64,122.51) PR295.1
PWR_VDDCC_BOOT: length 3.4
  TOP w0.305: PU44.4 73.57,119.22 73.3,118.95 v1(73.3,118.95)
  BOTTOM w0.508: PC359.1 73.96,118.95 v1(73.3,118.95) 72.85,119.4 v2(72.62,119.4)
PWR_VDDCC_BOOT_A: length 3.1
  BOTTOM w0.508: v2(75.56,120.14) 75.56,118.86 PC359.2 75.69,118.65 75.69,117.25 PR303.1
PWR_VDDCC_EN_A: length 3.8
  TOP w0.254: PU44.39 76.02,122.35 v1(75.84,122.53)
  BOTTOM w0.254: v1(75.84,122.53) 75.79,122.58 74.7,122.58 v2(74.55,122.43) 74.43,122.31 PR305.1
PWR_VDDCC_ISEN_N: length 85.7
  TOP w0.203: 118.88,149.74 PU39.33
  TOP w0.254: v1(79.25,132.13) 79.09,131.98 77.72,131.98 77.32,132.38 PG182.1 ; v1(126.62,152.5) 126.44,152.68 126.14,152.68 125.92,152.46 PC286.1 125.16,152.46 124.35,153.27 PC288.1 121.88,153.27 120.14,151.54 120.14,150.97 119.92,150.75 119.89,150.75 118.88,149.74
  BOTTOM w0.254: 127.64,150.89 127.13,151.4 127.13,152.3 126.94,152.49 126.88,152.49 v1(126.62,152.5) ; 127.64,150.89 129.82,148.71 129.82,141.31 128.04,139.52 128.04,137.53 125.63,135.13 117.77,135.13 116.2,133.55 114.56,133.55 112.63,135.48 83.46,135.48 79.89,131.92 79.46,131.92 v1(79.25,132.13) ; 127.64,150.89 v5(127.38,150.62)
PWR_VDDCC_ISEN_P: length 78.3
  TOP w0.254: PG181.1 77.19,130.99 77.67,131.47 78.76,131.47 v1(79.25,130.98) ; PR255.2 126.61,153.48 v1(126.67,153.42)
  BOTTOM w0.254: v1(79.25,130.98) 79.67,131.41 80.1,131.41 83.67,134.98 112.42,134.98 114.35,133.05 116.41,133.05 117.98,134.62 125.84,134.62 128.54,137.32 128.54,139.31 130.33,141.1 130.33,148.92 127.64,151.61 127.64,152.58 127.38,152.83 ; 127.38,152.83 126.8,153.42 v1(126.67,153.42) ; 127.38,152.83 v5(127.64,153.09)
PWR_VDDCC_ISEN_P_A: length 10.2
  TOP w0.203: PU39.34 118.77,150.14 119.76,151.13
  TOP w0.254: PR255.1 124.79,154.8 PC288.2 123,154.8 v3(122.5,154.31) 121.79,154.31 119.76,152.27 119.76,151.13
PWR_VDDCC_PH: length 9.7
  TOP w0.305: PU44.7 74.21,117.72 73.51,117.02 v1(73.51,116.26) ; PU44.15 77.52,116.33 77.54,116.33 77.84,116.62 v6(77.84,116.64)
  L3 w0.508: v1(73.51,116.26) 73.94,115.82 77.02,115.82 v6(77.84,116.64)
  BOTTOM w0.508: v1(73.51,116.26) 73.51,116.38 PR303.2
  vias: v2(74.55,129.41) v2(77.72,127.13) v2(78.99,129.29) v4(73.84,127.66) v4(73.81,126.7) v4(74.7,128.14) v4(74.73,126.16) v4(74.75,127.13) v4(75.46,124.64) v4(76.66,124.64) v4(77.77,124.64) v4(79.73,128.04) v4(79.76,127.03) v4(79.76,125.91) v6(77.9,120.24) v6(77.89,119.35) v6(77.89,118.47) v6(77.86,117.53) v6(78.71,120.24) v6(78.7,119.35) v6(78.7,118.47) v6(78.7,117.6) v6(78.67,116.61) v6(79.44,118.47) v6(79.45,120.24) v6(79.49,119.33) v6(79.46,117.63) v6(79.51,116.56)
PWR_VDDCC_PWM: length 63.6
  TOP w0.203: 110.13,151.1 111.1,150.14 PU39.3
  TOP w0.254: 110.13,151.1 v1(108.56,151.1) ; PR307.2 72.9,124.48 v1(72.85,124.54)
  L3 w0.254: v1(72.85,124.54) 71.75,125.63 71.75,135.56 72.21,136.02 97.69,136.02 104.62,142.95 104.62,144.75 106.35,146.48 107.75,146.48 108.18,146.91 108.18,150.72 v1(108.56,151.1)
  BOTTOM w0.254: v2(109.46,150.73) 108.93,150.73 v1(108.56,151.1)
PWR_VDDCC_PWM_A: length 3.3
  TOP w0.254: PR307.1 74.46,123.59 v3(74.85,123.2) 74.93,123.12 74.93,122.33 75.52,121.73 PU44.40
PWR_VDDCC_SMOD#: length 3.1
  TOP w0.254: PR301.1 72.56,122.23 v3(73.36,121.43) 74.08,120.72 PU44.1
PWR_VDDCC_SNB: length 2.4
  TOP w0.508: PC361.1 82.47,124.03 82.45,124.05 v3(82.45,124.1) 81.46,124.1 PR299.2
PWR_VDDCC_THWN#: length 3.1
  TOP w0.254: v1(76.61,122.66) 76.61,122.1 76.52,122.02 PU44.38
  BOTTOM w0.254: v2(76.71,121.67) 76.71,121.79 76.61,121.89 v1(76.61,122.66) 76.82,122.87 PR309.1
PWR_VDDCD_BOOT: length 4.2
  TOP w0.305: v1(58.88,119.18) 58.94,119.24 PU41.4
  BOTTOM w0.508: v2(60.33,119.73) 60.33,119.08 PC311.1 59.25,118.83 59.22,118.83 v1(58.88,119.18)
PWR_VDDCD_BOOT_A: length 3
  BOTTOM w0.508: v2(60.58,115.7) 61.19,116.31 PR276.1 61.11,117.25 61.11,118.34 PC311.2
PWR_VDDCD_EN_A: length 4.7
  TOP w0.254: v1(61.47,122.94) 61.62,122.78 PU41.39
  BOTTOM w0.254: PR278.1 60.44,122.06 60.71,121.79 60.71,121.79 v2(61.09,121.41) 61.21,121.41 61.47,121.67 v1(61.47,122.94)
PWR_VDDCD_ISEN_N: length 88.9
  TOP w0.254: v1(126.57,148.97) 126.36,149.18 PC285.1 125.22,149.48 123.7,149.48 123.61,149.57 PC284.1 123.01,149.55 R2767.2 ; PG164.1 62.81,132.18 63.13,131.86 63.71,131.86 v1(64.14,132.29)
  BOTTOM w0.254: 128.2,148.27 128.55,147.92 128.55,141.89 126.67,140.01 126.67,137.96 125.16,136.45 122.04,136.45 121.96,136.53 121.58,136.91 70.1,136.91 68.66,135.47 68.66,133.71 66.83,131.88 64.54,131.88 64.14,132.28 v1(64.14,132.29) ; 128.2,148.27 127.5,148.97 v1(126.57,148.97) ; 128.2,148.27 v5(128.02,148.08)
PWR_VDDCD_ISEN_N_A: length 4.6
  TOP w0.203: PU39.31 118.97,148.94
  TOP w0.254: R2767.1 121.18,150.44 PR414.1 120.67,150.01 v3(119.76,149.1) 119.6,148.94 118.97,148.94
PWR_VDDCD_ISEN_P: length 88
  TOP w0.254: v1(64.14,131.14) 64.14,131.14 63.92,131.35 63.23,131.35 62.81,130.94 PG163.1 ; v1(126.62,149.99) 126.58,150.02 PR250.2
  BOTTOM w0.254: v1(64.14,131.14) 64.37,131.37 67.04,131.37 69.16,133.5 69.16,135.25 70.31,136.4 113.74,136.4 ; 113.74,136.4 121.37,136.4 121.83,135.94 125.37,135.94 127.18,137.75 127.18,139.8 129.06,141.68 129.06,148.13 127.71,149.48 127.03,149.48 126.62,149.89 v1(126.62,149.99) ; 113.74,136.4 v2(113.74,136.04)
PWR_VDDCD_ISEN_P_A: length 8.7
  TOP w0.203: PU39.32 119.1,149.34
  TOP w0.254: 119.1,149.34 121.63,151.87 121.67,151.87 v3(121.69,151.89) 121.98,152.18 PR413.1 123.07,151.73 123.02,151.69 PC284.2 123.95,151.09 PR250.1
PWR_VDDCD_PH: length 9.2
  TOP w0.305: v1(59.31,116.2) 59.31,117.35 59.7,117.74 PU41.7 ; PU41.15 63.12,116.35 v6(63.43,116.66)
  L3 w0.508: v6(63.43,116.66) 62.88,116.1 59.41,116.1 v1(59.31,116.2)
  BOTTOM w0.508: v1(59.31,116.2) 59.31,116.59 59.67,116.95 PR276.2
  vias: v2(60.2,129.54) v2(62.74,126.62) v2(64.77,129.54) v4(59.44,127.69) v4(59.41,126.72) v4(60.3,128.17) v4(60.33,126.19) v4(60.35,127.15) v4(65.33,128.07) v4(65.35,127.05) v4(65.35,125.93) v4(66.34,128.27) v4(66.37,127.25) v4(66.37,126.14) v6(63.5,120.27) v6(63.49,119.38) v6(63.49,118.49) v6(63.46,117.55) v6(64.31,120.27) v6(64.3,119.38) v6(64.3,118.49) v6(64.3,117.63) v6(64.27,116.64) v6(65.05,120.27) v6(65.03,118.49) v6(65.09,119.35) v6(65.06,117.65) v6(65.11,116.59)
PWR_VDDCD_PWM: length 75.1
  TOP w0.203: 110.36,150.18 110.8,149.74 PU39.4
  TOP w0.254: PR280.2 58.5,124.51 v1(58.45,124.56) ; 110.36,150.18 110.15,150.39 v3(109.63,150.39) 108.52,150.39 107.68,151.23 107.57,151.23 v1(107.37,151.43)
  L3 w0.254: v1(58.45,124.56) 58.57,124.69 67.84,124.69 68.07,124.92 68.07,135.98 68.96,136.87 68.96,136.88 70.76,138.68 94.67,138.68 96.93,140.94 96.93,144.48 99.36,146.91 101.59,146.91 102.64,147.97 102.64,148.78 104,150.14 105.46,150.14 106.76,151.43 v1(107.37,151.43)
PWR_VDDCD_PWM_A: length 3.3
  TOP w0.254: PU41.40 61.12,122.52 v3(60.42,123.23) 60.02,123.62 PR280.1
PWR_VDDCD_SMOD#: length 3.5
  TOP w0.254: v3(58.17,122.73) 58.29,122.61 58.29,121.73 PR274.1 58.54,121.72 59.52,120.74 PU41.1
PWR_VDDCD_SNB: length 2.6
  TOP w0.508: PR272.2 68.1,124.46 68.71,124.46 v3(68.78,124.38) PC312.1
PWR_VDDCD_THWN#: length 3.8
  TOP w0.254: PU41.38 62.12,122.04 62.13,122.05 62.13,122.83 v1(62.23,122.94)
  BOTTOM w0.254: v1(62.23,122.94) 62.36,122.81 v2(63.08,122.81) 63.6,123.33 PR282.1
PWR_VDDCE_BOOT: length 4.3
  TOP w0.305: v3(47.75,118.11) 48.13,118.49 48.13,118.72 48.65,119.24 PU43.4
  TOP w0.508: v3(47.75,118.11) 47.4,118.47 v1(47.4,118.9)
  BOTTOM w0.508: PC329.1 47.74,118.44 47.4,118.78 v1(47.4,118.9)
PWR_VDDCE_BOOT_A: length 2.8
  BOTTOM w0.508: v2(50.29,119.76) 49.98,119.45 PC329.2 49.98,117.26 PR289.1
PWR_VDDCE_EN_A: length 5.1
  TOP w0.254: v1(49.22,123.32) 49.35,123.32 50.5,122.17 PU43.39
  BOTTOM w0.254: PR291.1 50.91,121.81 v2(49.91,122.81) 49.91,122.81 49.4,123.32 v1(49.22,123.32)
PWR_VDDCE_ISEN_N: length 95.2
  TOP w0.254: v1(53.58,132.22) 53.31,131.95 52.06,131.95 51.66,132.35 PG174.1 ; R2768.2 124.03,146.05 PC282.2 125.03,145.61 125.32,145.31 PC283.1 125.91,145.31 126.42,145.82 126.42,145.85 v1(126.47,145.9)
  BOTTOM w0.254: v1(53.58,132.22) 53.85,131.96 55.78,131.96 56.49,132.67 56.49,137.36 57.3,138.18 105.05,138.18 105.82,138.94 107.98,138.94 108.41,138.51 121.77,138.51 122.49,137.79 124.71,137.79 125.32,138.41 125.32,140.82 126.75,142.25 126.75,142.88 ; v1(126.47,145.9) 126.79,145.9 127.1,145.59 127.1,143.7 126.75,143.34 126.75,142.88 ; 126.75,142.88 v5(126.36,142.88)
PWR_VDDCE_ISEN_N_A: length 6.3
  TOP w0.203: PU39.29 120.21,148.14
  TOP w0.254: 120.21,148.14 120.22,148.14 120.7,147.66 120.7,147.65 121.54,146.81 122.15,146.81 PR416.1 122.81,146.6 123.14,146.93 R2768.1
PWR_VDDCE_ISEN_P: length 94.7
  TOP w0.254: PG173.1 51.66,131.04 52.06,131.44 53.21,131.44 v1(53.58,131.07) ; v1(126.52,146.89) 126.52,146.76 126.1,146.34 PR248.2
  BOTTOM w0.254: 118.54,138 121.56,138 122.28,137.29 124.92,137.29 125.83,138.2 125.83,140.61 127.25,142.04 127.25,143.13 127.61,143.48 127.61,145.8 v1(126.52,146.89) ; 118.54,138 v2(118.54,137.59) ; 118.54,138 108.2,138 107.76,138.43 106.03,138.43 105.26,137.67 57.51,137.67 57,137.15 57,132.46 55.99,131.45 53.96,131.45 v1(53.58,131.07)
PWR_VDDCE_ISEN_P_A: length 8.5
  TOP w0.203: PU39.30 119.46,148.54 119.51,148.49 120.01,148.49 120.06,148.54 120.32,148.54
  TOP w0.254: PR248.1 125.5,147.13 PC282.1 124,147.6 PR415.1 121.64,147.6 v3(121.33,147.91) 120.7,148.54 120.32,148.54
PWR_VDDCE_PH: length 9.2
  TOP w0.305: v1(48.18,116.2) 48.18,117.42 48.5,117.74 PU43.7 ; v6(52.31,116.66) 52,116.35 PU43.15
  L3 w0.508: v6(52.31,116.66) 51.75,116.1 48.29,116.1 v1(48.18,116.2)
  BOTTOM w0.508: PR289.2 48.54,116.59 48.18,116.23 v1(48.18,116.2)
  vias: v2(48.9,129.41) v2(51.44,126.62) v2(53.09,129.16) v4(48.31,127.69) v4(48.29,126.72) v4(48.77,125.22) v4(49.17,128.17) v4(49.23,127.15) v4(49.2,126.19) v4(49.94,124.66) v4(51.13,124.66) v4(52.25,124.66) v4(54.2,128.07) v4(54.23,127.05) v4(54.23,125.93) v6(52.33,117.55) v6(52.37,120.27) v6(52.36,119.38) v6(52.36,118.49) v6(53.15,116.64) v6(53.19,120.27) v6(53.17,119.38) v6(53.17,118.49) v6(53.17,117.63) v6(53.92,120.27) v6(53.91,118.49) v6(53.93,117.65) v6(53.96,119.35) v6(53.99,116.59)
PWR_VDDCE_PWM: length 88.3
  TOP w0.203: PU39.5 110.5,149.34 110.17,149.67
  TOP w0.254: 110.17,149.67 110.08,149.76 109.36,149.76 109.19,149.94 107.85,149.94 v1(107.44,150.34) ; v1(46.1,124.46) 46.82,124.46 PR293.2
  L3 w0.254: v1(46.1,124.46) 46.35,124.21 49.48,124.21 49.73,123.95 57.8,123.95 58.08,123.67 58.81,123.67 58.94,123.8 67.48,123.8 68.21,123.8 68.96,124.55 68.96,135.61 71.15,137.79 95.05,137.79 97.82,140.56 97.82,144.09 99.72,146 101.93,146 103.53,147.6 103.53,148.41 104.37,149.25 105.83,149.25 106.92,150.34 v1(107.44,150.34)
  BOTTOM w0.254: v2(108.08,149.68) 108.08,149.78 107.52,150.34 v1(107.44,150.34)
PWR_VDDCE_PWM_A: length 4
  TOP w0.254: PU43.40 50,122.04 49.46,122.58 49.02,122.58 v3(48.27,123.32) 47.81,123.78 PR293.1
PWR_VDDCE_SMOD#: length 3.2
  TOP w0.254: v3(47.17,122.5) 47.17,122.45 47.26,122.36 47.26,121.65 PR287.1 48.08,121.52 48.85,120.74 PU43.1
PWR_VDDCE_SNB: length 2.5
  TOP w0.508: PR286.2 55.91,124.1 56.79,124.1 v3(56.9,124) 56.95,123.95 PC331.1
PWR_VDDCE_THWN#: length 3.7
  TOP w0.254: PU43.38 51,122.79 v1(50.9,122.88)
  BOTTOM w0.254: v1(50.9,122.88) 51.3,122.49 v2(51.62,122.49) 51.75,122.49 52.14,122.88 PR296.1
PWR_VDDCF_BOOT: length 4.8
  TOP w0.305: PU45.4 36.21,119.24 v1(36.07,119.38)
  BOTTOM w0.508: PC360.1 37.03,118.24 v2(35.88,118.24) 35.88,118.94 36.07,119.13 v1(36.07,119.38)
PWR_VDDCF_BOOT_A: length 2.8
  BOTTOM w0.508: v2(38.61,119.81) 38.61,118.58 PC360.2 38.97,118.22 PR304.1
PWR_VDDCF_EN_A: length 4.9
  TOP w0.254: v1(38.04,123.39) 38.06,123.37 38.2,123.37 39.4,122.17 PU45.39
  BOTTOM w0.254: PR306.1 v2(38.04,122.58) v1(38.04,123.39)
PWR_VDDCF_ISEN_N: length 98.1
  TOP w0.254: PG184.1 40.64,132.2 40.94,131.9 42.06,131.9 v1(42.38,132.22) ; PC281.1 124.47,141.06 v1(124.51,141.1) 124.72,141.3 R2769.2 124.72,142.24 125.34,142.86 PC280.1
  BOTTOM w0.254: 113.64,142.16 v5(113.64,142.52) ; 113.64,142.16 109.56,142.16 108.32,140.92 105.63,140.92 104.16,139.45 46.58,139.45 45.64,138.51 45.64,132.98 44.57,131.9 42.7,131.9 v1(42.38,132.22) ; 113.64,142.16 118.04,142.16 119.18,141.02 124.43,141.02 v1(124.51,141.1)
PWR_VDDCF_ISEN_N_A: length 8.9
  TOP w0.203: PU39.27 118.85,147.34
  TOP w0.254: R2769.1 123.41,142.43 123.33,142.43 122.76,143 PR418.1 121.54,144.17 121.54,144.95 121.03,145.46 121.03,145.88 120.66,146.25 120.27,146.64 119.93,146.64 119.22,147.34 118.85,147.34
PWR_VDDCF_ISEN_P: length 96.4
  TOP w0.254: v1(124.46,140.18) 125.36,141.09 PR244.2 ; v1(42.38,131.07) 42.06,131.39 40.89,131.39 40.64,131.14 PG183.1
  BOTTOM w0.254: 115.98,141.65 117.83,141.65 118.97,140.51 124.13,140.51 v1(124.46,140.18) ; 115.98,141.65 109.77,141.65 108.53,140.41 105.84,140.41 104.37,138.94 46.79,138.94 46.15,138.3 46.15,132.77 44.78,131.39 42.7,131.39 v1(42.38,131.07) ; 115.98,141.65 v5(115.98,141.35)
PWR_VDDCF_ISEN_P_A: length 13
  TOP w0.203: PU39.28 119.76,147.74
  TOP w0.254: 119.76,147.74 120.02,147.49 v3(120.02,147.45) 120.14,147.45 121.67,145.92 121.67,145.54 122.25,144.95 PR417.1 122.25,144.57 122.94,143.89 123.04,143.89 PC280.2 124.55,143.85 125.89,143.85 126.24,143.51 126.24,142.49 125.78,142.04 PR244.1
PWR_VDDCF_PH: length 9.4
  TOP w0.305: PU45.15 40.9,116.35 v6(41.21,116.66) ; PU45.7 37.32,117.74 36.98,117.4 36.98,116.31 v1(37.08,116.2)
  L3 w0.508: v1(37.08,116.2) 37.19,116.1 40.65,116.1 v6(41.21,116.66)
  BOTTOM w0.508: PR304.2 37.44,116.59 37.08,116.23 v1(37.08,116.2)
  vias: v2(39.12,129.16) v2(40.13,126.36) v2(42.67,124.46) v4(37.21,127.69) v4(37.19,126.72) v4(38.07,128.17) v4(38.13,127.15) v4(38.1,126.19) v4(38.1,124.97) v4(38.84,124.16) v4(40.01,124.18) v4(41.07,124.18) v4(43.1,128.07) v4(43.13,127.05) v4(43.13,125.93) v6(41.23,117.55) v6(41.27,120.27) v6(41.26,119.38) v6(41.26,118.49) v6(42.05,116.64) v6(42.09,120.27) v6(42.07,119.38) v6(42.07,118.49) v6(42.07,117.63) v6(42.82,120.27) v6(42.81,118.49) v6(42.84,117.65) v6(42.86,119.35) v6(42.89,116.59)
PWR_VDDCF_PWM: length 100.2
  TOP w0.203: v1(107.49,148.64) 107.64,148.79 107.64,148.84 108.25,149.45 109.17,149.45 109.22,149.4 109.52,149.4 109.99,148.94 PU39.6
  TOP w0.254: PR308.2 36.28,124.51 v1(36.22,124.56)
  L3 w0.254: v1(36.22,124.56) 36.22,123.65 37.03,122.83 38.71,122.83 39.29,123.42 45.76,123.42 46.52,122.66 47.26,122.66 47.28,122.68 49.91,122.68 50.37,122.22 51,122.22 51.84,123.06 57.28,123.06 57.7,122.64 60.06,122.64 60.38,122.33 62.46,122.33 62.87,122.73 68.4,122.73 70.38,124.71 70.38,135.76 71.53,136.91 95.44,136.91 98.72,140.19 98.72,143.72 100.06,145.06 103.61,145.06 107.19,148.64 v1(107.49,148.64)
  BOTTOM w0.254: v1(107.49,148.64) 107.67,148.64 107.87,148.44 v2(107.87,147.8)
PWR_VDDCF_PWM_A: length 4.1
  TOP w0.254: PU45.40 38.9,121.76 PR308.1 v3(35.84,123.62)
PWR_VDDCF_SMOD#: length 3.3
  TOP w0.254: PR302.1 35.86,122.41 v3(36.65,121.62) 37.53,120.74 PU45.1
PWR_VDDCF_SNB: length 2.6
  TOP w0.508: PR300.2 45.56,123.83 45.87,123.52 v3(45.87,123.52) 45.87,123.51 46.18,123.21 PC362.1
PWR_VDDCF_THWN#: length 3.5
  TOP w0.254: PU45.38 v1(39.9,122.81)
  BOTTOM w0.254: PR310.1 40.08,121.84 v2(40.01,121.92) 39.9,122.03 v1(39.9,122.81)
PWR_VDDCI_BOOT: length 5
  TOP w0.305: PU46.4 138.24,218.83 138.2,218.8 138.2,217.93 138.4,217.73
  TOP w0.508: 138.4,217.73 v1(138.73,217.4)
  BOTTOM w0.508: v1(138.73,217.4) 138.58,217.25 v5(138.58,216.48) 137.34,216.48 PC367.1
PWR_VDDCI_BOOT_A: length 3.1
  BOTTOM w0.508: PC367.2 138.25,215.21 v5(138.58,214.88) 139.27,214.88 139.41,215.02 PR314.1
PWR_VDDCI_EN: length 407
  TOP w0.203: PU39.14 113,145.21 112.77,144.98 112.74,144.98
  TOP w0.254: v1(109.19,143.64) 109.22,143.61 109.93,143.61 111.3,144.98 112.74,144.98 ; v1(7.11,205.74) 7.11,205.23 v3(7.57,204.77) 7.92,204.77 8.18,205.03 PR404.1 ; v1(133.22,217.68) 133.43,217.88 PG229.1
  L3 w0.254: v1(133.22,217.68) 133.15,217.6 124.22,217.6 123.15,216.53 120.41,216.53 120.38,216.51 116.23,216.51 111.2,221.54 104.98,221.54 99.77,226.75 97.92,226.75 95.18,229.48 43.23,229.48 38.82,225.08 26.11,225.08 25.61,225.57 17.43,225.57 17.22,225.78 16.61,225.78 14.61,223.77 12.97,223.77 7.84,218.64 7.84,217.03 5.59,214.78 5.59,208.28 7.24,206.63 7.24,205.87 v1(7.11,205.74) 11.81,201.04 14.1,201.04 17.86,197.28 17.86,169.75 12.87,164.76 12.87,146.29 14.38,144.78 15.19,144.78 15.7,144.27 15.7,143.26 14.36,141.93 14.36,139.87 14.86,139.37 14.86,136.12 12.98,134.24 12.98,132.97 8.19,128.18 8.19,119.08 12.89,114.39 23.51,114.39 26.76,111.14 79.85,111.14 83.74,107.25 83.74,107.25 v1(85.93,105.05)
  L6 w0.254: v1(85.93,105.05) 88.11,105.05 89.64,106.58 90.16,106.58 106.54,106.58 109.09,109.13 109.09,124.61 113.21,128.73 113.21,131.7 107.98,136.93 107.98,140.12 108,140.14 108,140.76 107.54,141.22 107.54,141.88 109.19,143.54 v1(109.19,143.64)
PWR_VDDCI_EN_A: length 4.1
  TOP w0.254: PU46.39 135.26,220.86 v1(134.87,220.47)
  BOTTOM w0.254: PR315.1 136.78,219.84 v5(135.89,220.73) 135.13,220.73 v1(134.87,220.47)
PWR_VDDCI_ISEN_N: length 97.8
  TOP w0.203: PU39.25 117.8,145.8
  TOP w0.254: 117.8,145.8 118.24,145.36 118.8,145.36 v1(118.85,145.41) 119.38,144.88 119.38,144.45 120.9,142.93 120.9,142.14 PC279.1 121.79,141.25 121.79,140.26 PC277.1 ; PG189.1 125.55,223.19 125.83,222.91 125.83,219.58 v1(125.58,219.33)
  L6 w0.254: v1(118.85,145.41) 117.81,146.46 117.81,149.05 119.08,150.32 119.08,164.84 117.04,166.87 117.04,168.57 116.59,169.03 116.59,181.77 117.68,182.86 117.68,185.47 123.19,190.98 123.19,192.19 122.1,193.29 122.1,212.6 121.64,213.06 121.64,216.21 122.98,217.55 124.61,217.55 125.76,218.71 125.76,219.14 v1(125.58,219.33)
  BOTTOM w0.254: v1(118.85,145.41) 119.25,145.82 v5(119.75,145.82)
PWR_VDDCI_ISEN_P: length 90.7
  TOP w0.254: PG188.1 126.75,223.29 126.34,222.88 126.34,219.76 v1(126.72,219.38) ; v1(118.85,146.33) 118.85,146.2 120.05,145 PR242.2
  L6 w0.254: v1(126.72,219.38) 126.27,218.93 126.27,218.5 124.82,217.04 123.19,217.04 122.15,216 122.15,213.27 122.61,212.81 122.61,193.5 123.7,192.41 123.7,190.77 118.19,185.26 118.19,182.65 117.09,181.56 117.09,169.24 117.55,168.78 117.55,167.09 119.58,165.05 119.58,150.11 118.31,148.84 118.31,146.86 v1(118.85,146.33)
  BOTTOM w0.254: v5(118.85,147.32) v1(118.85,146.33)
PWR_VDDCI_ISEN_P_A: length 6.3
  TOP w0.203: PU39.26 119.06,146.94
  TOP w0.254: 119.06,146.94 v3(120.33,145.67) 120.33,145.26 PR242.1 120.9,144.61 120.9,143.66 PC279.2
PWR_VDDCI_PG: length 3.1
  TOP w0.203: PU39.17 114.2,144.5 113.92,144.22 v3(113.92,144.12)
  TOP w0.254: PR236.1 113.18,143.38 v3(113.92,144.12)
PWR_VDDCI_PG_A: length 2.8
  TOP w0.254: PR406.2 112.93,140.8 TP123.1 113.18,141.04 PR236.2
PWR_VDDCI_PH: length 9.1
  TOP w0.305: PU46.7 139.74,218.83 140.03,218.54 v4(140.03,218.31) ; PU46.15 141.22,222.36 v6(140.94,222.63)
  BOTTOM w0.508: PR314.2 139.98,218.26 v4(140.03,218.31)
  BOTTOM w0.635: v4(140.03,218.31) 140.94,219.23 v6(140.94,222.63)
  vias: v4(129.92,227.33) v4(129.9,226.14) v4(130.15,220.52) v4(130.81,219.46) v4(130.94,227.33) v4(130.96,226.14) v4(131.27,220.52) v4(131.93,227.36) v4(132.03,226.14) v4(132.08,219.46) v4(132.33,220.52) v4(133.53,223.72) v4(133.48,222.2) v4(134.59,223.72) v4(135.76,225.68) v5(130.56,223.14) v5(133.99,226.95) v5(136.4,222.76) v6(137.26,224.41) v6(137.34,223.49) v6(137.31,222.66) v6(138.23,224.41) v6(138.28,223.49) v6(138.28,222.66) v6(139.19,224.36) v6(139.24,223.47) v6(139.24,222.66) v6(140.11,224.36) v6(140.08,223.47) v6(140.06,222.68) v6(140.87,224.36) v6(140.92,223.49)
PWR_VDDCI_PWM: length 101.2
  TOP w0.203: PU39.7 110.7,148.54 109.91,148.54 109.7,148.34 v4(109.7,148.29)
  TOP w0.254: v1(135,214.5) 135.17,214.68 PR316.2
  L3 w0.254: v1(135,214.5) 132.79,216.71 124.59,216.71 123.52,215.65 v1(120.78,215.65)
  L6 w0.254: v1(120.78,215.65) 120.52,215.39 120.52,212.92 121.21,212.23 121.21,208.53 119.76,207.09 119.76,205.61 121.21,204.17 121.21,193.8 120.45,193.04 120.45,191.21 115.65,186.41 115.65,186.39 115.14,185.88 115.14,183.97 113.79,182.63 113.79,169.42 110.87,166.5 106.43,166.5 103.66,163.73 103.66,158.04 109.25,152.45 109.25,148.51 109.47,148.29 v4(109.7,148.29)
  BOTTOM w0.254: v4(109.7,148.29) 109.47,148.06 v2(109.47,147.4)
PWR_VDDCI_PWM_A: length 6.6
  TOP w0.254: PU46.40 135.57,220.36 134.98,219.76 134.98,217.53 133.99,216.53 133.99,216.34 v3(133.93,216.28) 134.18,216.03 134.52,216.03 134.76,216.27 PR316.1
PWR_VDDCI_SMOD#: length 3.8
  TOP w0.254: PR313.1 136.24,216.69 135.86,217.07 v3(135.86,217.73) 135.86,218.31 136.74,219.19 PU46.1
PWR_VDDCI_SNB: length 2.4
  TOP w0.508: PC371.1 133.76,228.3 v3(133.73,228.27) 133.73,227.15 PR312.2
PWR_VDDCI_TEMP: length 6.8
  TOP w0.203: 112.78,152.65 112.83,152.6 113.51,152.6 113.8,152.32 PU39.45
  TOP w0.254: 112.78,152.65 112.27,153.16 v1(112.27,153.49)
  BOTTOM w0.254: PR267.2 111.89,154 112.27,153.62 v1(112.27,153.49) 112.22,153.49 111.61,152.88 v2(111.61,152.78) 111.57,152.74 PC300.1
PWR_VDDCI_TEMP_A: length 80.4
  TOP w0.254: v1(128.5,215.8) 128.73,216.03 129.88,216.03 PQ10.C 130.14,216.03 131.5,216.03 131.91,215.61 PQ10.B
  L3 w0.254: v1(128.5,215.8) 128.02,215.32 128.02,213.87 129.16,212.72 132.6,212.72 133.35,211.97 133.35,208.76 130.94,206.34 130.94,204.85 130.1,204.01 130.1,203.01 128.2,201.12 127.08,201.12 126.7,200.73 126.7,200.25 127.38,199.57 127.38,196.43 126.85,195.9 126.85,195 123.29,191.44 123.29,190.5 113,180.21 113,169.06 111.99,168.04 111.99,159.08 v1(112.01,159.05)
  BOTTOM w0.254: PR267.1 112.1,155.8 PC301.1 111.58,156.79 111.15,157.23 v5(111.15,157.63) 111.15,158.27 111.79,158.9 111.86,158.9 v1(112.01,159.05)
PWR_VDDCI_TEMP_B: length 81
  TOP w0.254: v1(127.51,215.77) 127.58,215.77 128.35,216.53 131.57,216.53 PQ10.E
  L3 w0.254: v1(127.51,215.77) 127.51,213.66 128.95,212.22 132.38,212.22 132.84,211.76 132.84,208.97 130.43,206.55 130.43,205.06 129.59,204.22 129.59,203.22 127.99,201.63 126.87,201.63 126.19,200.94 126.19,200.04 126.87,199.36 126.87,196.64 126.34,196.11 126.34,195.21 122.78,191.65 122.78,191.23 122.78,190.71 112.5,180.42 112.5,169.27 111.48,168.25 111.48,159.31 111.43,159.26 111.43,158.7 v1(112.01,158.12)
  BOTTOM w0.254: v5(113,158.01) 112.9,158.12 v1(112.01,158.12) 112.01,157.84 112.88,156.98 112.88,156.91 PC301.2 112.98,156.78 112.98,155.74 PR268.1
PWR_VDDCI_THWN: length 3.3
  TOP w0.254: PG229.2 134.04,217.88 v1(134.11,217.81)
  BOTTOM w0.254: v1(134.11,217.81) 134.11,218.57 v5(134.24,218.69) 134.7,218.69 134.89,218.5 PR317.2
PWR_VDDCI_THWN#: length 5.8
  TOP w0.254: PU46.38 134.94,221.36 134.06,220.47 v1(133.73,220.47)
  BOTTOM w0.254: v1(133.73,220.47) 133.35,220.09 v5(133.35,219.71) 133.67,219.39 PR317.1
PWR_VDDNB_COMP: length 7.5
  TOP w0.254: v1(215.62,225.04) 214.96,224.38 PR74.1
  BOTTOM w0.203: v1(215.62,225.04) 214.7,224.13 PU6.43
  BOTTOM w0.254: v1(215.62,225.04) 215.62,225.04 215.99,225.41 PC117.1 215.99,226.77 PC115.1 215.42,227.34 215.05,227.34 v2(214.68,227.71)
PWR_VDDNB_FB: length 10
  BOTTOM w0.203: PU6.44 215.1,223.92 215.59,224.41 215.72,224.41 216.51,225.2
  BOTTOM w0.508: PR68.2 216.8,230.35 PR73.1 216.52,229.72 PR70.2 216.57,228.98 v2(216.57,228.04) 216.85,227.76 PR69.2 216.88,227.1 PC117.2 216.88,225.56 216.51,225.2
PWR_VDDNB_FB_A: length 2.4
  BOTTOM w0.508: v2(218.95,229.9) 218.67,230.17 PR73.2 217.87,229.39 PC116.1
PWR_VDDNB_FB_B: length 3.4
  BOTTOM w0.508: PR68.1 214.92,230.67 v2(214.27,231.32) 213.65,230.7 PC114.2
PWR_VDDNB_FB_C: length 2.1
  BOTTOM w0.508: v2(214.6,229.06) PR70.1 215.63,228.04 PC115.2
PWR_VDDNB_FCCM: length 36.5
  TOP w0.254: v1(212.72,202.62) 212.95,202.39 PU21.7 ; PR81.1 213.94,224.87 214.17,225.09 v1(214.17,225.11)
  L3 w0.254: v1(212.72,202.62) 213.64,201.7 216.43,201.7 218.85,204.11 218.85,211.61 219.2,211.96 219.2,217.47 217.88,218.8 217.88,221.06 215.57,223.37 215.57,223.38 215.26,223.68 215.26,224.21 214.36,225.11 v1(214.17,225.11)
  BOTTOM w0.203: v1(214.17,225.11) 214.17,225.09 214.05,224.97 214.05,223.8 213.9,223.66 PU6.41
  BOTTOM w0.254: v5(212.22,201.85) 212.22,202.11 v1(212.72,202.62)
PWR_VDDNB_IMON: length 6.1
  TOP w0.254: PC126.1 217.69,220 217.93,219.76 v3(218.19,219.76) 218.53,219.76 218.85,220.08 v1(218.85,221.21) 218.34,221.72 PR89.1
  BOTTOM w0.203: v1(218.85,221.21) 218.65,221.01 PU6.3
PWR_VDDNB_ISEN1: length 12.9
  BOTTOM w0.203: 217.6,222.99 217.22,222.61 PU6.48
  BOTTOM w0.254: PR159.1 224.03,223.67 224.36,224 224.36,225.32 222.63,227.05 PC123.1 220.77,225.66 220.77,224.59 PR153.1 220.48,224.31 219.74,224.31 v2(219.46,224.03) 218.64,224.03 217.6,222.99
PWR_VDDNB_ISEN2: length 13.7
  TOP w0.254: PR150.1 220.71,223.85 PC124.1 219.84,224.46 v3(219.43,224.05) 218.11,222.73 218.11,222.71 v1(218.08,222.68) ; PR84.1 223.35,224.42 v1(223.57,224.21) 223.57,224.16 223.27,223.85 PR162.1
  L3 w0.254: v1(223.57,224.21) 223.52,224.21 223.49,224.23 219.63,224.23 v1(218.08,222.68)
  BOTTOM w0.203: PU6.1 217.5,222.1 v1(218.08,222.68)
PWR_VDDNB_ISUMN: length 7.6
  BOTTOM w0.203: 216.48,223.85 215.9,223.27 PU6.46
  BOTTOM w0.254: 216.48,223.85 216.64,223.85 217.15,224.36 218.14,224.36 v2(218.16,224.38) 218.57,224.79 219.59,224.79 220.15,225.36 PC121.1 220.15,226.21 PR79.2
PWR_VDDNB_ISUMN_A: length 2.4
  BOTTOM w0.254: PC121.2 219.27,226.45 v2(219.23,226.49) 218.81,226.91 PR80.1
PWR_VDDNB_NTC: length 47.6
  TOP w0.254: v1(226.52,218.57) 226.12,218.17 226.12,214.28 225.32,213.49 224.16,213.49 221.26,210.59 219.44,210.59 218.13,209.28 216.33,209.28 215.51,208.46 v1(215.49,208.46) ; PR88.2 208.14,197.44 208.53,197.84 208.53,198.37 v1(208.33,198.58) ; v1(220.6,221.34) 220.65,221.28 PR82.1
  L3 w0.254: v1(215.49,208.46) 214.63,208.46 213.85,207.67 213.46,207.67 212.45,206.65 212.45,206.18 211.56,205.29 211.56,201.88 210.01,200.33 210.01,198.38 209.27,197.63 208.82,197.63 208.36,198.1 208.36,198.58 v1(208.33,198.58)
  BOTTOM w0.203: PU6.2 218.23,221.41 218.95,222.12 v2(219.2,222.12)
  BOTTOM w0.254: v1(226.52,218.57) 226.52,218.86 226.05,219.33 225.14,219.33 222.68,221.79 221.06,221.79 v1(220.6,221.34) 220.45,221.49 219.84,221.49 v2(219.2,222.12)
PWR_VDDNB_NTC_A: length 40.7
  TOP w0.254: PR82.2 223.01,221.28 223.33,220.97 PR95.1 225.44,220.97 225.96,220.45 v3(225.96,219.51) 225.96,219.19 225.61,218.84 225.61,214.49 225.11,214 223.94,214 221.05,211.1 219.23,211.1 217.92,209.78 216.03,209.78 214.76,208.51 v1(214.76,207.77) ; PR88.1 207.25,197.5 207.68,197.93 v1(207.68,197.93)
  L3 w0.254: v1(207.68,197.93) 207.81,197.93 208.61,197.13 209.48,197.13 210.52,198.17 210.52,200.12 212.06,201.67 212.06,205.08 212.95,205.97 212.95,206.35 213.21,206.6 213.61,206.6 214.76,207.75 v1(214.76,207.77)
PWR_VDDNB_VSEN: length 9.3
  TOP w0.254: PR72.2 216.66,223.69 PC119.1 216.04,223.66 v1(215.8,223.9)
  BOTTOM w0.203: PU6.45 215.5,223.61 v1(215.8,223.9)
  BOTTOM w0.254: v1(215.8,223.9) 216.13,224.23 216.46,224.23 216.98,224.75 217.59,224.75 217.98,225.15 v2(217.98,225.7) 217.98,226.89 PR69.1 217.74,228.04 PC116.2
PWR_VDDNB_VSUM_A: length 76.9
  TOP w0.254: v1(220.34,228.85) 221.26,227.94 PR75.2 ; PR77.2 206.4,168.67 206.15,168.92 206.15,176.49 204.88,177.76 204.88,181.71 ; 204.88,181.71 204.88,183.95 204.6,184.23 v1(204.6,184.78) ; 204.88,181.71 v3(205.23,181.71)
  L3 w0.254: v1(204.6,184.78) 204.11,184.78 201.14,187.76 201.14,190.12 206.5,195.48 206.5,197.82 209.09,200.41 209.09,213.28 209.14,213.33 209.14,214.06 v1(209.41,214.33)
  L4 w0.254: v1(220.34,228.85) 220.12,228.63 220.12,227.35 216.92,224.15 216.92,222.1 217.88,221.13 217.88,218.21 216.31,216.64 212.32,216.64 210.08,214.4 209.49,214.4 v1(209.41,214.33)
PWR_VDDNB_VSUMN: length 97.3
  TOP w0.254: PR151.1 221.87,223.76 221.87,223.77 221.6,224.04 PC124.2 221.48,224.59 221.48,224.59 220.64,225.43 PC122.1 PR76.2 219.99,226.48 PC118.2 219.99,228.09 v1(219.38,228.7) 218.19,227.51 PC120.2 ; PR77.1 207.12,168.15 206.16,168.15 205.64,168.67 205.64,176.28 204.37,177.55 204.37,183.74 v1(203.52,184.59)
  L3 w0.254: v1(208.56,214) 208.58,213.97 208.58,200.62 205.99,198.03 205.99,195.69 200.63,190.33 200.63,187.55 203.52,184.66 v1(203.52,184.59)
  L4 w0.254: v1(208.56,214) 208.56,214.53 208.97,214.93 209.9,214.93 212.11,217.14 212.53,217.14 212.53,217.14 216.1,217.14 217.37,218.42 217.37,220.92 216.41,221.89 216.41,224.36 219.61,227.56 219.61,228.47 v1(219.38,228.7)
  BOTTOM w0.254: PR160.1 225.16,223.37 225.16,225.62 222.83,227.94 PC123.2 222.17,228.56 221.31,229.41 v2(221.23,229.41) 220.09,229.41 v1(219.38,228.7) 219.7,228.38 PR80.2 219.81,227.77 PR79.1
PWR_VDDNB_VSUMP: length 21
  TOP w0.254: PR75.1 221.74,227.01 221.75,227 222.73,227 223.32,226.42 223.32,225.83 223.34,225.81 223.34,225.4 v1(223.6,225.15) 223.9,225.15 PR161.1 ; v1(217.47,223.82) 217.5,223.82 217.88,224.21 v3(217.88,225.17) 217.88,226.44 PC120.1 218.49,226.62 218.64,226.47 PR76.1 219.1,226.48 PC118.1
  L3 w0.254: v1(223.6,225.15) 223.39,225.35 219,225.35 v1(217.47,223.82)
  BOTTOM w0.203: v1(217.47,223.82) 217.35,223.82 216.97,223.44 216.59,223.44 216.3,223.16 PU6.47
  BOTTOM w0.254: PR152.1 223.19,224.74 v1(223.6,225.15)
