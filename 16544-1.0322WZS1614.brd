# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUO_3V_POP1: length 4.8
  TOP w0.254: U41.5 206.12,58.9 205.95,58.73 204.87,58.73 v3(203.96,59.64) 203.68,59.92 L30.1
AUO_3V_POP2: length 9.3
  TOP w0.254: L31.1 215.54,60.11 v1(215.46,60.2) ; v1(211.2,61.09) 211.2,60.07 210.54,59.41 U42.5
  L6 w0.254: v1(211.2,61.09) 212.34,59.94 215.26,59.94 215.46,60.13 v1(215.46,60.2)
  BOTTOM w0.254: v2(211.2,61.98) v1(211.2,61.09)
AUO_AGPO_1: length 7
  TOP w0.114: v1(199.94,47.05) 199.97,47.02 199.97,46.84 200.28,46.54 U6.39
  BOTTOM w0.114: Q68.G 199.18,51.05 198.84,50.72 v2(198.84,50.24) 199.02,50.06 R2630.1 199.02,48.55 199.94,47.63 v1(199.94,47.05)
AUO_AGPO_1_R: length 4.5
  BOTTOM w0.114: D14.2 197.19,56.27 196.47,55.55 v2(196.47,55.14) 196.47,55.04 197.78,53.73 Q68.D
AUO_BEEP_C: length 4.3
  TOP w0.114: v1(206.65,42.94) 206.48,42.77 205.69,42.77 205.68,42.76 U6.23
  BOTTOM w0.114: v1(206.65,42.94) 206.65,43.23 206.45,43.43 v5(206.45,44.04) 206.45,44.08 C321.1
AUO_BEEP_R: length 5.6
  BOTTOM w0.114: R271.1 206.63,45.15 C321.2 205.99,45.09 205.41,45.67 205.08,45.67 v5(205.03,45.62) 204.91,45.5 R272.1 204.91,43.18 C326.1
AUO_CBN1: length 5
  TOP w0.203: U6.28 205.1,45.11 205.58,45.59
  TOP w0.305: C320.1 v3(207.72,46.63) 206.63,46.63 205.58,45.59
AUO_CBN2: length 4.5
  TOP w0.203: U6.25 205.97,43.56
  TOP w0.305: C323.1 209.07,44.65 v3(207.54,44.65) 207.49,44.6 207.08,44.6 207.03,44.55 206.96,44.55 205.97,43.56
AUO_CBP1: length 8.2
  TOP w0.203: U6.27 205.71,44.36 205.99,44.65 205.99,45.03
  TOP w0.305: 205.99,45.03 206.86,45.9 209.96,45.9 C320.2
  TOP w0.381: v3(210.79,48.03) 210.79,46.74 C320.2
AUO_CBP2: length 8.1
  TOP w0.203: U6.26 205.81,43.96 206.32,44.48 206.32,44.6 206.6,44.88
  TOP w0.305: 206.6,44.88 207.06,45.34 209.91,45.34 C323.2
  TOP w0.381: C323.2 211.58,45.54 v3(211.84,45.54)
AUO_CPVEE: length 5.6
  TOP w0.114: C309.2 206.58,48.19 206.38,47.99 v3(206.38,47.98) 206.37,47.99 205.01,47.99 203.48,46.45 U6.31
AUO_CPVPP: length 6.4
  TOP w0.114: v3(208.43,49.38) 207.8,48.74 C315.2 206.78,47.12 205.69,47.12 205.1,46.53 204.62,46.53 204.28,46.19 U6.29
AUO_DMIC_CLK1: length 85.8
  TOP w0.114: v1(227.46,76.83) 227.5,76.79 DMIC1.3 ; L34.2 193.74,40.67 C337.2 193.07,41.66 v1(191.59,40.18)
  L3 w0.114: v1(227.46,76.83) 227.27,77.02 218.69,77.02 217.77,77.94 216,77.94 215.99,77.95 214.54,77.95 214.53,77.94 210.52,77.94 209.75,78.71 201.95,78.71 195,71.75 187.96,71.75 185.48,69.27 185.48,64.74 185.71,64.51 185.71,46.19 185.93,45.97 185.93,44.53 190.27,40.18 v1(191.59,40.18)
  BOTTOM w0.114: v5(191.41,41.16) 191.41,40.37 v1(191.59,40.18)
AUO_DMIC_CLK1_R: length 4.3
  TOP w0.114: L34.1 195.02,40.59 195.71,39.9 v3(196.14,39.9) 196.62,39.9 197.48,40.76 U6.53
AUO_DMIC_CLK2: length 85.5
  TOP w0.114: DMIC1.6 230.5,74.17 230.12,73.79 230,73.79 229.24,73.03 228.47,73.03 v1(228.35,72.9) ; L33.2 196.38,36.58 C2525.1 195.3,36.17 v1(195.1,35.97)
  L3 w0.114: v1(195.1,35.97) 195.07,35.99 195.07,36.3 193.93,37.44 193.93,39.45 192.28,41.09 190.55,41.09 189.13,42.51 189.13,55.65 194.72,61.25 194.72,63.32 195.62,64.22 195.62,65.51 197.35,67.23 197.35,72 198.63,73.28 198.63,74.19 201.89,77.45 209.23,77.45 210,76.68 215.06,76.68 215.06,76.69 215.47,76.69 219.26,72.9 v1(228.35,72.9)
  BOTTOM w0.114: v2(194.41,36.96) 194.41,36.65 v1(195.1,35.97)
AUO_DMIC_CLK2_R: length 3.2
  TOP w0.114: L33.1 198.22,37.13 v3(198.32,37.24) 198.93,37.85 199.19,37.85 199.48,38.14 U6.2
AUO_DMIC_DATA1: length 92.9
  TOP w0.114: v1(227.99,79.59) C2534.2 228.83,78.54 228.5,78.21 DMIC1.4 ; R277.2 191.74,39.42 v1(191.44,39.12)
  L3 w0.114: v1(191.44,39.12) 191.13,39.12 190.22,38.2 188.49,38.2 185.29,41.4 185.29,64.33 185.06,64.57 185.06,70.5 192.53,77.98 199.52,77.98 200.91,79.38 209.68,79.38 210.69,78.36 214.36,78.36 214.37,78.37 216.16,78.37 216.17,78.36 226.76,78.36 v1(227.99,79.59)
  BOTTOM w0.114: v1(191.44,39.12) 191.08,39.12 v5(190.37,38.4)
AUO_DMIC_DATA1_R: length 5.2
  TOP w0.114: R277.1 194.81,39.42 v3(194.96,39.27) 196.39,39.27 196.47,39.34 196.55,39.34 197.57,40.36 U6.54
AUO_DMIC_DATA2: length 105
  TOP w0.114: DMIC1.7 231.5,76.09 229.87,77.72 C2533.1 230.5,79.57 v1(230.82,79.25) ; v1(193.27,36.02) 193.85,35.44 194.45,35.44 194.9,34.98 195.7,34.98 196.32,34.37 199.32,34.37 R286.2 199.98,33.7 v3(199.98,32.39)
  L3 w0.114: v1(230.82,79.25) 225.11,73.53 219.22,73.53 215.64,77.11 214.89,77.11 214.88,77.1 210.17,77.1 209.4,77.87 201.72,77.87 197.74,73.89 197.74,73.89 197.45,73.61 197.45,73.6 194.46,70.61 187.96,70.61 185.9,68.55 185.9,64.92 186.44,64.38 186.44,44.61 190.37,40.67 192.11,40.67 193.4,39.39 193.4,36.14 v1(193.27,36.02)
AUO_DMIC_DATA2_R: length 4.1
  TOP w0.114: R286.1 199.78,37.06 v3(199.99,37.27) 199.99,37.3 200.22,37.53 200.22,38.01 200.28,38.07 U6.4
AUO_DMIC_DET: length 139
  TOP w0.114: v1(103.8,50.22) 103.32,49.74 KBC1.25 ; v1(169.42,71.25) 172.29,71.25 180.77,79.73 195.68,79.73 196.49,80.54 200.36,80.54 200.79,80.11 v3(206.17,80.11) 210.46,80.11 210.9,80.54 216.71,80.54 221.75,75.5 R2589.1 223.08,74.97 DMIC1.1
  L6 w0.102: v1(103.8,50.22) 104.91,51.33 109.05,51.33 110.44,52.73 111.55,52.73 112.65,53.83 112.65,54.17 114.34,55.85 115.54,55.85 116.69,57 117.47,57 118.05,57.58 118.1,57.58 119.98,59.46 122.01,59.46 124.54,61.99 124.54,62.69 126.68,64.84 126.7,64.84 126.78,64.92 131.58,64.92 136.18,69.52 137.61,69.52 147.17,69.52 147.9,70.26 163.08,70.26 163.54,70.71 168.88,70.71 v1(169.42,71.25)
AUO_EAPD: length 25.3
  TOP w0.114: PD1.K 214.68,37.85 v1(214.55,37.97) ; U6.52 197.27,41.16 196.9,40.79 v1(196.65,40.79)
  L4 w0.114: v1(196.65,40.79) 196.75,40.69 196.75,40.67 198.67,38.75 198.93,38.75 199.67,38 204.28,38 205.17,37.11 205.52,37.11 206.17,37.11 206.45,36.83 213.41,36.83 v1(214.55,37.97)
  BOTTOM w0.114: R274.1 196.93,40.61 196.75,40.79 v1(196.65,40.79) ; v2(215.52,37.97) v1(214.55,37.97)
AUO_HDA_SDIN0_CPU_R: length 3.9
  TOP w0.114: R275.1 207.67,38.15 v3(206.91,38.91) 205.86,39.96 U6.16
AUO_HP_LINE1_JD: length 10.3
  TOP w0.114: U6.9 202.28,37.98 202.59,37.67 203.02,37.24 203.02,36.23 203.63,35.61 R291.2 205.67,35.61 v3(205.77,35.51) 205.77,34.26 R294.1 205.84,34.24 206.98,35.38 R293.1 C344.1
AUO_HP_MUTE1: length 4.1
  TOP w0.114: U41.6 205.47,60.51 206.75,61.8 v3(206.75,62.1) 206.76,62.1 R2628.2
AUO_HP_MUTE2: length 5.7
  TOP w0.114: U42.6 209.34,58.76 209.04,59.05 209.04,59.82 207.79,61.07 v3(207.79,61.2) 207.79,61.23 207.79,61.23 R2629.1
AUO_HP_MUTE_R: length 14.7
  TOP w0.114: R2627.2 208.14,64.33 R2629.2 207.78,63.97 R2628.1 205.5,63.97 v1(205.49,63.98)
  BOTTOM w0.114: v1(205.49,63.98) 205.13,64.34 v5(203.28,64.34) 203.28,64.32 200.44,61.48 200.44,58.46 200.16,58.18 D14.3
AUO_HPOUT_JD: length 26.7
  TOP w0.114: R293.2 206.98,33.66 v1(207.52,33.12) ; v1(221.16,27.86) v3(222.37,29.07) 226.8,33.5 SUSBC1.20
  L4 w0.114: v1(207.52,33.12) 207.65,32.99 207.65,32.36 208.01,32 215.25,32 217.29,29.95 217.3,29.95 217.48,29.77 217.91,29.77 218.5,29.18 218.5,29.18 218.77,28.91 220.07,28.91 221.11,27.86 v1(221.16,27.86)
AUO_HPOUT_L: length 4
  TOP w0.203: U6.32 203.08,46.59 203.81,47.32 203.81,47.42 204.29,47.9 v3(204.29,48.11)
  TOP w0.508: v3(204.29,48.11) 204.36,48.18 R289.1
AUO_HPOUT_R: length 5.2
  TOP w0.203: 203.37,48.22 203.37,47.56 202.68,46.87 U6.33
  TOP w0.508: 203.37,48.22 203.37,48.48 v3(202.82,49.03) 202.25,49.6 R290.1
AUO_I2S_OUT_MIC1_JD: length 18.5
  TOP w0.114: U6.8 201.88,38.03 202.49,37.41 v1(202.49,36.6) ; v1(192.35,36.09) 192.18,36.09 C1116.1 191.22,35.14 R2586.1 191.74,34.06 R2585.2
  L4 w0.114: v1(202.49,36.6) 202.1,36.21 198.81,36.21 198.12,36.91 193.34,36.91 192.53,36.09 v1(192.35,36.09)
  BOTTOM w0.114: v2(201.55,36.37) 202.26,36.37 v1(202.49,36.6)
AUO_INL_R2: length 3.1
  TOP w0.114: R2624.2 213.67,58.35 214.03,58.7 v3(214.03,58.91) 213.37,58.91 213.22,58.76 U42.1
AUO_INR_L1: length 5.5
  TOP w0.114: R2626.1 207.26,55.88 v3(208.15,56.77) 208.15,57.02 206.88,58.29 205.61,58.29 205.47,58.15 U41.1
AUO_INR_R1: length 3.3
  TOP w0.114: U41.3 206.77,56.05 v3(206.16,55.44) 206.1,55.37 R2625.1
AUO_INR_R2: length 3.2
  TOP w0.114: R2623.2 213.21,61.59 v3(212.15,61.59) U42.3
AUO_IRQOUT: length 4.8
  TOP w0.203: U6.6 201.08,37.25
  TOP w0.508: 201.08,37.25 201.17,37.16 201.17,36.7 v3(201.32,36.55) 201.32,36.5 201.9,35.92 202.41,35.92 203.08,35.25 R282.1
AUO_LDO1_CAP: length 3.6
  TOP w0.203: 196.44,44.68 197.1,44.68 197.42,44.36 U6.44
  TOP w0.381: 196.44,44.68 195.81,44.04 C322.1
AUO_LDO2_CAP: length 9
  TOP w0.203: U6.22 205.13,42.39 207.21,42.39 207.58,42.77
  TOP w0.381: v3(213.41,43.94) 212.04,43.94 C330.1 211.84,43.74 210.01,43.74 209.25,42.98 C331.1 207.79,42.98 207.58,42.77
AUO_LDO3_CAP: length 6.1
  TOP w0.203: U6.18 206.04,40.76 206.24,40.56 206.53,40.56 206.74,40.35 206.97,40.35 207.44,39.88 v1(207.47,39.88)
  BOTTOM w0.381: v1(207.47,39.88) 207.47,39.88 206.88,40.46 v2(206.62,40.46) 206.36,40.21 205.61,40.21 C335.1 C334.1
AUO_LINE1-VREF_O_L: length 23.8
  TOP w0.203: U6.40 199.88,46.38 199.11,47.14 v1(199.03,47.14)
  BOTTOM w0.381: D13.3 213.11,56.13 v2(212.47,55.5) 212.47,55.37 211.71,54.61 211.71,52.07 210.95,51.31 206.93,51.31 204.39,48.77 204.39,47.96 202.56,46.13 199.92,46.13 199.03,47.02 v1(199.03,47.14)
AUO_LINE1-VREF_O_L_N: length 4
  TOP w0.381: v1(215.46,61.34) 215.29,61.18 R2622.1
  BOTTOM w0.381: D13.2 214.09,60.55 v2(214.38,60.83) 214.88,61.34 v1(215.46,61.34)
AUO_LINE1-VREF_O_L_R: length 28
  TOP w0.381: v1(212.34,50.16) 212.34,53.72 215.26,56.64 215.26,58.17 214.76,58.67 214.76,60.17 R2622.2 R2623.1
  BOTTOM w0.381: v1(212.34,50.16) 212.34,45.57 214.6,43.31 v5(216.08,43.31) L15.1 220.94,43.31 R304.1 221.01,43.31 PR3.2
AUO_LINE1-VREF_O_R_N: length 4.2
  TOP w0.381: v1(212.09,57.66) v3(211.33,56.9) 211.33,56.26 211.58,56.01 R2621.1
  BOTTOM w0.381: v1(212.09,57.66) 212.12,57.69 D13.1
AUO_LINE1-VREF_O_R_R: length 30.3
  TOP w0.381: R2624.1 214.56,56.95 v1(214.25,56.64) 213.61,56.01 R2621.2
  BOTTOM w0.381: L14.1 R305.1 PR2.2 218.99,37.53 218.64,37.87 217.78,37.87 216.94,38.71 216.94,39.83 210.92,45.85 v5(210.92,47.34) 210.92,49.89 212.58,51.55 212.58,54.47 214.25,56.13 v1(214.25,56.64)
AUO_LINE1_L: length 24
  TOP w0.203: U6.35 201.88,47.42 v1(201.89,47.43)
  TOP w0.508: v1(219.13,44.22) 219.74,43.61 PT2.1
  L4 w0.508: v1(201.89,47.43) 202.33,46.99 203.2,46.99 205.71,44.48 216.92,44.48 217.45,43.94 218.85,43.94 v1(219.13,44.22)
  BOTTOM w0.508: v2(219.81,44.9) v1(219.13,44.22)
AUO_LINE1_L_T: length 5.6
  TOP w0.508: PT2.2 226.34,44.83 v1(225.04,44.83)
  BOTTOM w0.508: v1(225.04,44.83) 224.92,44.83 v2(224.2,44.12) 223.39,43.31 PR3.1
AUO_LINE1_R: length 28.1
  TOP w0.203: v1(202.62,48.03) 202.67,47.98 202.67,47.33 202.28,46.94 U6.34
  TOP w0.508: v1(218.24,44.81) v3(218.24,41.66) 218.24,40.31 219.38,39.17 PT1.1
  L4 w0.508: v1(202.62,48.03) 202.84,47.8 203.78,47.8 205.77,45.82 217.22,45.82 v1(218.24,44.81)
AUO_LINE1_R_T: length 5.7
  TOP w0.508: v1(221.77,34.94) 221.77,34.8 221.77,34.79 PT1.2
  BOTTOM w0.508: v1(221.77,34.94) 221.77,36.04 221.01,36.8 v2(221.01,36.88) 220.54,36.88 220.29,36.64 PR2.1
AUO_LINEOUT_JD: length 83.6
  TOP w0.114: v1(206.91,32.41) 206.6,32.72 R294.2 205.23,32.16 v3(205.23,31.62) ; LAUOC1.39 142.25,7.91 v1(142.67,8.33)
  L4 w0.114: v1(142.67,8.33) 145.4,11.06 150.43,11.06 151.46,12.09 154.61,12.09 160.38,17.86 164.44,17.86 164.87,18.29 168.02,18.29 171.07,15.24 v1(176.91,15.24) ; v1(206.91,32.41) 205.13,32.41 204.9,32.18 202.27,32.18 202.08,32.37 201.53,32.37 200.33,31.17 196.37,31.17 195.94,30.73 195.86,30.73 195.55,30.43 195.55,30.35 194.31,29.11 187.42,29.11 186.77,28.45 v1(186.77,26.67)
  L6 w0.102: v1(186.77,26.67) 186.31,26.67 185.62,25.98 185.62,23.06 178.56,16 177.67,16 v1(176.91,15.24)
AUO_LINEOUT_L: length 134
  TOP w0.305: LAUOC1.38 141.75,6.6 v1(141.5,6.35)
  BOTTOM w0.508: v1(141.5,6.35) 141.81,6.05 151.46,6.05 154.69,2.82 221.41,2.82 224.95,6.35 224.95,7.57 231.11,13.74 231.11,19.48 228.98,21.62 v2(228.98,35.4) 228.98,36.58 224.64,40.92 220.29,40.92 219.71,41.5 L15.2 218.44,41.78 C351.1
AUO_LINEOUT_R: length 127.7
  TOP w0.305: LAUOC1.37 v1(141.25,8)
  BOTTOM w0.508: v1(141.25,8) 142.32,6.93 152.15,6.93 155.35,3.73 220.93,3.73 v5(222.02,4.83) 224.03,6.83 224.03,8.26 230.1,14.33 230.1,19.13 228.09,21.13 228.09,36.07 224.16,40.01 C352.1 L14.2
AUO_LINK_BCLK: length 8.7
  TOP w0.114: U6.13 203.88,38.06 204.24,37.69 205.46,37.69 206.2,36.96 v3(206.3,36.96) 207.04,36.22 209.12,36.22 209.49,35.85 R278.1 209.83,35.42 C338.1
AUO_MIC1-VREF_O_L: length 8.4
  TOP w0.203: U6.38 200.68,46.59 200.48,46.79 200.48,47.34 199.55,48.27 v3(199.45,48.27)
  TOP w0.356: RN2415.1 201.05,51.59 200.85,51.79 200.6,51.79 200.4,51.59 RN2415.2 200.4,50.8 200.1,50.5 200.09,50.5 199.39,49.79 199.39,48.33 v3(199.45,48.27)
AUO_MIC1_CAP: length 4.6
  TOP w0.203: 199.16,46.53 199.48,46.22 U6.41
  TOP w0.305: C314.2 197.95,47.77 v3(198.12,47.6) 198.09,47.57 198.09,47.12 198.68,46.53 199.16,46.53
AUO_MIC1_L: length 7
  TOP w0.203: v4(201.7,48.4) 201.7,48.05 201.35,47.7 201.35,46.98 201.48,46.86 U6.36
  TOP w0.356: RN2415.4 201.05,49.05 v4(201.7,48.4)
  BOTTOM w0.508: v4(201.7,48.4) 201.75,48.46 L11.1 202.56,49.4 v2(202.87,49.1)
AUO_MIC1_R: length 6.9
  TOP w0.203: U6.37 201.08,46.79 200.92,46.95 200.92,47.9 v4(200.58,48.23)
  TOP w0.356: RN2415.3 200.4,48.42 v4(200.58,48.23)
  BOTTOM w0.508: L10.1 v4(200.58,48.23) 200.58,47.6 v2(200.94,47.24)
AUO_MONITOR_SW: length 68.2
  TOP w0.114: LAUOC1.26 135.75,7.78 136.96,8.99 142.87,8.99 142.99,8.87 143.55,8.87 144.37,8.05 v1(145.43,8.05) ; v1(173.35,10.44) 173.35,13.08 176.53,16.26 178.46,16.26 179.07,16.87 179.07,18.16 181.94,21.03 181.94,21.67 182.91,22.63 v3(182.91,23.77) 182.91,25.43 183.96,26.48 R2587.1
  L4 w0.114: v1(173.35,10.44) 173.35,11.43 170.05,14.73 163.56,14.73 160.76,11.94 158.04,11.94 154.76,8.66 147.42,8.66 146.56,7.8 145.68,7.8 v1(145.43,8.05)
AUO_POST_I2S_BCLK: length 5
  TOP w0.114: R302.1 195.1,38.66 196.06,38.66 196.35,38.37 197.96,38.37 198.25,38.66 U6.56
AUO_POST_I2S_BCLK_R: length 43.6
  TOP w0.114: U8.10 200.19,26.6 v1(200.33,26.47) ; U7.10 217.1,25.64 v1(217.22,25.76) ; R302.2 192.35,38.15 v1(192.13,38.38)
  L3 w0.114: v1(192.13,38.38) 192.15,38.35 192.15,37.72 191.29,36.86 191.29,35.46 191.8,34.95 192.86,34.95 197.05,30.76 197.08,30.76 197.43,30.4 197.43,29.67 200.33,26.77 v1(200.33,26.47)
  L4 w0.114: v1(200.33,26.47) 200.38,26.42 200.79,26.42 203.45,23.75 204.72,23.75 206.12,22.35 209.93,22.35 210.45,21.83 214.75,21.83 216.66,23.74 216.66,24.09 216.66,25.2 v1(217.22,25.76)
  BOTTOM w0.114: v2(201.29,26.49) 201.22,26.49 201.19,26.47 v1(200.33,26.47) ; C347.1 216.64,25.18 v1(217.22,25.76)
AUO_POST_I2S_DIN: length 6.2
  TOP w0.114: U6.5 200.68,37.49 200.63,37.44 200.63,37.17 200.6,37.14 200.6,36.25 200.99,35.87 v3(200.99,35.22) 200.87,35.1 C350.1 200.99,33.99 201.33,34.33 R297.1
AUO_POST_I2S_DIN_R: length 28
  TOP w0.114: U8.14 199.98,28.2 v1(200.91,29.13) 201.02,29.24 202.13,29.24 202.16,29.21 202.56,29.21 202.87,29.51 202.87,30.43 v3(202.44,30.86) 202.44,32.25 R297.2 ; U7.14 216.02,27.71 216,27.73 216,28.57 216.89,29.46 v1(217.09,29.46)
  L4 w0.114: v1(200.91,29.13) 201.12,29.34 201.93,29.34 202.18,29.08 205.71,29.08 206.52,28.28 215.53,28.28 216.71,29.46 v1(217.09,29.46)
AUO_POST_I2S_DOUT: length 4.2
  TOP w0.114: R298.1 199.19,35.79 199.19,36.16 v3(199.18,36.16) 199.18,37.3 199.88,37.99 U6.3
AUO_POST_I2S_DOUT_R: length 41.5
  TOP w0.114: R298.2 196.07,35.1 195.84,35.33 195.05,35.33 194.59,35.78 194.42,35.78 v1(194.18,36.02) ; v1(200.94,28.22) 200.63,28.22 199.82,27.4 U8.12 ; U7.12 216.63,26.44 216.89,26.7 216.89,27.97 217.25,28.32 218.57,28.32 218.88,28.64 C349.1 218.03,28.96 v1(218.01,28.98)
  L3 w0.114: v1(200.94,28.22) 200.3,28.22 198.37,30.15 198.37,30.69 194.11,34.96 194.11,35.94 v1(194.18,36.02)
  L4 w0.114: v1(200.94,28.22) 201.35,27.81 202.21,27.81 203.03,28.63 205.56,28.63 206.33,27.86 215.79,27.86 216.89,28.96 217.98,28.96 v1(218.01,28.98)
  BOTTOM w0.114: v1(200.94,28.22) 201.47,27.69 v2(201.8,27.69)
AUO_POST_I2S_LRCK: length 5.1
  TOP w0.114: U6.1 198.82,38.74 198.1,38.02 196.21,38.02 196.16,38.07 v3(195.7,38.07) 194.82,37.19 R301.1
AUO_POST_I2S_LRCK_R: length 43
  TOP w0.114: v1(200.63,27.36) 200.28,27 U8.11 ; v1(192.3,37.06) 192.79,37.06 192.86,36.98 R301.2 ; U7.11 216.79,26.04 217.4,26.64 v1(217.5,26.64)
  L3 w0.114: v1(192.3,37.06) 191.74,36.5 191.74,35.86 192.23,35.38 193.04,35.38 197.23,31.19 197.26,31.19 197.95,30.5 197.95,29.97 200.57,27.36 v1(200.63,27.36)
  L4 w0.114: v1(217.5,26.64) 217.3,26.64 216.24,25.59 216.24,23.91 214.58,22.25 210.67,22.25 208.03,24.89 204.32,24.89 202.16,27.05 200.94,27.05 v1(200.63,27.36)
  BOTTOM w0.114: v1(217.5,26.64) 216.84,27.31 v2(216.38,27.31) 216.38,27.3 216.26,27.18 C348.1
AUO_PVDD1: length 5.2
  TOP w0.203: U6.46 197.41,43.56 v4(196.62,42.77) ; 196.95,41.86 197.25,41.56 U6.51
  TOP w0.508: 196.95,41.86 196.29,41.86 v4(195.48,42.67)
  vias: v2(196.22,41.73)
AUO_RESET_OUT: length 5.4
  TOP w0.114: R2690.1 v3(207.62,36.96) 207.14,36.96 206.3,37.8 206.3,38.91 205.65,39.56 U6.15
AUO_SET1: length 2.7
  TOP w0.114: C1124.2 208.36,59.61 v3(208.15,59.82) 207.66,59.82 207.39,59.55 U41.4
AUO_SET2: length 2.5
  TOP w0.114: C1123.2 210.05,62.46 v3(210.05,61.42) U42.4
AUO_SIO_HP_MUTE: length 144.2
  TOP w0.114: v1(205.69,75.21) 203.89,75.21 201.22,77.88 190.16,77.88 190,78.04 185.15,78.04 180.31,73.2 180.31,72.41 179.8,71.89 178.42,71.89 173.05,66.52 v1(173.05,63.88) ; KBC1.30 103.4,47.74 103.76,48.11 v1(104,48.11)
  L6 w0.102: v1(173.05,63.88) 172.57,63.4 167.41,63.4 167.06,63.75 156.6,63.75 154.21,61.37 153.87,61.37 144.15,61.37 144.15,61.37 139.99,61.37 137.88,59.26 135.32,59.26 132.47,56.41 132.46,56.41 130.58,54.53 130.58,54.19 130.58,52.92 128.64,50.98 122.61,50.98 121.87,50.24 110.25,50.24 109.72,49.71 107.44,49.71 105.47,47.73 104.38,47.73 v1(104,48.11)
  BOTTOM w0.114: v1(205.69,75.21) 206.15,74.75 v5(206.15,68.33) 206.15,63.65 205.97,63.47 205.16,63.47 204.93,63.7 203.15,63.7 200.79,61.34 200.79,58.29 199.84,57.35 D14.1
AUO_SPDIF_IN: length 99.9
  TOP w0.114: v1(125.12,10.57) 125.12,9.58 v3(125.17,9.53) 126.75,7.95 LAUOC1.8
  L4 w0.114: v1(190.81,32.9) 190.81,36.36 192.22,37.76 192.35,37.76 192.64,38.05 192.64,38.18 193.45,38.99 196.44,38.99 196.58,38.86 v1(196.67,38.86)
  L6 w0.102: v1(190.81,32.9) 190.81,32.67 189.87,31.72 187.38,31.72 175.84,20.19 175.13,20.19 174.55,19.61 174.55,16.89 172.19,14.53 172.19,11.76 170.99,10.57 165.84,10.57 165.58,10.82 163.12,10.82 162.94,10.64 156.18,10.64 155.13,9.58 136.66,9.58 134.54,7.47 125.09,7.47 124.31,8.26 124.31,9.75 v1(125.12,10.57)
  BOTTOM w0.114: C1151.2 197.08,37.68 197.08,37.75 196.67,38.15 v1(196.67,38.86)
AUO_SPDIF_IN_R: length 3.9
  TOP w0.114: v1(197.58,38.94) 197.44,39.08 197.44,39.71 197.7,39.96 U6.55
  BOTTOM w0.114: v1(197.58,38.94) 198.02,38.94 198.36,38.59 v2(198.36,38.37) 198.23,38.23 C1151.1
AUO_VD33STB: length 6.6
  TOP w0.203: U6.10 202.68,38.04 203.5,37.21 v1(203.5,36.47)
  BOTTOM w0.508: v1(203.5,36.47) 204.19,35.79 R2719.2 204.18,35.12 R2718.2 203.1,35.1 v2(201.88,35.1)
AUO_VREF1_1: length 7.1
  TOP w0.203: U6.21 206.02,41.96 206.11,42.06 206.66,42.06 206.97,41.76 v1(207.62,41.76)
  BOTTOM w0.381: C329.1 C332.1 208.3,42.24 207.82,41.76 v1(207.62,41.76) 207.11,42.27 v2(205.79,42.27)
AUO_VREF_1: length 4.3
  TOP w0.203: 197.37,45.07 197.68,44.76 U6.43
  TOP w0.381: C312.1 195.58,46.13 C313.1 196.42,45.21 196.58,45.37 v3(196.65,45.37) 197.07,45.37 197.37,45.07
AZ_SDIN2: length 38.5
  TOP w0.114: CPU1.AV4 151.47,179.53 150.87,179.53 150.64,179.76 149.24,179.76 148.88,179.4 148.88,179.24 149.65,178.48 149.65,178.3 149.5,178.15 149.32,178.15 148.56,178.92 148.4,178.92 148.14,178.66 146.43,178.66 146.1,178.33 146.1,177.99 146.22,177.88 146.86,177.88 146.99,177.75 146.99,177.52 146.89,177.42 146.22,177.42 146.1,177.3 146.1,176.62 145.27,175.79 145.27,175.62 146.2,174.7 146.2,174.52 146.05,174.37 145.87,174.37 144.94,175.3 144.78,175.3 144.54,175.06 144.54,174.9 145.63,173.8 145.63,173.65 145.46,173.48 145.31,173.48 144.22,174.57 144.05,174.57 143.89,174.41 143.89,174.25 144.96,173.19 144.96,173.02 144.22,172.29 137.85,172.29 137.34,171.78 136.45,171.78 v3(136.12,171.45) 135.61,170.94 132.51,170.94 132.02,170.45 132.02,170.25 131.57,169.8 R56.1
BIST_EN_INV: length 67.1
  TOP w0.114: LAUOC1.13 129.25,8.83 v3(129.82,9.4) 129.82,9.63 v1(128.73,10.72) ; KBC1.42 107.65,44.66 107.31,44.32 106.83,44.32 106.06,43.55 106.06,41.44 v1(106.12,41.38)
  L6 w0.102: v1(106.12,41.38) 105.93,41.57 105.93,41.78 106.39,42.24 107.16,42.24 107.87,41.53 120.62,41.53 122.45,39.7 130.73,39.7 132.33,38.1 132.33,35.41 132.59,35.15 132.59,17.81 130.05,15.27 130.05,12.04 v1(128.73,10.72)
CASA0B: length 31.8
  TOP w0.13: v6(79.85,187.2) 79.85,187.05 GPU1.R32 ; VRAMA1.L3 v6(101.3,197.2)
  BOTTOM w0.089: 86.94,188.8 86.86,188.72 86.86,188.25 86.85,188.24 86.85,188.23 86.61,187.99 80.64,187.99 v6(79.85,187.2)
  BOTTOM w0.13: 86.94,188.8 88.35,190.21 88.35,192.07 90.34,194.06 90.34,194.32 92.35,196.33 92.35,196.34 94.21,198.2 94.74,198.2 95.06,197.88 95.06,196.36 95.59,195.82 100.75,195.82 101.1,196.17 101.1,197 v6(101.3,197.2)
CASA1B: length 40.8
  TOP w0.13: GPU1.L35 82.25,190.65 v6(82.25,190.8) ; VRAMA2.G3 92.08,218.9 v6(91.67,219.31)
  BOTTOM w0.13: v6(82.25,190.8) 82.25,191.64 82.53,191.92 82.53,193.32 82.75,193.55 82.75,196.11 83.2,196.56 83.2,200.25 86.69,203.73 86.87,203.73 87.22,203.38 87.41,203.38 87.6,203.57 87.6,203.76 87.25,204.11 87.25,204.29 87.44,204.48 87.62,204.48 87.97,204.13 88.16,204.13 88.35,204.32 88.35,204.51 88,204.86 88,205.04 89.25,206.3 89.25,207.18 91.94,209.86 91.94,209.9 93.58,211.54 93.58,212.86 93.19,213.25 90.53,213.25 90.42,213.36 90.42,218.79 90.65,219.02 91.34,219.02 91.63,219.31 v6(91.67,219.31)
CASB0B: length 35.3
  TOP w0.13: v6(66.82,219.31) 66.78,219.31 VRAMB1.L3 ; GPU1.K21 68.95,191.45 v6(68.8,191.45)
  BOTTOM w0.089: v6(68.8,191.45) 68.77,191.45 68.4,191.82 68.4,195.72 68.45,195.77 68.45,196.06 68.4,196.12
  BOTTOM w0.13: 68.4,196.12 68.4,197.62 68.43,197.65 68.43,204.45 65.96,206.92 65.96,210.59 66.38,211 66.38,211.27 66.25,211.4 65.83,211.4 65.7,211.53 65.7,211.8 65.83,211.93 66.25,211.93 66.38,212.06 66.38,212.46 66.26,212.58 65.88,212.58 65.74,212.72 65.74,213.03 65.87,213.16 67.93,213.16 68.08,213.32 68.08,218.8 67.58,219.3 66.86,219.3 66.85,219.31 v6(66.82,219.31)
CASB1B: length 39.1
  TOP w0.13: VRAMB2.G3 v6(54.7,219.3) ; v6(66.4,189.85) 66.55,189.85 GPU1.M19
  BOTTOM w0.089: v6(66.4,189.85) 65.81,190.44 65.81,190.84
  BOTTOM w0.1: 65.81,190.84 65.8,190.84 65.8,195.8 65.86,195.85 65.86,197.84 65.64,198.06
  BOTTOM w0.13: v6(54.7,219.3) 53.84,219.3 53.42,218.88 53.42,213.45 54.45,212.43 54.62,212.43 54.72,212.32 57.78,212.32 60.3,209.8 60.3,206.35 65.64,201.01 65.64,198.06
CASC0B: length 40.9
  TOP w0.13: v6(30.7,195.31) 30.7,195.3 VRAMC1.L3 ; GPU1.W12 60.15,183.45 v6(60.15,183.6)
  BOTTOM w0.089: 51.94,184.36 52.1,184.2 59.55,184.2 v6(60.15,183.6)
  BOTTOM w0.13: v6(30.7,195.31) 30.72,195.33 30.73,195.33 30.95,195.55 30.95,196.41 31.12,196.58 36.42,196.58 37.24,195.76 37.24,195.64 37.68,195.2 37.68,194.69 37.55,194.56 37.11,194.56 36.98,194.43 36.98,194.16 37.11,194.03 37.55,194.03 37.68,193.9 37.68,193.63 37.55,193.5 37.11,193.5 36.98,193.37 36.98,193.1 37.11,192.97 37.43,192.97 40.69,189.7 43.65,189.7 48.99,184.36 51.94,184.36
CASC1B: length 36.7
  TOP w0.13: GPU1.AA10 58.55,181.05 v6(58.55,181.2) ; VRAMC2.G3 v6(30.7,183.2)
  BOTTOM w0.089: v6(58.55,181.2) 58.15,181.6 55.04,181.6 54.98,181.66 54.57,181.66
  BOTTOM w0.13: v6(30.7,183.2) 30.7,182.42 31.2,181.92 36.55,181.92 36.75,182.12 36.75,184.04 36.97,184.26 37.28,184.26 37.42,184.12 37.42,183.74 37.54,183.62 37.94,183.62 38.07,183.75 38.07,184.17 38.2,184.3 38.47,184.3 38.6,184.17 38.6,183.75 38.73,183.62 39.04,183.62 39.14,183.72 39.14,184.1 39.29,184.25 39.55,184.25 39.65,184.15 39.66,184.15 39.66,184.14 39.66,184.11 39.67,184.1 39.67,183.72 39.78,183.62 40.11,183.62 40.21,183.72 40.21,184.07 40.36,184.23 40.61,184.23 40.72,184.12 40.72,183.79 40.82,183.69 43.43,183.69 45.46,181.66 54.57,181.66
CASD0B: length 40.4
  TOP w0.13: VRAMD1.L3 v6(30.7,158.3) ; GPU1.AR11 59.35,168.2 59.17,168.02 v6(59.17,167.98)
  BOTTOM w0.089: 54.2,167.22 57.27,167.22 57.63,167.58 57.92,167.58 57.99,167.64 58.79,167.64 59.13,167.98 v6(59.17,167.98)
  BOTTOM w0.13: v6(30.7,158.3) 30.84,158.44 30.84,159.24 31.18,159.58 36.55,159.58 36.85,159.28 36.85,157.77 37.39,157.24 38.04,156.58 38.61,156.58 42.74,160.7 43.5,160.7 46.42,163.62 46.6,163.62 46.86,163.37 47.04,163.37 47.23,163.56 47.23,163.74 46.98,164 46.98,164.18 47.17,164.37 47.35,164.37 47.61,164.12 47.79,164.12 47.98,164.31 47.98,164.49 47.73,164.74 47.73,164.93 47.92,165.12 48.1,165.12 48.36,164.87 48.54,164.87 48.73,165.06 48.73,165.24 48.48,165.49 48.48,165.68 49.6,166.8 53.78,166.8 54.2,167.22
CASD1B: length 32.9
  TOP w0.13: v6(52.81,148.71) 52.79,148.71 VRAMD2.G3 ; v6(62.8,170.15) 62.95,170.15 GPU1.AM15
  BOTTOM w0.089: 61.23,163.9 61.3,163.98 61.8,163.98 62,164.17 62,169.35 62.14,169.49 62.14,169.99 62.3,170.15 v6(62.8,170.15)
  BOTTOM w0.13: 61.23,163.9 59.85,162.52 59.33,162.52 58.38,161.58 58.13,161.58 57.56,161.01 57.38,161.01 57.18,161.22 56.99,161.22 56.8,161.03 56.8,160.84 57.01,160.64 57.01,160.46 56.21,159.66 55.6,159.66 51.49,155.55 51.49,155.2 51.75,154.94 53.64,154.94 54.08,154.5 54.08,149.2 53.57,148.69 52.82,148.69 v6(52.81,148.71)
CHAR_CTL1_REAR: length 3
  TOP w0.114: U12.6 98.55,44.89 98.48,44.96 v3(98.48,45.01) 98.48,45.59 98.17,45.9 R346.1
CHAR_CTL1_SIDE: length 7.9
  TOP w0.114: U10.6 222.13,13.83 223.19,12.76 v3(223.19,12.32) 223.19,11.48 223.44,11.23 223.44,8.89 224.47,7.86 R333.1
CHAR_CTL2_REAR: length 3.2
  TOP w0.114: R349.1 97.1,45.52 v3(97.18,45.45) 97.46,45.17 97.46,44.71 98.05,44.12 U12.7
CHAR_CTL2_SIDE: length 6
  TOP w0.114: U10.7 222.63,13.82 223.77,12.67 223.77,11.67 v3(224.09,11.35) 224.39,11.05 225.89,11.05 R335.1
CHAR_CTL3_REAR: length 4
  TOP w0.114: R352.1 95.81,46.14 v3(95.81,45.36) 95.81,45.16 96.67,44.3 97.26,44.3 97.55,44.02 U12.8
CHAR_CTL3_SIDE: length 4.1
  TOP w0.114: U10.8 223.13,13.95 224.16,12.92 224.31,12.92 224.6,12.64 R337.1 225.51,12.64 226.02,13.15 v3(226.02,13.39)
CHAR_EN_REAR: length 4.9
  TOP w0.114: R2497.1 R351.1 R354.2 99.45,45.67 99.87,45.25 v3(99.87,45.02) 99.87,44.73 99.05,43.9 U12.5
CHAR_EN_REAR_EC: length 17.5
  TOP w0.114: R2497.2 100.44,47.9 100.99,47.9 v1(101.14,48.06) ; KBC1.121 106.85,60.16 106.68,59.99 106.68,59.56 106.07,58.95 106.07,58.93 v1(105.79,58.65)
  L4 w0.114: v1(101.14,48.06) 101.14,48.64 102.06,49.56 102.06,55.6 104,57.54 105.02,57.54 105.79,58.32 v1(105.79,58.65)
  BOTTOM w0.114: v1(101.14,48.06) 100.61,48.59 100.61,48.67 v2(100.61,48.67)
CHAR_EN_SIDE: length 5
  TOP w0.114: U10.5 221.63,13.52 221.62,13.52 221.62,13.07 v3(221.87,12.82) 222.02,12.67 222.02,11.54 R339.2 R336.1 R2498.1
CHAR_EN_SIDE_EC: length 135.9
  TOP w0.114: v1(121.18,48.01) 121.18,48.13 120.15,49.16 119.19,49.16 119,49.34 KBC1.71 ; R2498.2 219.57,10.58 v1(218.92,11.23)
  L3 w0.114: v1(218.92,11.23) 219.38,10.77 219.38,10.09 219.32,10.03 219.32,9.19 218.64,8.5 213.62,8.5 212.98,9.14 206.24,9.14 206.23,9.15 204.29,9.15 204.25,9.11 193.07,9.11 191.74,10.44 191.74,10.45 190.91,11.28 190.91,13.92 184.92,19.91 167.27,19.91 166.19,18.82 v1(165.53,18.82)
  L6 w0.102: v1(121.18,48.01) 121.82,47.37 127.04,47.37 127.7,46.71 128.5,46.71 128.6,46.61 133.99,46.61 134.32,46.28 134.36,46.28 139.03,41.61 140.8,41.61 142.2,40.21 142.48,40.21 144.25,38.44 144.25,37.34 143.87,36.96 143.87,34.85 144.63,34.09 151.92,34.09 152.83,33.17 153.92,33.17 157.82,29.27 158.04,29.27 160.27,27.04 160.27,19.02 163.3,16 163.88,16 165.63,17.75 165.63,18.72 v1(165.53,18.82)
  BOTTOM w0.114: v1(218.92,11.23) 218.95,11.23 v2(219.58,10.59)
CHAR_ILIM_HI_REAR: length 3.6
  TOP w0.114: R356.1 100.9,38.29 100.37,38.82 v3(100.02,38.82) 99.05,39.8 U12.16
CHAR_ILIM_HI_SIDE: length 3.9
  TOP w0.114: R341.1 221.39,20.15 v3(221.36,20.12) 221.36,19.48 221.63,19.22 U10.16
CHAR_ILIM_LO_REAR: length 2.5
  TOP w0.114: R355.1 98.55,38.54 v3(98.55,39.11) 98.55,39.11 U12.15
CHAR_ILIM_LO_SIDE: length 4
  TOP w0.114: U10.15 222.13,19 222.19,19.07 v3(222.19,19.1) 222.53,19.44 R340.1
CHAR_ILIM_SEL_REAR: length 3.1
  TOP w0.114: U12.4 100.19,42.79 100.91,43.51 v3(101.49,43.51) 102.53,43.51 R353.1
CHAR_ILIM_SEL_SIDE: length 3.8
  TOP w0.114: R338.1 220.92,13.11 v1(220.24,13.78) 220.24,14.76 220.48,15 U10.4
  BOTTOM w0.114: v1(220.24,13.78) 220.25,13.77 220.93,13.77 v2(220.93,13.77)
CHAR_USBOC4#: length 2.9
  TOP w0.114: R332.1 223.65,19.08 v3(223.5,18.94) 223.13,18.56 U10.13
CHAR_USBOC6#: length 3.3
  TOP w0.114: R345.1 97.08,37.86 v3(97.08,38.9) 97.08,39.65 97.55,40.12 U12.13
CKEA0: length 32.5
  TOP w0.13: VRAMA1.J3 102.87,197.97 v6(102.9,197.97) ; GPU1.P34 81.45,188.25 v6(81.45,188.4)
  BOTTOM w0.089: v6(81.45,188.4) 82.04,188.99 85.61,188.99 85.83,189.21
  BOTTOM w0.13: 85.83,189.21 86.9,190.28 86.9,192.92 94.2,200.22 94.76,200.22 95.82,201.27 102.07,201.27 102.68,200.66 102.68,198.22 102.9,198 v6(102.9,197.97)
CKEA1: length 41.5
  TOP w0.13: v6(92.53,220.91) 92.51,220.91 VRAMA2.J3 ; v6(81.45,189.6) 81.45,189.45 GPU1.M34
  BOTTOM w0.089: 84.16,192.86 84.16,191.78 83.45,191.08 83.45,190.54 83.22,190.31 83.19,190.31 82.84,190.23 82.49,190 82.08,190 81.68,189.6 v6(81.45,189.6)
  BOTTOM w0.13: 84.16,192.86 83.95,193.07 83.95,196.61 84.46,198.46 90.68,204.68 90.68,205.51 90.68,205.51 90.68,206.76 94.78,210.87 95.55,212 95.55,219.99 95.14,220.4 94.27,220.67 92.77,220.67 v6(92.53,220.91)
CKEB0: length 39.3
  TOP w0.13: v6(66,220.9) 66.03,220.9 VRAMB1.J3 ; GPU1.N21 69.25,188.6 v6(68.8,189.05)
  BOTTOM w0.089: 67.81,196.37 67.78,196.33 67.78,195.96 68,195.74 68,189.91 68.8,189.11 v6(68.8,189.05)
  BOTTOM w0.13: 67.81,196.37 67.94,196.5 67.94,202.98 64.13,206.79 64.13,212.01 62.31,213.83 62.31,220.14 63.07,220.9 66,220.9 v6(66,220.9)
CKEB1: length 39.8
  TOP w0.13: v6(67.66,189.06) 68.12,188.6 GPU1.N20 ; VRAMB2.J3 v6(55.5,220.9)
  BOTTOM w0.089: 66.83,195.99 66.82,195.98 66.82,190.26 67.2,189.88 67.2,189.68 67.66,189.23 v6(67.66,189.06)
  BOTTOM w0.13: v6(55.5,220.9) 55.56,220.84 58.28,220.84 58.94,220.18 59.79,219.33 59.79,213.08 61.6,211.27 61.6,206.9 66.33,202.17 66.33,199.89 66.31,199.87 66.31,197.52 66.33,197.5 66.33,196.49 66.83,195.99
CKEC0: length 41.9
  TOP w0.13: GPU1.Y13 60.95,182.25 v6(60.95,182.4) ; VRAMC1.J3 v6(29.1,194.5)
  BOTTOM w0.089: 54.51,183.12 54.65,183.12 54.71,183.18 60.17,183.18 v6(60.95,182.4)
  BOTTOM w0.13: 54.51,183.12 52.04,183.12 51.46,183.7 49.93,183.7 49.79,183.56 47.94,183.56 43.1,188.4 40.15,188.4 38,190.55 34.41,190.55 34.28,190.42 34.28,190.2 34.15,190.07 33.88,190.07 33.75,190.2 33.75,190.42 33.62,190.55 33.35,190.55 33.22,190.42 33.22,190.2 33.09,190.07 32.82,190.07 32.69,190.2 32.69,190.42 32.56,190.55 32.29,190.55 32.16,190.42 32.16,190.2 32.03,190.07 31.76,190.07 31.63,190.2 31.63,190.42 31.32,190.73 30.15,190.73 29.16,191.72 29.16,193.85 29.16,194.44 v6(29.1,194.5)
CKEC1: length 38.6
  TOP w0.13: GPU1.AA13 60.95,181.05 v6(60.95,181.13) ; VRAMC2.J3 v6(29.1,184)
  BOTTOM w0.089: v6(60.95,181.13) 60.51,181.58 60.31,181.64 59.17,181.99 55.2,181.99 54.99,182.19 54.46,182.19
  BOTTOM w0.13: v6(29.1,184) 29.14,184.04 29.14,186.54 29.7,187.1 31.78,187.69 36.17,187.69 37.99,185.87 43.21,185.87 46.89,182.19 54.46,182.19
CKED0: length 41.3
  TOP w0.13: GPU1.AP12 60.55,168.55 v6(60.4,168.55) ; VRAMD1.J3 v6(29.1,157.5)
  BOTTOM w0.13: v6(60.4,168.55) 59.26,167.41 59.01,167.41 58.27,166.67 57.71,166.67 57.12,166.09 53.33,166.09 52.78,165.54 51.54,165.54 50.95,164.95 50.49,164.95 44.86,159.32 43.23,159.32 38.76,154.84 37.35,153.96 31.11,153.96 29.86,154.44 29.33,154.98 29.33,157.28 v6(29.1,157.5)
CKED1: length 31.9
  TOP w0.13: VRAMD2.J3 v6(52,147.1) ; GPU1.AP14 61.75,168.55 v6(61.6,168.55)
  BOTTOM w0.089: v6(61.6,168.55) 61.2,168.15 61.2,166.97 61,166.77 61,165.29 60.9,165.19
  BOTTOM w0.13: 60.9,165.19 60.63,164.92 60.27,164.92 59.35,164 59.05,164 58.15,163.1 57.3,163.1 49.68,155.48 49.68,155.34 48.48,154.14 48.48,148.29 49.45,147.32 51.78,147.32 v6(52,147.1)
CLEAN_CMOS_EC: length 4.8
  TOP w0.114: KBC1.122 106.45,62.03 106.86,62.44 v3(106.86,63.02) 106.71,63.17 R2771.2 104.57,63.17 R2772.2
CLK_100M: length 4.5
  TOP w0.114: R563.2 92.08,155.45 v3(92.35,155.17) 92.58,154.94 94.55,154.94 R561.2
CLK_100M_R: length 2.6
  TOP w0.114: R561.1 95.95,153.99 96.63,153.31 U29.4
CLK_100M_VDD: length 6.4
  TOP w0.203: U29.1 99.04,152.07
  TOP w0.508: 99.04,152.07 99.04,151.31 99.03,151.3 v3(99.03,151.16) 99.03,150.89 98.45,150.3 L28.2 99.54,150.02 C638.1 C639.1 101.77,149.98 C2526.1
CLK_100M_XIN: length 6.5
  TOP w0.114: X99.3 103.54,152.81 101.8,152.81 C640.1 100.69,152.53 v3(100.51,152.35) 100.05,152.35 99.49,152.91 U29.2
CLK_100M_XOUT: length 4.6
  TOP w0.114: U29.3 99.64,153.31 100.2,153.87 v3(100.53,153.87) 100.81,153.59 C641.1 102.68,153.59 X99.1
CLK_REQ0: length 6.7
  TOP w0.114: CPU1.AT23 154,160 v6(153.55,160.45)
  BOTTOM w0.114: v6(153.55,160.45) 153.8,160.45 154.05,160.2 v2(154.05,159.77) 153.92,159.64 152.93,159.64 152.39,159.1 150.83,159.1 150.5,159.44 150.16,159.44 149.91,159.69 149.52,159.69 RN2404.4
CLK_REQ1: length 4.6
  TOP w0.114: v6(151.51,159.51) 152,159.02 CPU1.AV24
  BOTTOM w0.114: v2(149.52,161.87) RN2404.3 150.68,160.35 v6(151.51,159.51)
CLK_REQ2: length 120.9
  TOP w0.114: CPU1.AT24 154.45,158.55 154.45,158.54 v6(154.54,158.45) ; R2745.1 109.38,103.05 v1(109.02,103.05)
  L4 w0.114: v6(154.54,158.45) 153.99,159 153.24,159 152.63,158.39 149.02,158.39 148.13,157.51 148.13,156.05 147.37,155.29 147.37,154.53 146.6,153.76 146.6,117.28 145.93,116.62 145.93,99.88 145.97,99.84 145.97,99.45 145.93,99.41 145.93,94.49 v1(144.96,93.53)
  BOTTOM w0.114: v2(152.48,156.54) 152.34,156.68 RN2405.4 152.79,157.59 153.19,157.99 153.99,157.99 154.45,158.45 v6(154.54,158.45) ; v1(109.02,103.05) 109.02,103.61 109.98,104.57 123.45,104.57 123.7,104.32 128.85,99.17 128.85,96.8 131.56,94.09 135.39,94.09 135.61,93.87 144.63,93.87 v1(144.96,93.53)
CLK_REQG_L: length 81.6
  TOP w0.114: R496.2 95.39,166.87 R494.2 99.77,166.75 100.59,165.93 104.16,165.93 105.43,167.2 113.28,167.2 v1(114.65,165.83) ; v6(154.49,161.47) 154.96,161 CPU1.AR22
  L3 w0.114: v6(154.49,161.47) 154.05,161.03 154.05,160.37 153.7,160.02 151.05,160.02 150.72,160.35 150.14,160.35 149.48,159.69 148.06,159.69 141.57,153.2 140.75,153.2 140.04,152.49 140.04,151.14 140.54,150.65 v1(140.72,150.65)
  BOTTOM w0.114: R70.1 151.69,161.88 153.81,161.88 154.23,161.47 v6(154.49,161.47) ; v1(114.65,165.83) 115.56,164.92 124.87,164.92 v2(126.21,163.58) 132.79,157 132.79,155.68 133.32,155.15 133.32,154.33 134.37,153.29 134.37,151.64 135.24,150.77 136.93,150.77 137.15,150.98 138.86,150.98 139.19,150.65 v1(140.72,150.65)
CLKA0: length 37.7
  TOP w0.122: v6(79.94,183.61) 79.94,183.54 GPU1.W32 ; v6(102.9,190.8) VRAMA1.J12
  BOTTOM w0.122: v6(79.94,183.61) 80.11,183.11 80.12,183.11 80.39,182.83 86.03,182.83 86.21,183.01 86.21,183.01 86.59,183.4 88.38,183.4 88.87,183.89 93.1,183.89 93.8,184.59 94.04,184.83 94.96,184.83 95.45,184.33 96.07,184.33 96.72,184.98 97.1,184.98 97.26,184.82 97.26,184.38 97.57,184.07 98.22,184.07 98.48,184.33 98.48,184.78 98.68,184.98 99.06,184.98 99.21,184.83 99.21,184.35 99.49,184.07 100.16,184.07 101.06,184.96 101.48,184.96 101.95,185.44 101.95,188.08 101.98,188.11 101.98,189.46 102.59,190.07 102.59,190.07 102.68,190.16 v6(102.9,190.8) 103.08,190.8 103.37,191.09 104.03,191.75 104.03,192.26 104.04,192.26 104.04,192.56 104.47,193 105.02,193 105.52,193.5 R674.1
CLKA0B: length 37.2
  TOP w0.122: v6(80.76,183.59) 80.76,183.51 80.25,183 GPU1.W33 ; VRAMA1.J11 v6(102.1,190.8)
  BOTTOM w0.1: 103.2,191.27 103.14,191.21 102.51,191.21 v6(102.1,190.8)
  BOTTOM w0.122: v6(80.76,183.59) 80.49,183.59 80.37,183.47 80.37,183.21 80.5,183.08 85.93,183.08 85.96,183.11 85.96,183.12 86.49,183.65 88.28,183.65 88.77,184.14 92.99,184.14 93.93,185.08 94.14,185.08 95.06,185.08 95.55,184.58 95.97,184.58 96.61,185.23 97.21,185.23 97.51,184.93 97.51,184.48 97.67,184.32 98.11,184.32 98.23,184.44 98.23,184.89 98.58,185.23 99.16,185.23 99.46,184.94 99.46,184.46 99.6,184.32 100.06,184.32 100.95,185.21 101.37,185.21 101.7,185.54 101.7,188.19 101.73,188.21 101.73,189.56 102.46,190.3 102.46,190.67 102.34,190.8 v6(102.1,190.8) ; 103.2,191.27 103.2,191.27 103.78,191.86 103.78,192.66 104.53,193.41 R673.1
CLKA1: length 44.8
  TOP w0.122: v6(77.2,189.85) 76.85,189.85 76.6,189.6 GPU1.M29 ; v6(85.3,220.1) 85.3,220.31 85.11,220.5 VRAMA2.J12
  BOTTOM w0.1: 85.7,221.1 85.7,220.5
  BOTTOM w0.122: v6(77.2,189.85) 77.58,190.23 77.71,190.23 77.95,190.47 77.95,196.84 77.29,197.5 77.29,199.19 77.3,199.19 77.3,199.74 77.28,199.76 77.28,206.46 81.18,210.37 82.62,210.37 82.97,210.72 82.97,211.3 82.68,211.59 81.38,211.59 80.65,212.32 80.65,217.83 82.06,219.24 82.56,219.74 84.18,219.74 84.71,220.27 85.13,220.27 v6(85.3,220.1) 85.7,220.5 ; 85.7,221.1 85.7,221.15 86.35,221.8 87.25,221.8 87.8,222.35 R675.1
CLKA1B: length 44.6
  TOP w0.122: VRAMA2.J11 v6(85.29,220.9) ; GPU1.L29 v6(77.2,190.65)
  BOTTOM w0.122: v6(77.2,190.65) 77.37,190.48 77.61,190.48 77.7,190.57 77.7,196.74 77.04,197.4 77.04,199.29 77.05,199.29 77.05,199.64 77.03,199.66 77.03,205.57 77.03,205.57 77.03,206.57 81.08,210.62 82.52,210.62 82.72,210.83 82.72,211.2 82.58,211.34 81.28,211.34 80.4,212.22 80.4,217.93 81.88,219.42 82.45,219.99 84.07,219.99 84.61,220.52 v6(85.29,220.9) 85.29,220.97 85.3,220.98 85.3,221.1 85.45,221.25 86.25,222.05 87.14,222.05 87.38,222.29 87.38,222.77 R672.1
CLKB0: length 43.7
  TOP w0.122: VRAMB1.J12 73.2,220.13 v6(73.2,220.1) ; GPU1.P26 v6(74.78,188.34)
  BOTTOM w0.089: 72.53,221.4 72.8,221.13 72.8,220.73 73.2,220.33 v6(73.2,220.1) ; 74.56,199.13 74.56,199.09 74.54,199.06 74.25,197.64 74.05,196.62 74.05,188.77 74.3,188.52 74.59,188.52 v6(74.78,188.34)
  BOTTOM w0.122: v6(73.2,220.1) 73.49,220.39 73.78,220.39 74.39,219.78 76.51,219.78 78.08,218.21 78.08,217.85 77.95,217.72 77.95,217.36 78.08,217.23 78.08,216.86 77.95,216.74 77.95,216.37 78.08,216.25 78.08,215.88 77.95,215.76 77.95,215.39 78.08,215.27 78.08,211.67 74.56,208.16 74.56,199.13 ; R633.1 70.62,222.5 70.66,222.5 71.37,221.78 72.14,221.78 72.53,221.4
CLKB0B: length 43.5
  TOP w0.122: v6(74.8,189.05) GPU1.N26 ; VRAMB1.J11 73.2,220.93 v6(73.2,220.94)
  BOTTOM w0.089: 74.81,199.07 74.71,198.96 74.44,197.61 74.24,196.6 74.24,188.94 74.4,188.77 74.53,188.77 v6(74.8,189.05)
  BOTTOM w0.122: R632.1 71,223.15 71,222.51 71.48,222.03 72.25,222.03 72.41,221.87 72.46,221.82 73.2,221.08 73.2,220.94 v6(73.2,220.94) 73.85,220.67 73.86,220.67 74.49,220.03 75.35,220.03 76.62,220.03 78.33,218.32 78.33,211.57 74.81,208.06 74.81,199.07
CLKB1: length 44.1
  TOP w0.122: VRAMB2.J12 v6(48.3,220.9) ; GPU1.H14 61.75,193.05 v6(61.6,193.05)
  BOTTOM w0.122: v6(61.6,193.05) 61.4,193.05 60.9,193.55 60.9,196.93 43.52,214.3 43.52,218.45 45.07,220 47.24,220 48.14,220.9 v6(48.3,220.9) 48.3,221.1 49.25,222.05 50.09,222.05 50.38,222.33 50.38,222.72 R630.1
CLKB1B: length 43.7
  TOP w0.122: v6(48.29,220.14) 48.3,220.15 48.35,220.15 VRAMB2.J11 ; v6(61.6,193.85) 61.75,193.85 GPU1.G14
  BOTTOM w0.122: v6(61.6,193.85) 61.6,193.7 61.44,193.54 61.27,193.54 61.15,193.65 61.15,197.03 60.4,197.78 49.55,208.63 49.55,208.82 49.29,209.07 49.11,209.07 48.85,209.33 48.85,209.51 48.59,209.77 48.41,209.77 48.15,210.03 48.15,210.21 47.89,210.47 47.71,210.47 47.45,210.73 47.45,210.91 47.19,211.17 47.01,211.17 46.75,211.43 46.75,211.61 46.49,211.87 46.31,211.87 46.05,212.13 46.05,212.31 45.8,212.57 45.61,212.57 43.77,214.41 43.77,218.35 45.17,219.75 47.34,219.75 47.73,220.14 48.28,220.14 48.28,220.14 v6(48.29,220.14) 48.3,220.15 48.35,220.15 48.72,220.52 48.72,221.16 49.35,221.8 50.2,221.8 50.38,221.98 50.66,221.98 R631.1
CLKC0: length 44.2
  TOP w0.122: VRAMC1.J12 v6(29.1,201.7) ; GPU1.P8 56.95,188.25 v6(56.95,188.4)
  BOTTOM w0.122: v6(56.95,188.4) 56.95,188.6 56.71,188.84 56.45,189.1 53.07,189.1 35.7,206.48 31.52,206.48 30.52,205.47 30.52,205.02 30,204.5 30,202.76 29.1,201.86 v6(29.1,201.7) 28.9,201.7 27.95,200.75 27.95,199.9 27.82,199.77 27.67,199.62 27.23,199.62 27.11,199.51 27.04,199.51 R676.1
CLKC0B: length 43.7
  TOP w0.122: VRAMC1.J11 v6(29.9,201.7) ; v6(56.15,188.4) 56.15,188.25 GPU1.P7
  BOTTOM w0.089: 28.4,200.69 28.4,200.84 28.85,201.29 28.92,201.29 28.93,201.3 29.44,201.3 29.84,201.7 v6(29.9,201.7)
  BOTTOM w0.122: v6(29.9,201.7) 29.68,201.92 29.68,202.09 30.25,202.66 30.25,204.4 30.77,204.92 30.77,205.37 31.63,206.23 35.59,206.23 39.12,202.69 39.12,202.52 39.38,202.26 39.56,202.26 39.82,202 39.82,201.82 40.08,201.56 40.25,201.56 40.51,201.31 40.51,201.13 40.77,200.87 40.95,200.87 44.54,197.28 44.54,197.1 44.8,196.84 44.98,196.84 52.97,188.85 54.2,188.85 54.2,188.85 56.35,188.85 56.46,188.73 56.46,188.52 56.35,188.4 v6(56.15,188.4) ; 28.4,200.69 28.2,200.49 28.2,199.8 27.99,199.59 27.99,199.52 27.69,199.21 R677.1
CLKC1: length 43.3
  TOP w0.122: GPU1.AF14 61.75,175.35 v6(61.75,175.2) ; v6(29.9,176.8) VRAMC2.J12
  BOTTOM w0.089: 28.42,177.65 28.87,177.2 29.27,177.2 29.28,177.19 29.51,177.19 29.9,176.81 v6(29.9,176.8)
  BOTTOM w0.122: R705.1 27.69,179.32 27.69,179.19 28.22,178.66 28.22,177.86 28.42,177.65 ; v6(61.75,175.2) 61.48,175.47 61.48,175.71 61.23,175.95 52.5,175.95 50.84,175.44 42.62,175.44 42.36,175.18 42.19,175.18 41.93,174.92 41.93,174.74 41.67,174.48 41.49,174.48 41.23,174.22 41.23,174.05 40.97,173.79 40.8,173.79 40.54,173.53 40.54,173.35 39.52,172.34 31.39,172.34 30.22,173.5 30.22,175.77 29.64,176.35 29.64,176.54 29.9,176.8 v6(29.9,176.8)
CLKC1B: length 43.1
  TOP w0.122: VRAMC2.J11 v6(29.1,176.8) ; GPU1.AF13 v6(60.95,175.2)
  BOTTOM w0.122: v6(60.95,175.2) 61.22,175.47 61.23,175.47 61.23,175.6 61.13,175.7 52.53,175.7 52.41,175.66 51.74,175.45 50.88,175.19 42.72,175.19 39.63,172.09 31.28,172.09 29.97,173.4 29.97,175.67 29.39,176.25 29.39,176.51 v6(29.1,176.8) 28.92,176.8 27.97,177.75 27.97,178.56 27.53,179 26.98,179 26.77,179.22 26.77,179.25 26.44,179.58 R706.1
CLKD0: length 45.3
  TOP w0.122: v6(60.15,172.8) 60.15,173.18 60.37,173.4 GPU1.AJ12 ; VRAMD1.J12 v6(29.9,164.7)
  BOTTOM w0.089: v6(29.9,164.7) 29.89,164.7 29.49,164.3 28.85,164.3
  BOTTOM w0.122: 28.85,164.3 28.2,163.65 28.2,162.84 27.33,161.97 R629.1 ; v6(60.15,172.8) 59.98,172.8 59.23,172.05 54.35,172.05 52.04,172.67 43.48,172.67 39.63,168.82 39.63,167.38 39.28,167.03 38.7,167.03 38.41,167.32 38.41,168.66 37.71,169.35 31.03,169.35 30.76,169.08 30.76,167.94 30.25,167.43 30.25,165.58 29.9,165.23 29.9,164.7 v6(29.9,164.7)
CLKD0B: length 45.2
  TOP w0.122: GPU1.AJ11 v6(59.35,172.8) ; VRAMD1.J11 v6(29.1,164.7)
  BOTTOM w0.122: R628.1 27.1,162.53 27.54,162.53 27.95,162.94 27.95,163.75 28.9,164.7 v6(29.1,164.7) 29.1,164.79 30,165.69 30,167.53 30.51,168.04 30.51,169.18 30.93,169.6 37.82,169.6 38.66,168.76 38.66,167.42 38.8,167.28 39.17,167.28 39.38,167.48 39.38,168.92 43.38,172.92 52.07,172.92 54.38,172.3 59.12,172.3 59.35,172.53 v6(59.35,172.8)
CLKD1: length 36.4
  TOP w0.122: GPU1.AM19 v6(66.4,170.15) ; VRAMD2.J12 v6(59.2,147.1)
  BOTTOM w0.122: v6(66.4,170.15) 67.1,169.55 67.1,162.3 66.42,161.62 66.42,154.69 65.02,153.28 65.02,152.9 65.18,152.74 65.57,152.74 65.85,152.45 65.85,151.78 65.59,151.52 65.22,151.52 65.02,151.32 65.02,150.94 65.73,150.23 65.73,149.63 64.11,148.01 60.4,148.01 59.69,147.3 59.4,147.3 v6(59.2,147.1) 59.2,146.92 58.25,145.97 57.73,145.97 57.73,145.96 57.44,145.96 57,145.53 57,144.98 56.42,144.4 R661.1
CLKD1B: length 35.8
  TOP w0.122: GPU1.AN19 66.55,169.35 v6(66.4,169.35) ; v6(59.19,147.9) 59.19,147.89 VRAMD2.J11
  BOTTOM w0.089: 58.49,146.56 58.8,146.87 58.8,147.4 59,147.6 59,147.72 v6(59.19,147.9)
  BOTTOM w0.122: v6(66.4,169.35) 66.54,169.49 66.72,169.49 66.85,169.37 66.85,162.4 66.17,161.72 66.17,160.27 66.05,160.15 66.05,159.78 66.17,159.65 66.17,159.29 66.05,159.16 66.05,158.8 66.17,158.67 66.17,158.31 66.05,158.18 66.05,157.81 66.17,157.69 66.17,154.79 64.77,153.39 64.77,152.79 64.92,152.64 65.07,152.49 65.46,152.49 65.6,152.35 65.6,151.89 65.48,151.77 65.11,151.77 64.77,151.42 64.77,150.84 65.48,150.12 65.48,149.73 64.01,148.26 60.3,148.26 59.59,147.55 59.31,147.55 59.19,147.68 v6(59.19,147.9) ; 58.49,146.56 58.14,146.22 57.63,146.22 57.62,146.21 57.33,146.21 56.75,145.63 56.75,145.62 56.63,145.5 56.54,145.41 R662.1
CMOS_EC_R: length 39.1
  TOP w0.114: R2771.1 106.35,64.05 v1(106.55,64.26) 107.75,64.26 v3(107.92,64.08) ; R2770.1 130.27,51.91 129.54,51.18 127.91,51.18 126.39,49.66 JMP1.5 125.58,50.14 125.58,51.03 124.84,51.76 124.84,52.32 v1(124.76,52.4)
  L3 w0.114: v1(106.55,64.26) 107.11,63.7 109.96,63.7 110.59,64.34 113.51,64.34 114.65,63.19 114.65,62.54 115.44,61.76 119.09,61.76 120.25,60.6 122.15,60.6 124.94,57.81 124.94,54.31 125.12,54.13 125.12,52.76 v1(124.76,52.4)
CORETYPE0: length 161.9
  TOP w0.114: v1(128,112.27) 127.57,111.84 Q86.5 125.32,111.67 125,111.67 124.79,111.47 124.79,107.85 127.76,104.88 127.76,103.91 128.88,102.79 128.88,102.73 v1(129.92,101.7) ; KBC1.91 114.93,57.34 v1(114.63,57.05) ; CPU1.AM24 158.45,159 158.84,159.39 159.53,159.39 v6(160.35,158.57)
  L3 w0.114: v1(137.59,142.67) 137.59,142.43 133.22,138.07 133.22,132.94 133.28,132.88 133.28,131.25 v1(132.03,130)
  L4 w0.114: v1(107.21,88.77) 107.21,88.57 104.74,86.1 104.74,82.56 105.58,81.73 105.58,80.78 101.35,76.55 101.35,72.86 102.18,72.02 102.18,68.82 103.16,67.84 103.16,66.34 108.04,61.46 110.66,61.46 114.63,57.49 v1(114.63,57.05)
  L6 w0.102: v1(129.92,101.7) 128.22,101.7 122.62,96.09 122.12,96.09 116.77,90.73 109.17,90.73 v1(107.21,88.77)
  BOTTOM w0.114: v1(132.03,130) 132.03,128.86 129.13,125.96 128.76,125.96 128.29,125.5 128.29,125.12 128.29,116.82 128.52,116.59 128.52,112.8 v1(128,112.27) ; v1(137.59,142.67) 137.47,142.79 137.47,144.2 137.8,144.53 137.8,144.63 138.35,145.18 141.12,145.18 145.03,149.1 145.03,152.93 145.97,153.87 145.97,153.88 147.61,155.52 R1235.2 148.24,156.57 150.56,156.57 151.81,155.32 v2(151.82,155.32) 151.87,155.27 152.7,155.27 153.77,156.34 156.54,156.34 157.18,156.97 157.57,156.97 157.99,157.39 157.99,157.53 158.51,158.05 159.84,158.05 v6(160.35,158.57)
CORETYPE1: length 345.3
  TOP w0.114: CPU1.AN9 v6(156.5,174.5) ; v1(104.88,58.45) 104.88,57.81 104.61,57.54 104,57.54 103.94,57.48 103.45,57.48 103.31,57.34 KBC1.6 ; v1(134.44,141.25) 133.73,140.54 128.84,140.54 125.78,137.48 125.64,137.34 124.44,137.34 122.43,135.33 122.43,132.72 122.71,132.43 Q83.G ; R1233.2 207.68,155.07 v3(208.76,156.16) 209.88,157.28 v1(209.88,158.32) ; R2747.2 141.05,214.81 v1(141.07,214.83)
  L3 w0.114: v6(156.5,174.5) 156.02,174.98 155.32,174.98 154.43,174.09 150.35,174.09 149.97,174.47 148.72,174.47 147.3,173.06 147.3,170.22 141.83,164.75 139.49,164.75 139.04,164.3 138.28,163.55 138.08,163.35 136.86,163.35 135.59,164.62 134.9,164.62 133.22,162.93 133.22,159.93 133.64,159.51 133.64,158.22 132.79,157.37 132.79,156.62 131.83,155.65 131.83,151.89 132.38,151.33 132.38,144.3 134.44,142.24 v1(134.44,141.25) 134.44,141.11 131.89,138.55 131.89,131.86 131.13,131.1 131.13,121.13 130.19,120.2 130.19,110.49 129.11,109.41 129.11,101.7 v1(131.39,99.42)
  L4 w0.114: v1(104.88,58.45) 104.72,58.45 104.24,58.93 103,58.93 100.04,61.89 100.04,65.2 98.46,66.77 98.46,72.41 99.03,72.99 99.03,77.12 101.45,79.54 101.45,79.91 103.78,82.25 103.78,86.54 105.77,88.52 v1(105.82,88.52) ; v1(140.41,200.94) 140.41,200.53 139.93,200.04 139.93,198.41 141.99,196.36 141.99,192.61 139.93,190.55 139.93,190.19 v1(139.87,190.13)
  L6 w0.102: v1(209.88,158.32) 209.88,160.81 203.25,167.44 203.25,168.02 197.69,173.58 192.68,173.58 191.41,172.31 189.81,172.31 188.49,170.99 186.87,170.99 185.83,169.95 171.34,169.95 171.31,169.93 167.64,169.93 167.47,170.09 167.33,170.09 166.52,170.91 161.33,170.91 161.14,170.71 159.92,170.71 159.54,171.09 159.33,171.09 159.09,171.33 159.09,171.54 158.49,172.14 158.36,172.14 158.12,172.38 158.12,172.51 156.5,174.14 v6(156.5,174.5) 156.5,174.9 155.98,175.41 155.98,177.42 155.09,178.31 155.09,178.58 154.63,179.04 154.38,179.04 154.05,179.37 154.05,180.34 153.09,181.3 153.09,182.85 152.68,183.26 152.33,183.26 151.31,184.29 151.31,185.18 149.64,186.84 141.91,186.84 139.57,189.18 139.57,189.83 v1(139.87,190.13) ; v1(140.41,200.94) 137.31,204.04 137.31,211.86 138.84,213.39 139.63,213.39 139.98,213.74 139.98,213.75 v1(141.07,214.83) ; v1(105.82,88.52) 106.15,88.19 108.15,88.19 109.96,89.99 116.69,89.99 122.38,95.68 122.78,95.68 126.52,99.42 v1(131.39,99.42)
  BOTTOM w0.114: v1(209.88,158.32) 207.26,155.7 207.26,149.35 208.91,147.7 208.91,144.02 211.96,140.97 Q81.5 ; v1(141.07,214.83) 141.07,215.57 141.97,216.47 PC417.1 142.22,216.44 143.87,216.44 144.53,215.78 144.53,215.52 145.03,215.01 PU52.5
CPU_CORE_FB_N: length 53.3
  TOP w0.127: v1(211.46,207.9) 211.51,207.95 212.32,207.95 213.6,209.23 PR115.1 213.6,210.22 213.54,210.29 PR114.2
  BOTTOM w0.127: v1(211.46,207.9) 210.73,207.18 210.57,207.18 209.47,206.07 209.47,204.9 206.63,202.06 206.63,199.75 203.2,196.32 201.61,196.32 197.92,192.63 197.92,185.21 v2(198.27,184.85) 198.81,184.32 198.81,174.9 199.19,174.52 199.19,171.65 197.64,170.1 197.64,169.78 197.52,169.67 197.52,167.84 R31.1
CPU_CORE_FB_N_R: length 15.5
  TOP w0.127: CPU1.F15 v6(184.49,168.41)
  L3 w0.127: v1(192.94,168.86) 192.47,169.33 191.63,169.33 191.16,168.86 184.93,168.86 v6(184.49,168.41)
  BOTTOM w0.127: R31.2 195.77,166.05 v2(195.71,165.99) 194.51,165.99 194.32,166.18 194.06,166.18 193.79,166.45 193.79,167.64 192.94,168.49 v1(192.94,168.86)
CPU_CORE_FB_P: length 51.8
  BOTTOM w0.127: PR112.2 214.43,209.72 PR110.2 213.77,209.07 213.08,208.38 213.08,207.92 211.48,206.32 211.47,206.32 207.21,202.07 207.21,199.48 203.62,195.88 201.82,195.88 198.32,192.38 198.32,190.75 198.32,185.97 199.33,184.95 199.33,183.34 v2(199.34,183.33) 199.26,183.26 199.26,179.81 199.57,179.5 199.57,171.5 198.02,169.94 198.02,169.63 197.9,169.51 197.9,167.48 R29.1
CPU_CORE_FB_P_R: length 19.2
  TOP w0.127: CPU1.F14 v6(183.5,168.4)
  L3 w0.127: v6(183.5,168.4) 183.8,168.4 184.53,169.14 189.92,169.14 190.5,169.72 192.74,169.72 193.72,168.74 194.09,168.74 197.1,165.73 v1(197.1,165.72)
  BOTTOM w0.127: v1(197.1,165.72) 197.63,166.24 v2(197.87,166.24) 198.48,166.86 198.61,166.86 198.95,167.2 R29.2
CPU_FAN_CTRL_SIO: length 220.2
  TOP w0.114: v1(94.56,50.77) 94.34,51 94.03,51 93.75,51.28 85.14,51.28 v1(83.95,52.48) ; v1(12.19,166.24) 12.76,166.81 R253.1 ; KBC1.81 116.06,53.34 115.8,53.6 109.79,53.6 109.73,53.54 109.14,53.54 108.27,52.67 v1(108.27,51.79)
  L3 w0.114: v1(94.56,50.77) 94.66,50.87 94.66,51.04 95.09,51.47 98.16,51.47 98.26,51.57 108.05,51.57 v1(108.27,51.79)
  L6 w0.102: v1(83.95,52.48) 83.66,52.48 80.39,55.74 80.39,104.11 79.07,105.44 26.09,105.44 23.65,107.87 18.61,107.87 13.87,112.61 13.87,113.21 7.65,119.43 7.65,157.93 10.08,160.37 10.08,164.13 v1(12.19,166.24)
  BOTTOM w0.114: v2(94.56,49.86) v1(94.56,50.77)
