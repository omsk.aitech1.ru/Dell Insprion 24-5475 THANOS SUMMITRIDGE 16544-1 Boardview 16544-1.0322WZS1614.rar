# Allegro board 16544-1.0322WZS1614.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAD0_5: length 39.1
  TOP w0.13: v6(59.35,171.6) 59.35,171.75 GPU1.AK11 ; v6(30.72,163.02) 30.72,163.08 VRAMD1.K10
  BOTTOM w0.089: 51.74,170.71 51.83,170.8 58.55,170.8 v6(59.35,171.6)
  BOTTOM w0.13: 51.74,170.71 47.57,170.71 47.47,170.61 47.47,170.12 47.36,170 46.91,170 46.81,170.1 46.81,170.56 46.71,170.66 46.32,170.66 46.2,170.55 46.2,169.95 46.1,169.85 45.7,169.85 45.03,170.52 44.84,170.52 44.57,170.25 44.57,170.06 44.8,169.83 44.8,169.65 44.52,169.37 44.34,169.37 44.11,169.6 43.92,169.6 43.65,169.33 43.65,169.14 43.88,168.91 43.88,168.73 43.6,168.45 43.42,168.45 43.19,168.68 43,168.68 42.73,168.41 42.73,168.22 42.96,167.99 42.96,167.81 39.59,164.44 39.14,164.44 38.63,164.95 37.43,164.95 37.13,164.65 37.13,163.68 36.39,162.94 30.8,162.94 v6(30.72,163.02)
MAD0_6: length 39
  TOP w0.13: v6(30.76,160) 30.76,159.96 VRAMD1.K5 ; GPU1.AR8 57.75,168.25 v6(57.75,168)
  BOTTOM w0.089: 53.73,167.58 57.13,167.58 57.55,168 v6(57.75,168)
  BOTTOM w0.13: v6(30.76,160) 30.78,160.02 36.73,160.02 37.28,159.47 37.28,158.26 38.31,157.23 38.5,157.23 38.76,157.49 38.76,157.72 37.9,158.58 37.9,158.77 38.09,158.96 38.27,158.96 39.11,158.12 39.31,158.12 39.5,158.3 39.5,158.49 39.01,158.97 39.01,159.15 39.19,159.33 39.4,159.33 39.91,158.82 40.09,158.82 42.68,161.42 43.5,161.42 49.22,167.13 53.27,167.13 53.73,167.58
MAD0_7: length 39
  TOP w0.13: GPU1.AN11 v6(59.35,169.35) ; VRAMD1.K4 v6(29.9,159.1)
  BOTTOM w0.089: v6(59.35,169.35) 58.54,168.54 57.37,168.54 57.23,168.4 52.45,168.4 52.22,168.17
  BOTTOM w0.13: 52.22,168.17 51.56,167.51 48.89,167.51 44.1,162.72 43.28,162.72 40.13,159.57 39.93,159.57 39.79,159.71 39.79,160.19 39.66,160.32 39.39,160.32 39.26,160.19 39.26,159.96 39.13,159.83 38.86,159.83 38.73,159.96 38.73,160.19 38.6,160.32 38.33,160.32 38.2,160.19 38.2,159.64 38.09,159.53 37.89,159.53 37.55,159.87 37.55,160.12 37.24,160.44 30.56,160.44 30.32,160.2 30.32,159.75 30.6,159.47 30.6,159 30.43,158.82 30.18,158.82 v6(29.9,159.1)
MAD0_8: length 38.8
  TOP w0.13: v6(57.75,169.2) 57.75,169.35 GPU1.AN9 ; v6(29.86,160) 29.86,159.86 VRAMD1.J5
  BOTTOM w0.089: v6(57.75,169.2) 57.15,168.6 51.8,168.6 51.52,168.32
  BOTTOM w0.13: 51.52,168.32 51.3,168.1 48.77,168.1 45.51,164.84 45.33,164.84 45.25,164.92 45.07,164.92 44.88,164.73 44.88,164.54 44.95,164.47 44.95,164.28 44.69,164.02 44.34,164.02 44.21,164.15 44.03,164.15 43.84,163.96 43.84,163.78 43.96,163.65 43.96,163.46 43.85,163.35 43.2,163.35 42.84,162.98 42.65,162.98 42.27,163.36 42.09,163.36 41.89,163.17 41.89,162.99 42.28,162.61 42.28,162.42 42.09,162.23 41.9,162.23 41.52,162.62 41.34,162.62 41.14,162.42 41.14,162.24 41.53,161.86 41.53,161.67 41.34,161.48 41.15,161.48 40.77,161.87 40.59,161.87 40.39,161.67 40.39,161.49 40.78,161.11 40.78,160.92 40.4,160.55 40.22,160.55 39.95,160.82 37.5,160.82 37.38,160.94 30.04,160.94 29.86,160.76 v6(29.86,160)
MAD1_0: length 30.8
  TOP w0.13: VRAMD2.K4 v6(53.6,147.1) ; v6(64,170.15) 64.15,170.15 GPU1.AM17
  BOTTOM w0.089: 63.14,161.65 63.14,162.03 63.4,162.28 63.4,163.12 63.41,163.13 63.41,163.31 63.4,163.32 63.4,169.6 63.95,170.15 v6(64,170.15)
  BOTTOM w0.13: v6(53.6,147.1) 54.03,147.53 55.23,147.53 55.7,148 55.7,155.24 55.55,155.4 55.55,156.08 56.5,157.03 56.5,157.03 56.83,157.37 56.84,157.37 57.13,157.66 58.74,159.27 60.77,159.27 63.14,161.65
MAD1_1: length 29.5
  TOP w0.13: GPU1.AP17 64.45,169 v6(64,168.55) ; VRAMD2.K5 54.36,147.06 v6(54.48,147.06)
  BOTTOM w0.089: 62.9,160.46 62.9,160.78 63.6,161.48 63.6,168.15 v6(64,168.55)
  BOTTOM w0.13: v6(54.48,147.06) 54.48,147.06 55.88,147.06 55.98,146.96 56.14,146.96 56.33,147.15 56.33,147.36 56,147.69 56,147.88 56.2,148.08 56.2,155.92 59.18,158.9 61.34,158.9 62.9,160.46
MAD1_2: length 30.4
  TOP w0.13: v6(65.2,170.95) 65.35,170.95 GPU1.AL18 ; VRAMD2.K11 v6(58.4,147.1)
  BOTTOM w0.089: v6(65.2,170.95) 65.15,170.95 64.6,170.4 64.6,164.84 64.59,164.84 64.59,164.81 64.35,164.57
  BOTTOM w0.13: 64.35,164.57 64.35,160.15 61.76,157.56 60.03,157.56 57.08,154.61 57.08,148.65 57.34,148.38 57.82,148.38 58.4,147.8 v6(58.4,147.1)
MAD1_3: length 29.8
  TOP w0.13: GPU1.AR17 64.45,168.2 v6(64,167.75) ; VRAMD2.K10 57.67,147.03 v6(57.56,147.03)
  BOTTOM w0.089: v6(64,167.75) 64.4,167.35 64.4,165.1 63.98,164.68
  BOTTOM w0.13: v6(57.56,147.03) 57.41,146.87 57.15,146.87 56.85,147.17 56.85,147.93 56.7,148.07 56.7,155.03 56.83,155.16 56.97,155.16 57.09,155.28 57.09,155.51 56.81,155.79 56.81,155.93 57.02,156.14 57.23,156.14 57.49,155.88 57.7,155.88 57.86,156.04 57.86,156.26 57.64,156.48 57.64,156.66 57.83,156.84 58.03,156.84 58.22,156.65 58.41,156.65 58.62,156.86 58.62,157 58.34,157.28 58.34,157.46 58.52,157.64 59.36,157.64 59.82,158.09 61.49,158.09 63.98,160.58 63.98,164.68
MAD1_4: length 29.9
  TOP w0.13: GPU1.AT18 65.65,167.4 v6(65.2,166.95) ; v6(58.4,148.7) VRAMD2.H11
  BOTTOM w0.089: 65.2,161.96 65.66,162.42 65.66,166.49 v6(65.2,166.95)
  BOTTOM w0.13: v6(58.4,148.7) 57.84,149.26 57.84,153.76 58.05,153.97 58.82,153.97 59.06,154.22 59.06,154.96 59.45,155.35 60.38,155.35 60.51,155.22 60.51,155.01 60.63,154.88 61.01,154.88 61.18,155.06 61.18,155.51 61.31,155.64 62.76,155.64 62.98,155.86 62.98,156.05 62.62,156.41 62.62,156.6 62.81,156.79 62.99,156.79 63.36,156.42 63.54,156.42 63.73,156.61 63.73,156.8 63.22,157.31 63.22,157.5 63.4,157.68 63.6,157.68 64.11,157.17 64.29,157.17 64.48,157.36 64.48,157.55 64.12,157.91 64.12,158.1 64.31,158.29 64.49,158.29 64.58,158.2 64.8,158.2 64.9,158.3 64.9,159 65.2,159.3 65.2,161.96
MAD1_5: length 29.8
  TOP w0.13: v6(57.53,148.83) 57.53,148.77 VRAMD2.H10 ; GPU1.AN18 65.35,169.35 v6(65.2,169.35)
  BOTTOM w0.089: 64.78,164.51 64.78,164.76 64.8,164.77 64.8,168.95 v6(65.2,169.35)
  BOTTOM w0.13: 64.78,164.51 64.76,164.49 64.76,159.75 61.98,156.97 61.98,156.27 61.85,156.14 61.58,156.14 61.45,156.27 61.45,156.93 61.32,157.06 61.05,157.06 60.92,156.93 60.92,155.99 60.79,155.86 60.52,155.86 60.39,155.99 60.39,156.86 60.29,156.96 60.14,156.96 57.53,154.35 v6(57.53,148.83)
MAD1_6: length 30.3
  TOP w0.13: v6(62.8,169.35) 62.95,169.35 GPU1.AN15 ; VRAMD2.H5 54.45,148.75 v6(54.45,148.81)
  BOTTOM w0.089: v6(62.8,169.35) 62.2,168.75 62.2,163.4 62,163.2
  BOTTOM w0.13: 62,163.2 61.9,163.1 61.3,163.1 60.93,162.73 60.93,162.55 61.26,162.22 61.26,162.03 61.07,161.84 60.88,161.84 60.55,162.17 60.37,162.17 59.92,161.72 59.74,161.72 59.59,161.88 59.4,161.88 59.21,161.69 59.21,161.5 59.37,161.35 59.37,161.17 59.2,160.99 58.3,160.99 56.46,159.16 55.89,159.16 55.36,158.63 54.92,158.2 52.77,156.04 52.77,155.72 53.05,155.44 53.64,155.44 54.54,154.54 54.54,148.89 v6(54.45,148.81)
MAD1_7: length 29.7
  TOP w0.13: v6(62.8,167.75) 62.95,167.75 GPU1.AR15 ; v6(53.6,147.9) VRAMD2.H4
  BOTTOM w0.089: 62.4,163.09 62.4,167.6 62.55,167.75 v6(62.8,167.75)
  BOTTOM w0.13: v6(53.6,147.9) 54.08,148.38 54.63,148.38 54.9,148.65 54.9,154.85 53.98,155.78 53.98,156.54 54.43,156.99 54.61,156.99 54.74,156.87 54.92,156.87 55.1,157.04 55.1,157.25 54.99,157.36 54.99,157.54 55.12,157.67 55.67,157.67 55.8,157.8 55.8,158.37 56.09,158.66 56.71,158.66 58.12,160.07 60,160.07 60.5,160.57 60.5,160.75 60.19,161.06 60.19,161.24 60.38,161.43 60.57,161.43 60.87,161.13 61.05,161.13 62.38,162.46 62.38,163.08 62.4,163.09
MAD1_8: length 30.3
  TOP w0.13: GPU1.AL17 64.15,170.95 64.09,170.95 v6(64.03,170.89) ; VRAMD2.J5 54.45,147.95 v6(54.47,147.95)
  BOTTOM w0.089: v6(64.03,170.89) 63.94,170.89 63.2,170.15 63.2,162.72 62.74,162.26
  BOTTOM w0.13: 62.74,162.26 62.62,162.13 62.62,161.87 60.39,159.64 58.4,159.64 56.78,158.02 56.5,158.02 56.34,157.86 56.34,157.58 54.91,156.15 54.91,155.49 55.28,155.12 55.28,148.3 54.94,147.95 v6(54.47,147.95)
MAINPOWER_CONTROL: length 3.7
  TOP w0.114: R1202.2 107.05,203.06 106.44,203.67 R1198.2 106.89,204.09 107.08,203.89 v3(107.4,203.89) 108.43,203.89 R1196.1
MB_DM0: length 92
  TOP w0.114: v6(211.96,95.42) 212.81,94.56 212.81,93.06 212.81,93.06 212.81,92.78 212.62,92.6 DIMM2.12 ; CPU1.C21 v6(186.5,161.5)
  L6 w0.102: v6(186.5,161.5) 186.82,161.5 188.07,160.25 192.97,160.25 202.93,150.29 202.93,145.24 204.24,143.93 204.24,143.76 203.94,143.46 203.94,143.32 204.08,143.17 204.22,143.17 204.58,143.53 204.72,143.53 204.87,143.39 204.87,143.24 204.51,142.89 204.51,142.74 204.66,142.6 204.8,142.6 205.16,142.96 205.3,142.96 205.45,142.81 205.45,142.67 205.09,142.31 205.09,142.17 205.23,142.02 205.38,142.02 205.71,142.36 205.86,142.36 206,142.22 206,142.07 205.66,141.74 205.66,141.59 205.81,141.45 205.95,141.45 206.25,141.75 206.39,141.75 206.54,141.6 206.54,141.46 206.25,141.17 206.25,141.03 208.21,139.07 208.21,123.62 215.23,116.6 215.23,106.16 214.64,105.57 214.64,101.66 212.85,99.86 212.85,96.31 v6(211.96,95.42)
MB_DM1: length 80.3
  TOP w0.102: CPU1.D26 186.6,156.4 187.31,156.4 187.32,156.38 189.54,156.38 189.55,156.4 190.35,156.4 v6(190.63,156.12)
  TOP w0.114: v6(209.34,96.06) 208.92,96.06 207.37,97.6 DIMM2.33
  L6 w0.102: v6(190.63,156.12) 190.97,155.78 192.03,155.78 199.67,148.13 199.67,135.25 203.15,131.77 203.15,124.25 209.64,117.77 209.64,114.32 210.34,113.62 210.34,102.65 209.58,101.89 209.44,101.89 209.25,102.07 209.11,102.07 208.97,101.92 208.97,101.78 209.15,101.6 209.15,101.45 208.74,101.05 208.74,96.65 v6(209.34,96.06)
MB_DM2: length 70.7
  TOP w0.114: v6(203.8,94.6) 202.96,94.6 202.17,93.81 202.17,92.63 202.12,92.59 DIMM2.54 ; CPU1.A32 v6(189.5,150.5)
  L6 w0.102: v6(203.8,94.6) 202.62,95.78 202.62,104.91 204.59,106.88 204.59,107.08 204.59,107.19 204.49,107.29 204.27,107.29 204.17,107.39 204.17,107.59 204.27,107.69 204.49,107.69 204.59,107.8 204.59,113.61 204.59,114.12 204.49,114.22 204.17,114.22 204.07,114.33 204.07,114.53 204.17,114.63 204.49,114.63 204.59,114.73 204.59,114.94 204.49,115.04 203.76,115.04 203.61,115.19 203.61,118.05 198.29,123.36 198.29,129.75 195.44,132.61 195.44,145.57 190.51,150.5 v6(189.5,150.5)
MB_DM3: length 65.2
  TOP w0.114: CPU1.D37 186,145.61 186.13,145.47 187.43,145.47 187.55,145.34 187.55,144.79 187.68,144.66 187.68,143.72 187.54,143.58 187.54,142.64 v6(188.02,142.16) ; v6(196.3,96.82) 196.37,96.9 196.42,96.9 196.89,97.37 196.89,99.89 DIMM2.75
  L6 w0.102: v6(196.3,96.82) 196.3,97.04 195.89,97.45 195.89,107.46 196.01,107.58 196.01,117.79 190.38,123.42 190.38,125.11 190.48,125.21 191.03,125.21 191.13,125.31 191.13,125.52 191.03,125.62 190.48,125.62 190.38,125.72 190.38,125.92 190.48,126.02 191.03,126.02 191.13,126.13 191.13,127.69 189.51,129.31 189.51,133.94 188.41,135.04 188.41,137.47 188.51,137.58 189.41,137.58 189.51,137.68 189.51,137.88 189.41,137.98 188.51,137.98 188.41,138.08 188.41,138.29 188.51,138.39 189.41,138.39 189.51,138.49 189.51,138.69 189.41,138.8 188.51,138.8 188.41,138.9 188.41,139.1 188.51,139.2 189.1,139.2 189.2,139.3 189.2,139.51 189.1,139.61 188.51,139.61 188.41,139.71 188.41,141.77 v6(188.02,142.16)
MB_DM4: length 62.6
  TOP w0.114: CPU1.AL38 158.55,145.44 158.51,145.44 v6(158.47,145.48) ; DIMM2.178 169.12,92.55 168.41,93.27 v6(168.41,93.91)
  L6 w0.102: v6(168.41,93.91) 168.4,93.91 167.3,95.01 167.3,97.36 168.23,98.29 168.23,106.33 168.13,106.43 167.72,106.43 167.62,106.53 167.62,106.74 167.72,106.84 168.16,106.84 168.26,106.94 168.26,107.14 168.16,107.24 167.72,107.24 167.62,107.35 167.62,107.55 167.72,107.65 168.16,107.65 168.31,107.8 168.31,115.07 159.99,123.39 159.99,129.82 159.05,130.76 159.05,138.08 157.83,139.3 157.83,141.85 158.3,142.33 158.3,143.95 158.02,144.24 158.02,144.82 158.47,145.27 v6(158.47,145.48)
MB_DM5: length 61.5
  TOP w0.114: v6(156,142.65) 155,143.65 CPU1.AR39 ; v6(164.33,95.32) 163.85,95.8 163.85,99.87 DIMM2.199
  L6 w0.102: v6(156,142.65) 155.71,142.35 155.71,138.44 157.16,136.98 157.16,136.83 157.02,136.69 156.88,136.69 156.2,137.36 156.06,137.36 155.91,137.22 155.91,137.08 157.04,135.95 157.04,123.47 165.95,114.56 165.95,102.59 165.24,101.88 165.24,96.22 v6(164.33,95.32)
MB_DM6: length 70.2
  TOP w0.102: 151.64,148.61 153.39,148.61 CPU1.AT35
  TOP w0.114: DIMM2.220 158.62,93.6 v6(158.4,93.83) ; 151.64,148.61 151.6,148.56 149.74,148.56 149.59,148.72 148.65,148.72 148.2,148.26 v6(148.15,148.26)
  L6 w0.102: v6(158.4,93.83) 157.91,94.32 157.91,94.95 158.01,95.05 158.51,95.05 158.61,95.15 158.61,95.36 158.51,95.46 158.01,95.46 157.91,95.56 157.91,98.38 157.24,99.04 157.24,115.38 151.47,121.16 151.47,131.75 151.24,131.98 151.1,131.98 150.83,131.71 150.69,131.71 150.54,131.85 150.54,132 150.81,132.27 150.81,132.41 150.55,132.67 150.55,134.23 147.19,137.59 147.19,147.21 148.09,148.12 148.09,148.21 v6(148.15,148.26)
MB_DM7: length 78.6
  TOP w0.114: v6(153.95,96.33) 153.94,96.33 153.93,96.34 153.83,96.34 153.37,96.79 153.37,97.93 153.25,98.06 153.25,98.97 153.37,99.1 DIMM2.241 ; CPU1.AW29 150.92,154.08 150.46,154.08 v6(150.31,153.93)
  L6 w0.102: v6(150.31,153.93) 149.86,153.48 148.61,153.48 147.83,152.7 147.31,152.7 143.63,149.02 143.63,133.99 146.94,130.68 146.94,119.12 150.17,115.9 150.85,115.9 152.35,114.4 152.35,107.81 152.45,107.71 152.9,107.71 153,107.61 153,107.41 152.9,107.3 152.45,107.3 152.35,107.2 152.35,107 152.45,106.9 152.9,106.9 153,106.8 153,106.59 152.9,106.49 152.45,106.49 152.35,106.39 152.35,106.19 152.45,106.08 152.9,106.08 153,105.98 153,105.78 152.9,105.68 152.45,105.68 152.35,105.58 152.35,105.37 152.45,105.27 152.9,105.27 153,105.17 153,104.97 152.9,104.87 152.45,104.87 152.35,104.76 152.35,104.56 152.45,104.46 152.9,104.46 153,104.36 153,104.15 152.9,104.05 152.45,104.05 152.35,103.95 152.35,101.95 152.45,101.84 152.91,101.84 153.01,101.74 153.01,101.54 152.91,101.44 152.45,101.44 152.35,101.34 152.35,101.13 152.45,101.03 152.91,101.03 153.01,100.93 153.01,100.73 152.91,100.63 152.45,100.63 152.35,100.52 152.35,100.32 152.45,100.22 152.91,100.22 153.01,100.12 153.01,99.71 153.17,99.56 153.17,97.12 v6(153.95,96.33)
MB_ZV: length 3.5
  TOP w0.114: v6(170.51,147.53) 170,147.02 CPU1.Y36
  BOTTOM w0.114: v6(170.51,147.53) 170.51,147.5 v2(169.69,146.69) 168.66,145.65 R11.2
MB_ZVSS: length 16.8
  TOP w0.114: CPU1.AJ39 161.04,143.96 161.04,141.79 160.4,141.15 160.27,141.15 159.17,140.06 159.17,130.64 v3(160.02,129.79) 160.02,128.62 R13.2
ME_CNTL1: length 3
  TOP w0.114: R457.1 110.79,83.59 v3(111.25,84.05) 111.53,84.05 112.5,83.08 Q36.B
ME_UNLOCK: length 49.2
  TOP w0.114: KBC1.23 103.22,50.54 103.58,50.9 105.71,50.9 v1(106.86,52.04) ; v1(103.84,81.23) 105.04,82.44 108.57,82.44 109.09,81.91 v3(109.12,81.91) 109.89,81.14 R455.1 110.22,81.14 110.79,81.71 R457.2
  L4 w0.114: v1(103.84,81.23) 103.73,81.23 99.45,76.95 99.45,72.81 98.88,72.24 98.88,70.69 98.88,66.95 100.46,65.37 100.46,64.01 101.68,62.79 102.87,62.79 106.53,59.13 106.53,58.45 106.84,58.14 106.84,57.66 106.6,57.42 106.6,52.3 v1(106.86,52.04)
MEM_CALRA: length 52.6
  TOP w0.114: R610.1 93.48,203.91 93.12,203.56 v1(93.12,203.25) ; GPU1.Y31 79.05,182.25 v6(79.05,182.4)
  L6 w0.102: v6(79.05,182.4) 79.28,182.4 80.06,183.19 81.78,183.19 82.98,184.39 84.02,184.39 84.28,184.66 85.12,184.66 85.38,184.39 87.52,184.39 87.78,184.66 98.37,184.66 102.03,188.32 102.03,189.48 102.75,190.2 102.87,190.2 103.32,190.64 103.32,195.28 103.35,195.31 103.35,195.65 103.32,195.68 103.32,197.01 103.29,197.03 103.29,197.37 103.3,197.38 103.3,198.62 103.29,198.63 103.29,200.39 101.65,202.03 97.66,202.03 97.43,202.26 96.07,202.26 95.61,202.72 93.65,202.72 v1(93.12,203.25)
  BOTTOM w0.114: v2(93.12,202.29) v1(93.12,203.25)
MEM_CALRB: length 1.7
  TOP w0.114: v6(62.89,188.17) 63.26,187.8 GPU1.P15
  BOTTOM w0.114: R612.1 62.39,188.67 v6(62.89,188.17)
MEM_CALRC: length 2
  TOP w0.114: GPU1.R14 62.2,186.73 61.86,187.07 61.81,187.07 v6(61.76,187.12)
  BOTTOM w0.114: v6(61.76,187.12) 61.72,187.16 61.61,187.16 61.24,187.53 61.24,187.59 R621.1
MEM_CALRD: length 2.7
  TOP w0.114: GPU1.AL20 67.87,171.07 v6(67.54,171.07)
  BOTTOM w0.114: v6(67.54,171.07) 68.39,171.92 68.39,171.92 68.53,172.06 R622.1
MF_A0: length 1.5
  TOP w0.114: VRAMA1.J1 v6(102.1,199.6)
  BOTTOM w0.114: R683.1 101.97,199.73 v6(102.1,199.6)
MF_A1: length 1.6
  TOP w0.114: VRAMA2.J1 v6(94.1,220.1)
  BOTTOM w0.114: R684.1 94.41,219.79 v6(94.1,220.1)
MF_B0: length 2.4
  TOP w0.114: v6(64.41,220.1) 64.41,220.14 VRAMB1.J1
  BOTTOM w0.114: v2(62.86,219.66) 63.37,220.18 R642.1 64.33,220.18 v6(64.41,220.1)
MF_B1: length 2.7
  TOP w0.114: VRAMB2.J1 v6(57.1,220.1)
  BOTTOM w0.114: v2(58.96,219.38) 58.76,219.38 R639.1 57.12,220.12 v6(57.1,220.1)
MF_C0: length 1.5
  TOP w0.114: VRAMC1.J1 v6(29.9,192.9)
  BOTTOM w0.114: v6(29.9,192.9) 29.88,192.88 R686.1
MF_C1: length 1.3
  TOP w0.114: v6(29.9,185.6) VRAMC2.J1
  BOTTOM w0.114: R709.1 29.87,185.63 v6(29.9,185.6)
MF_D0: length 1.6
  TOP w0.114: VRAMD1.J1 v6(29.9,155.9)
  BOTTOM w0.114: v6(29.9,155.9) 30.11,155.69 R638.1
MF_D1: length 1.6
  TOP w0.114: v6(50.4,147.9) VRAMD2.J1
  BOTTOM w0.114: v6(50.4,147.9) 50.19,148.11 R665.1
MODEL_ID_DET: length 8.8
  TOP w0.114: R172.2 121.79,63.39 C1016.2 121.84,63.34 R178.1 121.4,62.24 121.25,62.39 120.25,62.39 v3(120.04,62.18) 119.46,61.59 119.46,60.05 119.06,59.66 119.06,59.09 118.91,58.94 KBC1.95
MPCIE_DISABLE_N: length 175
  TOP w0.114: v1(196.11,65.3) 196.98,64.44 196.98,60.63 R2479.1 ; v1(123.67,67.18) 124.07,66.78 124.07,65.25 123.69,64.87 121.45,64.87 121.23,64.65 121.23,63.5 120.52,62.79 119.58,62.79 116.57,59.77 116.57,59.4 116.01,58.85 115.06,58.85 113.84,57.63 113.84,56.62 111.16,53.94 109.65,53.94 109.6,53.89 108.78,53.89 107.8,52.92 107.8,47.08 106.85,46.12 KBC1.40
  L4 w0.114: v1(111.56,86.82) 111.24,86.5 111.24,84.38 116.59,79.04 116.59,69.43 119.7,66.32 122.89,66.32 123.67,67.11 v1(123.67,67.18)
  L6 w0.102: v1(195.94,73.43) 194.92,72.42 188.46,72.42 187.34,73.54 186.09,73.54 182,77.62 169.79,77.62 169.51,77.9 167.96,77.9 167.39,77.33 160.96,77.33 160.49,76.86 157.2,76.86 157.1,76.76 154.74,76.76 154.46,77.04 139.21,77.04 139.03,76.86 132.35,76.86 126.62,82.59 126.62,89.69 124.74,91.57 119.29,91.57 114.72,87 111.73,87 v1(111.56,86.82)
  BOTTOM w0.114: v1(196.11,65.3) 196.6,65.79 v5(196.6,72.13) 196.6,72.77 v1(195.94,73.43)
MUXSSD_OE#: length 3.9
  TOP w0.114: R443.1 125.4,99.09 v3(125.17,99.31) 123.9,99.31 123.16,98.57 U26.2
MUXSSD_RX_N0: length 18.7
  TOP w0.102: 110.49,104.85 110.03,104.85 109.82,104.64 109.82,104.46 109.6,104.24 109.43,104.24 109.21,104.03 109.21,103.85 108.99,103.64 108.82,103.64 108.56,103.38 108,103.38 107.62,103 107.62,101.67 107.75,101.54 SSDC1.43 ; 110.49,104.85 v3(110.49,104.47) ; 110.49,104.85 111.96,104.85 113,105.89 116.12,105.89 116.24,105.77 116.55,105.77 116.67,105.89 116.98,105.89 117.1,105.77 117.41,105.77 117.53,105.89 117.84,105.89 117.96,105.77 118.26,105.77 118.39,105.89 118.69,105.89 118.91,105.68 118.91,105.5 119.12,105.29 119.3,105.29 120.22,104.37 120.22,104.06 119.88,103.72 R2735.2
MUXSSD_RX_N0_R: length 12.8
  TOP w0.102: U26.4 122.16,98.81 122.3,98.94 122.3,99.18 122.83,99.72 122.83,99.9 122.71,100.03 120.61,100.03 120.35,100.29 120.35,100.75 120.61,101.02 123.11,101.02 123.24,101.14 123.24,101.35 123.04,101.55 120.45,101.55 120.14,101.86 120.14,102.43 R2735.1
MUXSSD_RX_P0: length 18.7
  TOP w0.102: SSDC1.41 107.25,101.56 107.39,101.7 107.39,103.09 107.91,103.61 108.46,103.61 109.94,105.08 111.87,105.08 112.59,105.8 ; 112.59,105.8 112.91,106.12 118.79,106.12 120.45,104.46 120.45,104.04 R2734.2 ; 112.59,105.8 v3(112.32,106.07)
MUXSSD_RX_P0_R: length 13.2
  TOP w0.102: 121.97,101.78 123.13,101.78 123.47,101.44 123.47,101.05 123.21,100.79 120.7,100.79 120.57,100.66 120.57,100.38 120.7,100.25 122.8,100.25 123.06,99.99 123.06,99.63 122.53,99.09 122.53,98.94 122.66,98.81 U26.3 ; 121.97,101.78 120.55,101.78 120.37,101.96 120.37,102.41 R2734.1 ; 121.97,101.78 v3(121.97,102.18)
MUXSSD_SEL: length 20.4
  TOP w0.114: v1(118.34,94.26) 118.19,94.41 118.19,97.28 119.11,98.2 U26.9 ; v3(112.45,86.68) 112.28,86.51 R2599.2 112.32,85.46 U43.D 115.61,85.46 115.62,85.45 v1(115.67,85.45)
  L4 w0.114: v1(118.34,94.26) 118.31,94.23 118.31,88.62 115.62,85.93 115.62,85.5 v1(115.67,85.45)
  BOTTOM w0.114: v1(115.67,85.45) v5(115.67,84.58)
MUXSSD_SEL_EN: length 131.6
  TOP w0.114: CPU1.AL23 158.93,160 v6(158.43,160.51) ; R2600.2 117.72,86.91 v1(118.01,86.61)
  L3 w0.114: v1(143.56,88.16) 143.56,88.19 143.89,88.52 143.89,94.59 142.65,95.84 142.65,97.92 141.99,98.58 141.99,116 141.5,116.48 141.5,122.68 141.02,123.16 141.02,124.29 140.99,124.32 140.99,124.7 141.02,124.73 141.02,125.39 140.88,125.53 140.88,145.12 139.32,146.69 139.32,152.79 140.45,153.92 140.86,153.92 142.24,155.3 142.24,155.98 144.92,158.66 145.98,158.66 147.27,159.94 149.35,159.94 151.29,161.88 154.66,161.88 155.07,161.48 155.07,161.35 156.33,160.09 158.01,160.09 v6(158.43,160.51)
  BOTTOM w0.114: RN2405.3 152.62,158.24 153.28,158.9 153.62,158.9 153.69,158.83 154.34,158.83 154.36,158.85 154.43,158.85 154.54,158.95 157.71,158.95 158.43,159.67 v6(158.43,160.51) ; v1(143.56,88.16) 143.56,89.66 142.63,90.59 134.26,90.59 134.03,90.82 130.2,90.82 128.84,92.18 v5(123.55,92.18) 121.94,92.18 117.98,88.22 117.98,87.18 117.98,87.18 117.98,86.64 v1(118.01,86.61)
MUXSSD_SEL_EN_C: length 2.9
  TOP w0.114: v3(118.06,88.65) 118.05,88.65 R2600.1 116.17,87.8 U43.G
MUXSSD_TX_N1: length 16.8
  TOP w0.102: U26.8 120.16,98.6 120.29,98.74 120.29,99.19 120.1,99.39 119.25,99.39 117.07,97.21 115.04,97.21 114.66,96.82 110.24,96.82 108.89,98.18 108.89,99.9 108.75,100.04 SSDC1.47
MUXSSD_TX_P1: length 16.8
  TOP w0.102: U26.7 120.66,98.69 120.52,98.83 120.52,99.29 120.19,99.62 119.16,99.62 116.97,97.43 114.94,97.43 114.56,97.05 110.33,97.05 109.11,98.27 109.11,99.94 109.25,100.08 SSDC1.49
MVREF_A: length 8.6
  TOP w0.114: GPU1.P25 73.15,187.8 v6(73.6,188.25)
  BOTTOM w0.114: v6(73.6,188.25) 73.94,187.91 75.17,187.91 v2(75.73,187.35) 75.79,187.35 76.43,187.35 77.24,186.54 77.83,186.54 R611.2 77.88,187.12 R614.1 77.89,188.1 77.89,188.47 77.9,188.49 C735.1
MVREF_B: length 4.1
  TOP w0.114: v6(67.67,188.24) 67.67,188.18 68.05,187.8 GPU1.P20
  BOTTOM w0.114: R613.2 66.74,187.98 C736.1 66.79,187.23 R615.1 67.9,188.01 v6(67.67,188.24)
MVREF_C: length 5.5
  TOP w0.114: GPU1.Y14 62.2,181.95 v6(61.75,182.4)
  BOTTOM w0.114: C738.1 62.24,180.45 62.24,181.25 62.69,181.71 R623.1 62.3,181.85 v6(61.75,182.4) 61.98,182.63 62.51,182.63 R619.2
MVREF_D: length 3.7
  TOP w0.114: GPU1.AE14 62.2,176.91 v6(61.77,176.48)
  BOTTOM w0.114: C739.1 62.42,177.13 v6(61.77,176.48) 62.15,176.1 R620.2 R624.1
NC7SB3157_A: length 22
  TOP w0.114: R21.1 196.7,164.58 197.58,164.58 197.61,164.62 199.54,164.62 200.23,163.93 v3(200.23,157.48) 200.23,154.99 201.89,153.33 R1229.2 202.28,152.38 R1231.1 202.6,152.06 R1232.1 203.59,152.1 R1230.2 204.74,153.38 204.93,153.57 U38.4
NC7SB3157_B0: length 3.5
  TOP w0.114: U38.3 204.93,156.39 204.58,156.74 v3(203.2,156.74) 203.08,156.62 R1228.2
NC7SB3157_B1: length 3
  TOP w0.114: R1227.2 207.06,157.82 v3(206.76,157.52) 206.23,156.98 U38.1
NC7SB3157_S: length 4
  TOP w0.114: U38.6 206.23,152.42 206.46,152.19 v3(206.96,152.19) 207.05,152.19 207.68,152.81 R1233.1
NCT_CLK: length 8
  BOTTOM w0.114: RN15.3 113.58,51.9 113.64,51.84 U2.8 113.67,50.35 113.67,49.35 114.88,48.13 v2(115.98,48.13) 116.04,48.13 116.92,49.02 Q15.1
NCT_DATA: length 6.5
  BOTTOM w0.114: Q15.4 115.62,51.22 115.62,51.79 v2(114.63,52.78) 114.07,53.34 113.21,53.34 112.93,53.06 RN15.4 112.93,51.57 112.99,51.51 U2.7
NGFF_BT_DISABLE: length 182.2
  TOP w0.114: KBC1.80 110.17,52.95 v1(109.98,53.14) ; R2478.1 197.33,57.62 R412.1 197.5,59.19 198.6,60.3 198.6,62.23 v1(199.09,62.71)
  L4 w0.114: v1(128.78,65.61) 126.57,67.82 118.8,67.82 117.01,69.61 117.01,79.21 113.31,82.91 v1(113.31,86.18)
  L6 w0.102: v1(109.98,53.14) 111.36,53.14 112.24,54.02 112.24,54.34 114.17,56.26 115.38,56.26 116.52,57.4 116.92,57.4 120.07,60.55 121.12,60.55 123.22,62.65 123.22,62.7 123.79,63.27 124.28,63.27 126.62,65.61 v1(128.78,65.61) ; v1(113.31,86.18) 114.48,86.18 119.46,91.16 124.57,91.16 126.21,89.52 126.21,82.42 132.18,76.45 132.52,76.45 139.2,76.45 139.38,76.63 153.82,76.63 154.1,76.35 157.27,76.35 157.37,76.45 160.66,76.45 161.13,76.92 167.56,76.92 168.13,77.5 169.34,77.5 169.62,77.22 181.83,77.22 185.92,73.13 187.17,73.13 188.29,72.01 195.99,72.01 196.72,72.75 197.28,72.75 v1(197.94,73.41)
  BOTTOM w0.114: v1(197.94,73.41) 198.45,72.9 v5(198.45,70.13) 198.45,63.35 v1(199.09,62.71)
NGFF_CLKREQ1_N: length 3.3
  TOP w0.114: WLAN1.68 192.26,58.5 192.54,58.79 TP94.1
NGFF_PEWAKE0_N: length 39.3
  TOP w0.114: WLAN1.55 180.87,55.25 v1(180.44,55.68) ; v1(195.02,65.23) 196.6,63.65 196.6,62.08 195.99,61.47 195.15,61.47 194.93,61.25 R1220.1 ; v1(180.47,60.58) 180.44,60.6 180.44,62.38 186.84,68.78 191.77,68.78 192.79,69.8 v1(196.09,69.8)
  BOTTOM w0.114: v1(195.02,65.23) 196.16,66.36 196.16,69.73 v1(196.09,69.8) ; v1(180.44,55.68) v5(180.44,58.12) 180.44,60.55 v1(180.47,60.58)
NGFF_PEWAKE1_N: length 5.2
  TOP w0.114: WLAN1.70 192.15,59 193.18,60.03 v3(193.84,60.03) 194.26,59.62 R1219.2
NGFF_W_DISABLE1_N: length 9
  TOP w0.114: R2479.2 196.98,58.86 v3(196.09,57.96) 195.76,57.96 194.3,56.5 192.34,56.5 191.34,55.5 WLAN1.56
NGFF_W_DISABLE2_N: length 6.8
  TOP w0.114: R2478.2 v3(195.33,56.64) 194.85,56.16 192.51,56.16 191.35,55 WLAN1.54
NPMALERT: length 2.7
  TOP w0.114: PR247.2 116.3,140.9 TP121.1 116.83,140 116.38,139.55 PR223.2
NSVALERT: length 68.7
  TOP w0.114: GPU1.AN23 70.45,169.8 70.03,169.38 v6(70.03,169.32) ; PR243.2 107.56,146.81 107.25,147.12 v1(106.89,147.12) 106.83,147.17 106.83,147.35 106.13,148.05 PR229.2
  L6 w0.102: v6(70.03,169.32) 70.37,168.97 70.5,168.84 70.5,168.45 70.22,168.16 70.22,167.2 69.55,166.53 69.55,159.49 67.54,157.48 67.54,150.43 68.25,149.72 68.25,147.4 69.98,145.67 69.99,145.67 70.42,145.24 71.86,145.24 v1(72.09,145.01)
  BOTTOM w0.114: v1(72.09,145.01) 72.99,145.91 77.71,145.91 78.51,145.11 82.78,145.11 83.44,145.77 v2(87.96,145.77) 102.34,145.77 103.17,144.93 104.75,144.93 106.83,147.02 106.83,147.06 v1(106.89,147.12)
NVRHOT: length 58.5
  TOP w0.114: PR240.2 109.54,141.14 107.64,139.24 106.53,139.24 104.97,140.81 v1(104.97,141.25) ; v6(80.65,172.8) 81,173.15 GPU1.AJ34
  L4 w0.114: v1(94.36,163.83) 94.36,162.86 96.82,160.4 96.82,153.82 102.76,147.89 102.76,145.88 104.8,143.83 104.8,141.41 v1(104.97,141.25)
  L6 w0.102: v1(94.36,163.83) 90.93,167.26 90.93,168.78 89.87,169.85 83.82,169.85 83.68,169.99 82.88,170.79 81.33,170.79 81.27,170.8 81.11,170.83 80.04,170.83 79.76,171.12 79.44,171.43 79.44,171.77 80.48,172.8 v6(80.65,172.8)
  BOTTOM w0.114: v1(94.36,163.83) 95.12,163.83 v2(95.63,163.32) 95.83,163.12 R2635.2
OC_ADJ1: length 6.4
  TOP w0.114: U8.5 199.99,24.6 200.01,24.62 201.21,24.62 v1(201.5,24.33)
  BOTTOM w0.114: v1(201.5,24.33) 201.5,23.7 v2(201.19,23.39) 201.17,23.37 200.46,23.37 199.51,24.32 R323.2
OSD_CONTROL_SEL: length 262.1
  TOP w0.114: v1(135.86,163.63) 136.58,164.34 138.94,164.34 139.14,164.54 139.78,164.54 139.85,164.62 140.72,164.62 141.77,165.11 143.08,166.42 143.08,167.16 146.52,170.6 152.4,170.6 CPU1.AU13 ; v1(135.42,144.22) 135.4,144.24 134.67,144.24 v3(134.56,144.34) 134.56,145.01 134.11,145.47 RN2402.3 ; LAUOC1.11 v1(128.25,8.31)
  L3 w0.114: v1(164.54,22.33) 166.6,24.38 173.35,24.38 178.82,29.84 180.97,29.84 182.75,31.62 182.75,40.13 175.7,47.19 175.7,56.74 171.46,60.99 168.31,60.99 166.27,63.03 166.27,76.84 163.01,80.1 157.26,80.1 156.14,78.98 146.62,78.98 142.24,83.36 140.45,83.36 136.47,87.35 136.47,93.05 135.46,94.06 135.46,98.91 132.31,102.05 132.31,102.58 130.63,104.26 130.63,120.04 131.55,120.96 131.55,130.92 132.31,131.69 132.31,137.74 135.64,141.07 135.64,144 v1(135.42,144.22) 135.83,144.63 135.83,145.17 133.42,147.59 133.42,152.52 133.56,152.66 133.56,154.91 133.27,155.21 133.27,155.79 133.63,156.15 133.63,157.03 134.47,157.87 134.47,159.86 134.05,160.28 134.05,161.89 135.8,163.63 v1(135.86,163.63)
  L4 w0.114: v1(164.54,22.33) 164.36,22.15 161.57,22.15 161.44,22.28 159.99,22.28 153.54,15.82 152.78,15.82 149.89,12.93 143.73,12.93 143.57,12.76 143.1,12.76 140.52,10.19 138.41,10.19 137.79,10.8 135.6,10.8 135.43,10.97 134.55,10.97 132.61,9.03 128.97,9.03 v1(128.25,8.31)
OSD_MENU: length 403.6
  TOP w0.114: v1(135.69,156.71) 135.84,156.71 138.89,159.77 R2762.1 ; R2459.2 114.5,42.47 v1(115.24,43.21) ; v1(10.62,133.3) 11.45,134.13 R1225.1 ; LAUOC1.4 124.75,8.02 124.44,8.32 121.13,8.32 120.02,7.21 v1(119.79,7.21)
  L3 w0.114: v1(93.34,47.57) 93.33,47.57 93.28,47.52 92.53,47.52 85.32,54.74 85.22,54.74 84.68,55.28 84.68,81.65 87.07,84.05 87.07,96.76 87.42,97.11 87.42,97.46 87.42,97.46 87.42,101.35 78.92,109.85 26.17,109.85 25.03,110.99 14.23,110.99 6.94,118.27 6.94,129.62 v1(10.62,133.3)
  L6 w0.102: v1(93.34,47.57) 93.34,46.76 92.81,46.23 92.81,28.73 93.8,27.74 93.8,21.41 98.4,16.81 98.4,15.52 105.41,8.51 105.41,7.87 107.16,6.12 113.54,6.12 115.58,8.15 118.75,8.15 119.68,7.21 v1(119.79,7.21) ; v1(90.42,72.69) 90.42,81.99 95.53,87.1 96.79,87.1 101.26,91.57 105.69,91.57 117.09,102.97 117.09,112.73 117.09,113.06 117.98,113.95 117.98,116.97 120.85,119.84 122.07,119.84 123.52,121.29 123.52,126.27 126.36,129.11 126.36,135.08 128.62,137.34 128.63,137.34 128.73,137.44 128.73,152.22 132.08,155.57 132.81,155.57 133.95,156.71 v1(135.69,156.71)
  BOTTOM w0.114: v1(90.42,72.69) 90.42,70.48 91.72,69.19 91.72,63.3 92.3,62.71 92.3,48.62 v1(93.34,47.57) 93.34,47.55 93.93,46.96 93.93,43.63 94.43,43.12 100.5,43.12 100.66,43.28 103.56,43.28 103.89,43.62 v5(113.28,43.62) 114.83,43.62 v1(115.24,43.21) ; C988.1 R1226.1 11.51,134.19 v1(10.62,133.3)
OSD_MENU_EC: length 3.4
  TOP w0.114: KBC1.56 113.25,44.29 112.78,43.81 v3(112.78,43.43) 112.78,43.04 R2459.1
OSD_MENU_R: length 4
  TOP w0.114: OSDC1.7 7.71,135.75 7.77,135.82 8.24,135.82 v3(9.38,134.68) 9.74,134.31 R1225.2
P0A_ZVSS: length 4.2
  TOP w0.114: CPU1.V8 v6(172.49,174.51)
  BOTTOM w0.114: v6(172.49,174.51) 172.98,175.01 174.28,175.01 R4.1 174.5,175.22 v2(174.5,176.43)
P0B_ZVSS: length 3.8
  TOP w0.114: CPU1.AT8 v6(153.5,175.54)
  BOTTOM w0.114: 153.49,174.65 153.49,175.54 v6(153.5,175.54) ; 153.49,174.65 153.08,174.65 152.3,175.44 151.76,175.44 R5.1 ; 153.49,174.65 v2(153.49,174.65)
P2800_DXN: length 19.4
  TOP w0.114: v1(99.72,50.16) 100.51,49.38 R228.2
  BOTTOM w0.114: v1(99.72,50.16) 99.67,50.16 99.35,49.85 C294.2 C295.2 99.35,47.59 99.82,47.12 Q13.E 99.86,46.27 104.78,46.27 v2(105.18,45.87) 105.66,45.39 111.99,45.39 112.34,45.75 112.34,46.39 U2.3
P2800_DXP: length 24.1
  TOP w0.114: R228.1 98.98,50.06 v1(98.81,50.24)
  BOTTOM w0.114: U2.2 112.99,45.63 112.29,44.93 104.42,44.93 v2(103.76,45.59) 103.71,45.59 103.38,45.93 100.84,45.93 99.33,44.41 Q13.C 97.85,45.4 Q13.B 97.85,47.12 98.46,47.74 C295.1 C294.1 98.46,49.9 v1(98.81,50.24)
P_ZVDDP: length 26
  TOP w0.114: CPU1.W8 v6(171.5,174.5)
  L3 w0.114: v1(149.98,173.84) 150.26,173.56 155.11,173.56 155.56,174.01 170.07,174.01 170.56,174.5 v6(171.5,174.5)
  BOTTOM w0.114: R1.2 147.47,173.41 148.06,173.99 v2(149.1,173.99) 149.24,173.84 v1(149.98,173.84)
P_ZVSS: length 1.6
  TOP w0.114: CPU1.W7 v6(171.49,175.49)
  BOTTOM w0.114: R3.1 171.43,175.43 v6(171.49,175.49)
PANEL_ON: length 283.2
  TOP w0.114: v1(158.55,182.58) 159,182.13 CPU1.AL1 ; LAUOC1.12 128.75,9.07 v3(128.42,9.4) 128.42,10.16 v1(127.97,10.62)
  L3 w0.114: v1(164.62,23.11) 166.4,24.89 173.23,24.89 178.69,30.35 180.85,30.35 182.25,31.75 182.25,39.95 175.26,46.93 175.26,55.27 170.07,60.45 168.25,60.45 165.84,62.87 165.84,76.68 162.84,79.68 157.44,79.68 156.32,78.56 146.45,78.56 145.13,79.88 145.11,79.88 142.06,82.93 140.29,82.93 135.99,87.23 135.99,92.79 132.66,96.11 132.66,97.28 128.69,101.26 128.69,109.6 129.77,110.68 129.77,120.37 130.64,121.23 130.64,131.57 131.4,132.33 131.4,156.58 133.22,158.39 133.22,159.34 132.8,159.76 132.8,161.61 132.51,161.91 132.4,161.91 v1(132.08,162.23) 132.8,162.95 132.8,163.27 134.58,165.05 136.11,165.05 136.8,164.36 138.5,164.36 138.76,164.62 138.95,164.81 139.15,165.01 139.32,165.18 141.66,165.18 146.43,169.95 146.43,173.24 148.04,174.85 151.49,174.85 151.71,175.08 154.97,175.08 156.06,176.17 156.06,176.73 157,177.67 158.42,177.67 159.21,178.46 159.21,181.86 158.55,182.52 v1(158.55,182.58)
  L4 w0.114: v1(164.62,23.11) 164.08,22.58 161.75,22.58 161.62,22.71 159.69,22.71 153.28,16.3 152.66,16.3 149.75,13.39 144.98,13.39 143.64,14.73 141.6,14.73 140.01,13.14 134.67,13.14 132.29,10.76 129.34,10.76 128.92,11.18 128.53,11.18 127.97,10.62 v1(127.97,10.62)
  BOTTOM w0.114: v1(132.08,162.23) 131.7,161.85 131.7,161.29 131.47,161.06 v2(130.94,161.06) 130.56,161.45 130.56,162.21 R2783.1 R2782.1
PB_IN_SW1: length 4.5
  TOP w0.114: OSDC1.6 7.84,136.25 7.87,136.22 8.33,136.22 8.43,136.32 v3(9.27,136.32) 10.55,136.32 R451.2 R452.1
PC_MONITOR_SW_D: length 3.4
  TOP w0.114: R2586.2 190.33,34.99 v3(190.2,35.13) 189.48,35.13 188.86,34.51 U40.D
PC_MONITOR_SW_G: length 8.4
  TOP w0.114: U40.G 187.93,33.84 187.93,32.11 187.4,31.57 187.4,31.57 v3(187.38,31.55) 187.38,31.55 187.18,31.35 R2588.1 185.04,30.19 C1117.1 184.85,29.78 R2587.2
PCB_VER_ID: length 6.1
  TOP w0.114: KBC1.98 116.05,61.92 117.04,62.92 v3(117.27,62.92) 118.08,63.73 R171.1 119.03,64.07 C1004.2 120.01,64.06 R177.1
PCH_CHAR_CTL3_REAR: length 20.5
  TOP w0.114: v1(95.35,43.71) 95.15,43.92 95.15,46.99 95.47,47.31 R352.2 ; v1(102.46,44.39) 102.93,44.39 103.49,43.83 R353.2 103.78,43.43 104.04,43.69 104.04,44.25 103.63,44.65 103.63,46.25 103.84,46.46 104.7,46.46 104.85,46.31 KBC1.35
  L3 w0.114: v1(95.35,43.71) 95.48,43.59 97.36,43.59 98.39,44.61 99.94,44.61 100.02,44.53 102.32,44.53 v1(102.46,44.39)
  BOTTOM w0.114: v1(102.46,44.39) 102.79,44.07 v2(103.38,44.07)
PCH_CHAR_CTL3_SIDE: length 219.8
  TOP w0.114: R337.2 224.5,11.75 224.24,12.01 v1(224.24,12.34) ; v1(219.23,12.4) 219.43,12.6 R338.2 ; v1(107.24,53.95) 107.46,53.73 107.46,49.83 106.71,49.07 106.71,46.86 106.45,46.6 KBC1.39
  L3 w0.114: v1(207.37,76.53) 219.19,64.7 219.19,62.3 222.85,58.64 222.85,31.39 221.96,30.49 221.96,26.38 222.7,25.63 222.7,22.63 219.3,19.23 219.3,19.2 218.87,18.76 218.87,12.76 v1(219.23,12.4)
  L4 w0.114: v1(207.37,76.53) 206.44,77.45 191.88,77.45 190.32,75.9 186.69,75.9 185.95,76.63 178.42,76.63 173.25,81.8 161.33,81.8 v1(160.76,82.37)
  L6 w0.102: v1(219.23,12.4) 219.28,12.34 v1(224.24,12.34) ; v1(107.24,53.95) 106.66,54.53 103.51,54.53 102.92,55.12 102.92,59.33 106.96,63.37 110.44,63.37 111.05,63.98 111.05,65.53 110.34,66.25 110.34,66.75 111.94,68.35 118.41,68.35 118.94,68.88 122.95,68.88 124.23,70.17 124.23,71.45 v1(124.21,71.48)
  BOTTOM w0.114: v1(160.76,82.37) 160.76,82.42 160.32,82.85 157.61,82.85 v5(156.36,81.61) 154.64,79.88 154.21,79.88 148.34,74.02 127.81,74.02 126.29,72.49 125.22,72.49 v1(124.21,71.48)
PCH_SUSCLK_WLAN: length 121.5
  TOP w0.114: PCH1.F25 170.58,51.38 171.06,51.38 171.93,52.26 173.28,52.26 174.87,50.67 v1(177.11,50.67) ; v1(199.11,61.87) 198.96,61.72 198.96,56.44 197.87,55.34 R2477.1 ; v1(126.39,53.49) 124.99,53.49 123.56,52.06 R2536.2 ; v1(181.25,61.04) 181.39,61.18 181.47,61.18 181.91,61.62 181.91,62 187.4,67.49 192.48,67.49 192.94,67.94 196.88,67.94 v1(197.84,68.91)
  L6 w0.102: v1(181.25,61.04) 178.21,61.04 174.78,64.47 172.77,64.47 172.16,63.86 167.98,63.86 167.7,64.14 167.29,64.14 167.26,64.16 156.43,64.16 154.04,61.77 140.13,61.77 140.13,61.77 139.82,61.77 137.72,59.66 135.13,59.66 128.96,53.49 v1(126.39,53.49)
  BOTTOM w0.114: v1(197.84,68.91) 197.74,68.81 197.74,63.25 v1(199.11,61.87) ; v1(177.11,50.67) TP2506.1 178.59,52.15 178.59,59.41 180.22,61.04 180.66,61.04 180.67,61.04 v1(181.25,61.04)
PCIE_RST#: length 116.5
  TOP w0.114: v1(194.89,55.65) 194.73,55.82 192.72,55.82 191.41,54.5 WLAN1.52 ; v1(194.87,58.12) 192.43,58.12 192.32,58 WLAN1.66 ; RN48.3 106.75,81.94 106.91,82.09 107.31,82.09 v1(107.47,81.94)
  L4 w0.114: v1(191.24,67.02) 191.24,66.83 194.87,63.2 v1(194.87,58.12) 194.89,58.09 v1(194.89,55.65)
  L6 w0.102: v1(107.47,81.94) 107.98,82.45 110.39,82.45 111.11,83.17 123.47,83.17 124.54,82.1 124.54,81.8 131.61,74.73 132.52,74.73 132.52,74.73 161.23,74.73 161.79,75.29 171.19,75.29 171.61,74.87 180.4,74.87 181.71,73.56 183.39,73.56 189.92,67.02 v1(191.24,67.02)
  BOTTOM w0.114: v2(194.01,58.12) v1(194.87,58.12)
PCIE_RST#_APU: length 401.5
  TOP w0.114: PR419.1 105.85,140.93 106.68,140.11 106.98,140.11 v1(107.34,139.75) ; v1(152.78,20.8) 152.78,21.46 153.42,22.1 158.39,22.1 162.48,18.01 v1(162.48,15.95) ; D11.1 115.89,118.99 C926.1 ; v1(105.73,165.05) 105.5,165.28 100.32,165.28 99.79,165.81 97.99,165.81 96.9,164.72 94.23,164.72 93.09,163.58 91.57,163.58 89.41,165.74 88.57,165.74 88.1,166.2 GPU1.AV42 ; C926.1 111.89,117.98 v1(111.04,117.13) ; C926.1 117.86,118.94 D11.2 ; CPU1.AL7 v6(158.5,175.5)
  L4 w0.114: v1(105.73,165.05) 106.72,164.06 106.72,162.14 105.75,161.17 105.75,157.55 106.81,156.49 106.81,150.32 107.96,149.17 107.96,147.91 107.37,147.33 107.37,140.04 107.34,140 v1(107.34,139.75) 107.34,139.32 108.06,138.6 108.06,137.34 105.82,135.09 105.82,129.49 111.98,123.33 111.98,118.07 v1(111.04,117.13) 111.04,112.85 103.53,105.35 97.62,105.35 90.72,98.45 90.72,86.08 83.95,79.31 83.95,58.29 85.85,56.39 85.85,51.31 83.86,49.32 83.86,32.31 82.26,30.71 82.26,29.55 85.32,26.49 85.32,15.27 96.09,4.5 108.82,4.5 109.71,3.61 114.76,3.61 114.83,3.68 123.81,3.68 124.11,3.99 141.52,3.99 141.95,4.42 143.15,4.42 144.78,6.05 144.78,8.1 146.8,10.12 150.79,10.12 151.87,11.2 155.25,11.2 158.78,14.73 161.29,14.73 162.48,15.93 v1(162.48,15.95)
  BOTTOM w0.114: R2682.1 145.52,34.85 148.06,32.31 150.52,32.31 151.18,31.65 151.18,30.55 149.25,28.63 149.25,25.29 149.25,24.71 149.25,24.71 149.25,23.47 151.92,20.8 v1(152.78,20.8) ; v6(158.5,175.5) 159.01,176.01 TP98.1 158.98,176.04 158.98,176.86 158.8,177.04 156.49,177.04 155.44,178.09 155.33,178.09 155.02,178.39 155.02,179.56 154.65,179.93 154.28,179.93 154,180.21 151.04,180.21 150.67,180.58 150.67,180.98 150.36,181.29 150.36,181.87 149.86,182.37 149.03,182.37 R44.1 148.3,182.58 147.37,182.58 146.57,181.78 146.05,181.78 144.96,180.69 144.96,177.07 144.44,176.56 142.47,176.56 141.43,175.51 141.43,174.52 141.24,174.34 135.83,174.34 133.56,172.07 125.76,172.07 125.65,171.95 125.06,171.95 120.5,167.39 114.6,167.39 112.14,164.92 110.31,164.92 109.85,165.39 106.07,165.39 v1(105.73,165.05)
PCIE_RST#_APU_R: length 13.1
  TOP w0.114: PCH1.V6 v6(154.6,41)
  BOTTOM w0.114: v6(154.6,41) 154.6,40.9 155.01,40.49 155.01,40.03 154.72,39.74 149.24,39.74 147.67,38.17 146.41,38.17 v2(146.14,37.9) 145.52,37.27 R2682.2
PCIE_RX_LAN_N1: length 110.1
  TOP w0.102: 110.09,9.29 109.9,9.09 109.9,7.89 109.75,7.75 TYPEC1.7 ; 110.09,9.29 110.69,9.88 113.17,9.88 114.33,8.72 114.33,3.12 114.91,2.54 114.91,2.51 v1(115.11,2.31) ; 110.09,9.29 v3(109.8,9.58) ; PCH1.R22 v6(168.2,43.4)
  L3 w0.102: v1(115.11,2.31) 115.08,1.88 115.17,1.79 115.35,1.79 116.46,2.9 149.56,2.9 149.61,2.84 150.31,2.84 150.57,3.11 150.57,3.25 150.79,3.47 150.93,3.47 152.81,5.34 152.81,5.48 153.02,5.7 153.16,5.7 153.38,5.92 153.38,6.06 153.6,6.27 153.74,6.27 153.95,6.49 153.95,6.63 154.17,6.84 154.31,6.84 154.52,7.06 154.99,7.53 154.99,10.73 161.44,17.18 161.44,25.76 168.15,32.46 168.15,32.88 169.31,34.04 170.84,34.04 174.32,37.52 174.32,39.69 174.22,39.79 174.22,40.09 174.32,40.19 174.32,40.5 174.22,40.6 174.22,40.9 174.32,41 174.32,43.38 173.6,44.09 172.04,44.09 171.94,44 171.63,44 171.53,44.09 171.23,44.09 171.13,44 170.83,44 170.73,44.09 170.42,44.09 170.32,44 170.02,44 169.92,44.09 169.08,44.09 168.68,43.7 168.5,43.7 v6(168.2,43.4)
PCIE_RX_LAN_P1: length 110
  TOP w0.102: TYPEC1.6 110.25,7.75 110.1,7.89 110.1,9.01 110.77,9.68 111.2,9.68 ; v1(114.4,1.7) 114.4,2.76 114.12,3.04 114.12,8.64 113.08,9.68 111.2,9.68 ; 111.2,9.68 v3(111.2,9.27) ; PCH1.P23 v6(168.2,44.2)
  L3 w0.102: v6(168.2,44.2) 168.5,43.9 168.6,43.9 169,44.3 173.69,44.3 174.52,43.46 174.52,37.43 170.92,33.83 169.39,33.83 168.35,32.79 168.35,32.38 161.65,25.67 161.65,17.09 155.19,10.64 155.19,7.44 154.73,6.97 150.39,2.64 149.52,2.64 149.47,2.69 116.55,2.69 115.44,1.58 114.99,1.58 114.91,1.66 v1(114.4,1.7)
PCIE_RX_PCH_N0: length 25
  TOP w0.102: v6(169.8,43.4) PCH1.R24 ; WLAN1.43 182.04,52.25 181.82,52.03 181.47,52.03 181.28,52.22 180.59,52.22 v1(180.26,52.55)
  L4 w0.102: v1(180.26,52.55) 180.62,52.2 181.23,52.2 181.69,51.74 181.69,47.03 178.37,43.71 171.3,43.71 170.94,44.07 169.71,44.07 169.5,43.87 169.5,43.7 v6(169.8,43.4)
  BOTTOM w0.102: v5(179.57,52.78) 180.04,52.78 v1(180.26,52.55)
PCIE_RX_PCH_P0: length 25
  TOP w0.102: WLAN1.41 182.01,51.75 181.93,51.82 181.39,51.82 181.2,52.02 180.64,52.02 v1(180.26,51.64) ; v6(169,43.4) PCH1.R23
  L4 w0.102: v6(169,43.4) 169.3,43.7 169.3,43.95 169.62,44.27 171.03,44.27 171.38,43.92 175.86,43.92 175.96,44.02 176.26,44.02 176.36,43.92 176.67,43.92 176.77,44.02 177.07,44.02 177.17,43.92 178.28,43.92 178.5,44.13 178.5,44.27 178.71,44.49 178.85,44.49 179.07,44.7 179.07,44.84 179.28,45.06 179.42,45.06 179.64,45.27 179.64,45.41 179.86,45.63 180,45.63 181.48,47.12 181.48,51.66 181.14,51.99 180.62,51.99 v1(180.26,51.64)
  BOTTOM w0.102: v5(179.95,50.98) 179.95,51.33 v1(180.26,51.64)
PCIE_RX_SSDX4_N4: length 94.1
  TOP w0.102: 129.29,80.82 129.64,80.82 130.15,81.33 130.38,81.33 v1(130.51,81.2) ; 129.29,80.82 127.4,80.82 125.58,82.64 125.58,87.69 125.98,88.1 125.98,89.15 125.58,89.55 125.58,93.87 125.16,94.28 123.19,94.28 122.81,94.67 122.81,95.1 122.66,95.24 U26.18 ; 129.29,80.82 v3(129.29,80.44) ; v6(168.2,47.4) PCH1.L22
  L4 w0.102: v1(130.51,81.2) 130.19,81.2 130.03,81.04 130.03,80.72 141.69,69.06 165,69.06 174.7,59.36 174.7,51.1 173.44,49.83 173,49.83 171.48,48.31 168.11,48.31 167.84,48.05 167.84,47.76 v6(168.2,47.4)
PCIE_RX_SSDX4_N5: length 125.3
  TOP w0.102: 104.4,104.93 104.4,105.7 106.47,107.77 119.1,107.77 127.22,99.65 127.22,90.58 128.27,89.53 128.27,87.01 127.92,86.66 127.71,86.66 v1(127.36,86.31) ; 104.4,104.93 104.4,101.55 104.25,101.41 SSDC1.29 ; 104.4,104.93 v3(104.01,104.93) ; v6(169,46.6) PCH1.L23
  L4 w0.102: v6(169,46.6) 170.38,47.98 171.82,47.98 173.07,49.23 173.69,49.23 175.31,50.84 175.31,59.74 163.91,71.15 140.49,71.15 131.93,79.71 131.93,81.02 128.17,84.78 128.17,86.43 127.93,86.66 127.71,86.66 v1(127.36,86.31)
PCIE_RX_SSDX4_N6: length 141.9
  TOP w0.102: v1(135.59,81.33) 135.59,80.91 135.3,80.62 134.32,80.62 ; v3(134.32,81) 134.32,80.62 ; 134.32,80.62 133.59,80.62 129.64,84.56 129.64,90.42 128.63,91.44 128.63,100.22 119.55,109.3 114.56,109.3 113.8,110.06 110.33,110.06 109.57,109.3 105.91,109.3 101.42,104.81 101.42,101.6 101.25,101.43 SSDC1.17 ; v6(167.4,46.6) PCH1.M22
  L4 w0.102: v6(167.4,46.6) 168.05,45.95 172.56,45.95 172.74,45.77 177.43,45.77 178.69,47.03 178.69,63.22 168.07,73.84 144.48,73.84 136.75,81.56 136.29,81.56 136.06,81.33 v1(135.59,81.33)
PCIE_RX_SSDX4_N7: length 147.3
  TOP w0.102: v1(132.31,84.94) 132,84.63 131.72,84.63 131.39,84.96 131.39,91.37 130.15,92.62 130.15,100.77 126.71,104.21 ; 126.71,104.21 120.18,110.74 115.25,110.74 114.49,111.51 106.21,111.51 105.94,111.23 105.12,111.23 103.84,109.94 103.84,109.43 98.42,104.02 98.42,101.57 98.25,101.4 SSDC1.5 ; 126.71,104.21 v3(127,104.5) ; v6(168.2,45) PCH1.N22
  L4 w0.102: v1(132.31,84.94) 132.62,84.62 132.62,84.61 132.7,84.53 133.64,84.53 133.97,84.2 135.28,84.2 144.83,74.65 168.41,74.65 179.6,63.46 179.6,46.35 177.88,44.63 172.42,44.63 171.62,45.42 168.62,45.42 v6(168.2,45)
PCIE_RX_SSDX4_P4: length 94.1
  TOP w0.102: v6(167.4,47.4) PCH1.K22 ; U26.19 123.16,95.27 123.01,95.12 123.01,94.75 123.27,94.49 125.25,94.49 125.78,93.95 125.78,89.64 126.19,89.23 126.19,88.01 125.78,87.6 125.78,82.73 127.48,81.03 128.09,81.03 ; 128.09,81.03 129.56,81.03 130,81.47 v1(130,81.97) ; 128.09,81.03 v3(128.09,81.41)
  L4 w0.102: v1(130,81.97) 130,81.3 129.83,81.13 129.83,80.64 141.6,68.86 164.91,68.86 174.5,59.28 174.5,51.18 173.35,50.04 172.92,50.04 171.39,48.51 168.02,48.51 167.64,48.13 167.64,47.64 v6(167.4,47.4)
PCIE_RX_SSDX4_P5: length 125.3
  TOP w0.102: v1(127.36,87.22) 127.71,86.87 127.84,86.87 128.07,87.1 128.07,89.45 127.02,90.5 127.02,99.56 119.02,107.57 108.23,107.57 ; 108.23,107.57 v3(108.23,107.19) ; 108.23,107.57 106.55,107.57 104.6,105.62 104.6,101.57 104.75,101.42 SSDC1.31 ; PCH1.L24 v6(169.8,46.6)
  L4 w0.102: v6(169.8,46.6) 169.8,47.11 170.47,47.78 171.91,47.78 173.15,49.02 173.78,49.02 175.51,50.76 175.51,51.01 175.61,51.11 175.61,51.42 175.51,51.51 175.51,51.82 175.61,51.92 175.61,52.22 175.51,52.32 175.51,52.63 175.61,52.73 175.61,53.03 175.51,53.13 175.51,59.83 175.3,60.04 175.3,60.18 175.08,60.4 174.94,60.4 174.73,60.61 174.73,60.75 174.51,60.97 174.37,60.97 174.16,61.18 174.16,61.32 173.94,61.54 173.8,61.54 173.58,61.75 173.58,61.89 173.37,62.11 173.23,62.11 173.01,62.33 173.01,62.47 172.8,62.68 172.66,62.68 172.44,62.9 172.44,63.04 172.23,63.25 172.09,63.25 170.21,65.13 170.21,65.27 169.99,65.49 169.85,65.49 169.64,65.7 169.64,65.84 169.42,66.06 169.28,66.06 169.07,66.27 169.07,66.41 168.85,66.63 168.71,66.63 163.99,71.35 140.57,71.35 132.13,79.79 132.13,81.1 128.37,84.86 128.37,86.51 128.02,86.87 127.71,86.87 v1(127.36,87.22)
PCIE_RX_SSDX4_P6: length 142.6
  TOP w0.102: v1(136.27,80.7) 135.66,80.7 135.38,80.42 133.5,80.42 129.44,84.48 129.44,90.34 128.42,91.36 128.42,100.13 119.46,109.09 114.48,109.09 113.72,109.86 110.41,109.86 109.65,109.09 105.99,109.09 101.63,104.72 101.63,101.57 101.75,101.45 SSDC1.19 ; v6(168.2,46.6) PCH1.M23
  L4 w0.102: v1(136.27,80.7) 136.27,81.25 136.37,81.36 136.67,81.36 142.68,75.35 142.68,75.21 142.89,74.99 143.03,74.99 143.25,74.78 143.25,74.64 143.46,74.42 143.6,74.42 143.82,74.21 143.82,74.07 144.04,73.85 144.18,73.85 144.39,73.63 167.99,73.63 168.2,73.42 168.2,73.28 168.42,73.06 168.56,73.06 168.77,72.85 168.77,72.71 168.99,72.49 169.13,72.49 169.35,72.28 169.35,72.14 169.56,71.92 169.7,71.92 171.68,69.94 171.68,69.8 171.9,69.58 172.04,69.58 172.25,69.37 172.25,69.23 172.47,69.01 172.61,69.01 172.82,68.8 172.82,68.66 173.04,68.44 173.18,68.44 173.4,68.23 173.4,68.09 173.61,67.87 173.75,67.87 173.97,67.66 173.97,67.51 174.18,67.3 174.32,67.3 174.54,67.08 174.54,66.94 174.75,66.73 174.89,66.73 175.11,66.51 175.11,66.37 175.32,66.16 175.46,66.16 175.68,65.94 175.68,65.8 175.9,65.59 176.04,65.59 176.77,64.85 176.77,64.71 176.99,64.49 177.13,64.49 177.34,64.28 177.34,64.14 177.56,63.92 177.7,63.92 177.91,63.71 177.91,63.57 178.13,63.35 178.27,63.35 178.49,63.14 178.49,48.73 178.39,48.63 178.39,48.33 178.49,48.23 178.49,47.92 178.39,47.83 178.39,47.52 178.49,47.42 178.49,47.12 177.91,46.55 177.77,46.55 177.56,46.33 177.56,46.19 177.34,45.97 177.04,45.97 176.94,46.07 176.63,46.07 176.54,45.97 176.23,45.97 176.13,46.07 175.83,46.07 175.73,45.97 175.42,45.97 175.32,46.07 175.02,46.07 174.92,45.97 172.82,45.97 172.64,46.15 168.65,46.15 v6(168.2,46.6)
  BOTTOM w0.102: v5(136.94,81.42) 136.88,81.36 136.88,81.32 136.27,80.71 v1(136.27,80.7)
PCIE_RX_SSDX4_P7: length 147.6
  TOP w0.102: v6(167.4,45) PCH1.P22 ; SSDC1.7 98.75,101.43 98.63,101.55 98.63,103.93 104.04,109.34 104.04,109.86 105.21,111.02 106.02,111.02 106.3,111.3 114.4,111.3 115.16,110.54 120.09,110.54 129.95,100.69 129.95,92.53 131.19,91.29 131.19,84.88 131.64,84.43 131.9,84.43 v1(132.31,84.02)
  L4 w0.102: v6(167.4,45) 168.02,45.62 171.71,45.62 172.5,44.83 177.8,44.83 179.4,46.43 179.4,63.37 168.33,74.45 144.75,74.45 136.34,82.86 136.2,82.86 135.98,83.07 135.98,83.21 135.77,83.43 135.63,83.43 135.41,83.64 135.41,83.78 135.2,84 133.88,84 133.55,84.33 132.61,84.33 v1(132.31,84.02)
  BOTTOM w0.102: v1(132.31,84.02) 132.28,84.05 v5(131.68,84.05)
PCIE_TX_CON_N0: length 14
  TOP w0.102: WLAN1.37 181.93,50.75 181.7,50.52 181.37,50.52 181.22,50.37 180.35,50.37 180.25,50.47 179.94,50.47 179.84,50.37 179.54,50.37 179.44,50.47 179.14,50.47 179.04,50.37 178.73,50.37 178.49,50.13 ; C204.2 176.7,43.54 177.77,43.54 178.21,43.97 178.21,44.48 178.11,44.58 178.11,44.89 178.21,44.99 178.21,45.29 178.11,45.39 178.11,45.7 178.21,45.79 178.21,46.85 178.11,46.94 178.11,47.25 178.21,47.35 178.21,47.65 178.11,47.75 178.11,48.06 178.21,48.16 178.21,48.46 178.11,48.56 178.11,48.87 178.21,48.96 178.21,49.84 178.49,50.13 ; 178.49,50.13 v3(178.21,50.42)
PCIE_TX_CON_P0: length 13.3
  TOP w0.102: 177.29,43.33 177.86,43.33 178.41,43.88 178.41,49.76 178.82,50.16 181.31,50.16 181.46,50.32 181.79,50.32 181.86,50.25 WLAN1.35 ; 177.29,43.33 176.5,43.33 176.27,43.1 C203.2 ; 177.29,43.33 v3(177.29,42.95)
PCIE_TX_LAN_N1: length 97.8
  TOP w0.102: v6(113.46,1.73) 113.46,2.16 113.54,2.24 113.54,8.44 113.14,8.84 111.7,8.84 111.33,8.47 111.33,7.82 111.25,7.75 TYPEC1.4
  L3 w0.102: v1(173.05,40.11) 172.69,39.75 172.69,38.53 167.51,33.35 167.51,32.71 160.71,25.9 160.71,17.32 154.31,10.92 154.31,9.47 153.03,8.19 151.78,8.19 147.09,3.51 114.73,3.51 113.46,2.24 v6(113.46,1.73)
  BOTTOM w0.102: 172.53,40.91 172.72,40.72 172.72,40.44 v1(173.05,40.11) ; 172.53,40.91 171.7,41.73 171.7,42.15 171.95,42.39 172.31,42.39 172.59,42.11 C206.2 ; 172.53,40.91 v2(172.77,41.15)
PCIE_TX_LAN_P1: length 98.2
  TOP w0.102: v1(112.55,1.73) 112.67,1.85 112.78,1.85 113.33,2.41 113.33,8.36 113.06,8.64 111.79,8.64 111.53,8.38 111.53,7.9 111.75,7.68 TYPEC1.3
  L3 w0.102: v1(112.55,1.73) 112.67,1.85 112.79,1.85 114.65,3.71 147.01,3.71 151.7,8.39 152.95,8.39 154.1,9.55 154.1,11.01 160.5,17.41 160.5,25.98 167.31,32.79 167.31,33.43 172.49,38.62 172.49,39.85 v1(172.24,40.11)
  BOTTOM w0.102: 171.5,41.86 171.5,41.65 172.52,40.63 172.52,40.39 v1(172.24,40.11) ; 171.5,41.86 171.5,42.23 171.87,42.6 172.19,42.6 172.59,43 C205.2 ; 171.5,41.86 v2(171.17,41.86)
PCIE_TX_PCH_N0: length 13.4
  TOP w0.102: 174.37,45.16 174.37,45.42 173.81,45.97 172.81,45.97 172.59,45.75 172.59,42.67 172.47,42.55 172.24,42.55 172.11,42.67 172.11,45.75 171.89,45.97 171.23,45.97 PCH1.M26 ; 174.37,45.16 v3(174.78,45.16) ; 174.37,45.16 174.37,44.68 174.47,44.58 174.47,44.28 174.37,44.18 174.37,43.87 174.56,43.69 174.77,43.69 175.05,43.96 C204.1
PCIE_TX_PCH_N1: length 13.6
  TOP w0.102: PCH1.N25 v6(170.6,45)
  BOTTOM w0.102: v2(174.27,44.6) 174.27,44.27 ; 174.27,44.27 173.26,44.27 173.16,44.37 173.16,45.91 172.91,46.15 172.52,46.15 172.27,45.91 172.27,44.37 172.17,44.27 170.52,44.27 170.3,44.49 170.3,44.7 v6(170.6,45) ; 174.27,44.27 175.22,44.27 175.46,44.03 175.46,42.69 175.22,42.44 174,42.44 C206.1
PCIE_TX_PCH_P0: length 14.2
  TOP w0.102: PCH1.M25 170.98,45.8 171.01,45.77 171.81,45.77 171.91,45.67 171.91,42.59 172.15,42.34 172.55,42.34 172.8,42.59 172.8,45.67 172.9,45.77 173.73,45.77 174.17,45.33 174.17,43.79 174.33,43.62 ; C203.1 175.05,43.1 174.66,43.48 174.47,43.48 174.33,43.62 ; 174.33,43.62 v3(174.04,43.33)
